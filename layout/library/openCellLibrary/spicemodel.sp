*
* ******************************************************************************
* *                                                                            *
* *                   Copyright (C) 2004-2009, Nangate Inc.                    *
* *                           All rights reserved.                             *
* *                                                                            *
* * Nangate and the Nangate logo are trademarks of Nangate Inc.                *
* *                                                                            *
* * All trademarks, logos, software marks, and trade names (collectively the   *
* * "Marks") in this program are proprietary to Nangate or other respective    *
* * owners that have granted Nangate the right and license to use such Marks.  *
* * You are not permitted to use the Marks without the prior written consent   *
* * of Nangate or such third party that may own the Marks.                     *
* *                                                                            *
* * This file has been provided pursuant to a License Agreement containing     *
* * restrictions on its use. This file contains valuable trade secrets and     *
* * proprietary information of Nangate Inc., and is protected by U.S. and      *
* * international laws and/or treaties.                                        *
* *                                                                            *
* * The copyright notice(s) in this file does not indicate actual or intended  *
* * publication of this file.                                                  *
* *                                                                            *
* *       NGLibraryCreator, v2009.07-HR28-2009-07-08 - build 0907160200        *
* *                                                                            *
* ******************************************************************************
*
*
*

.GLOBAL VDD
.GLOBAL VSS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X1 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 7 N_A1_M3_g N_3_M3_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g 7 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AND2_X1%VSS_c0 VSS x_PM_AND2_X1%VSS_12 4.17371e-17
C_x_PM_AND2_X1%VSS_c1 VSS N_VSS_M4_d 3.03714e-17
C_x_PM_AND2_X1%VSS_c2 VSS x_PM_AND2_X1%VSS_2 5.22182e-17
R_x_PM_AND2_X1%VSS_r3 x_PM_AND2_X1%VSS_12 x_PM_AND2_X1%VSS_6 0.145286
R_x_PM_AND2_X1%VSS_r4 N_VSS_M4_d x_PM_AND2_X1%VSS_6 0.637857
R_x_PM_AND2_X1%VSS_r5 x_PM_AND2_X1%VSS_12 x_PM_AND2_X1%VSS_2 0.0731438
R_x_PM_AND2_X1%VSS_r6 VSS x_PM_AND2_X1%VSS_2 0.145294
C_x_PM_AND2_X1%VDD_c0 VSS x_PM_AND2_X1%VDD_17 4.42784e-17
C_x_PM_AND2_X1%VDD_c1 VSS N_VDD_M1_d 2.91574e-17
C_x_PM_AND2_X1%VDD_c2 VSS x_PM_AND2_X1%VDD_8 1.23768e-17
C_x_PM_AND2_X1%VDD_c3 VSS x_PM_AND2_X1%VDD_7 3.31326e-17
C_x_PM_AND2_X1%VDD_c4 VSS N_VDD_M0_s 1.39093e-17
R_x_PM_AND2_X1%VDD_r5 x_PM_AND2_X1%VDD_17 x_PM_AND2_X1%VDD_11 0.145286
R_x_PM_AND2_X1%VDD_r6 N_VDD_M1_d x_PM_AND2_X1%VDD_11 0.393571
R_x_PM_AND2_X1%VDD_r7 VDD x_PM_AND2_X1%VDD_8 0.547647
R_x_PM_AND2_X1%VDD_r8 x_PM_AND2_X1%VDD_17 x_PM_AND2_X1%VDD_7 0.0731438
R_x_PM_AND2_X1%VDD_r9 VDD x_PM_AND2_X1%VDD_7 0.145294
R_x_PM_AND2_X1%VDD_r10 x_PM_AND2_X1%VDD_8 x_PM_AND2_X1%VDD_3 0.264221
R_x_PM_AND2_X1%VDD_r11 N_VDD_M0_s x_PM_AND2_X1%VDD_3 0.393571
C_x_PM_AND2_X1%3_c0 VSS x_PM_AND2_X1%3_29 1.52289e-17
C_x_PM_AND2_X1%3_c1 VSS x_PM_AND2_X1%3_26 1.72947e-17
C_x_PM_AND2_X1%3_c2 VSS x_PM_AND2_X1%3_23 4.99831e-17
C_x_PM_AND2_X1%3_c3 VSS N_3_M0_d 1.36112e-16
C_x_PM_AND2_X1%3_c4 VSS x_PM_AND2_X1%3_16 1.43389e-17
C_x_PM_AND2_X1%3_c5 VSS x_PM_AND2_X1%3_11 4.77021e-17
C_x_PM_AND2_X1%3_c6 VSS N_3_M2_g 9.70425e-17
C_x_PM_AND2_X1%3_c7 VSS N_3_M5_g 3.79514e-17
R_x_PM_AND2_X1%3_r8 x_PM_AND2_X1%3_29 x_PM_AND2_X1%3_27 5.46
R_x_PM_AND2_X1%3_r9 x_PM_AND2_X1%3_27 x_PM_AND2_X1%3_23 25.0012
R_x_PM_AND2_X1%3_r10 x_PM_AND2_X1%3_26 x_PM_AND2_X1%3_21 0.0418175
R_x_PM_AND2_X1%3_r11 x_PM_AND2_X1%3_23 x_PM_AND2_X1%3_21 1.045
R_x_PM_AND2_X1%3_r12 x_PM_AND2_X1%3_26 x_PM_AND2_X1%3_17 0.160909
R_x_PM_AND2_X1%3_r13 N_3_M0_d x_PM_AND2_X1%3_17 3.73214
R_x_PM_AND2_X1%3_r14 x_PM_AND2_X1%3_26 x_PM_AND2_X1%3_16 0.160909
R_x_PM_AND2_X1%3_r15 x_PM_AND2_X1%3_16 x_PM_AND2_X1%3_15 0.705714
R_x_PM_AND2_X1%3_r16 x_PM_AND2_X1%3_15 x_PM_AND2_X1%3_11 0.212317
R_x_PM_AND2_X1%3_r17 N_3_M3_s x_PM_AND2_X1%3_11 0.855
R_x_PM_AND2_X1%3_r18 x_PM_AND2_X1%3_29 x_PM_AND2_X1%3_5 1.95
R_x_PM_AND2_X1%3_r19 N_3_M2_g x_PM_AND2_X1%3_5 111.15
R_x_PM_AND2_X1%3_r20 x_PM_AND2_X1%3_29 x_PM_AND2_X1%3_VSS 1.95
R_x_PM_AND2_X1%3_r21 N_3_M5_g x_PM_AND2_X1%3_VSS 33.54
C_x_PM_AND2_X1%A1_c0 VSS x_PM_AND2_X1%A1_18 8.33317e-18
C_x_PM_AND2_X1%A1_c1 VSS x_PM_AND2_X1%A1_12 4.37038e-17
C_x_PM_AND2_X1%A1_c2 VSS N_A1_M0_g 7.49653e-17
C_x_PM_AND2_X1%A1_c3 VSS N_A1_M3_g 3.63419e-17
R_x_PM_AND2_X1%A1_r4 x_PM_AND2_X1%A1_18 x_PM_AND2_X1%A1_14 3.38
R_x_PM_AND2_X1%A1_r5 x_PM_AND2_X1%A1_14 x_PM_AND2_X1%A1_12 25.0012
R_x_PM_AND2_X1%A1_r6 x_PM_AND2_X1%A1_12 A1 0.183214
R_x_PM_AND2_X1%A1_r7 x_PM_AND2_X1%A1_18 x_PM_AND2_X1%A1_5 1.95
R_x_PM_AND2_X1%A1_r8 N_A1_M0_g x_PM_AND2_X1%A1_5 106.47
R_x_PM_AND2_X1%A1_r9 x_PM_AND2_X1%A1_18 x_PM_AND2_X1%A1_VSS 1.95
R_x_PM_AND2_X1%A1_r10 N_A1_M3_g x_PM_AND2_X1%A1_VSS 35.1
C_x_PM_AND2_X1%A2_c0 VSS A2 6.12931e-17
C_x_PM_AND2_X1%A2_c1 VSS x_PM_AND2_X1%A2_11 1.19173e-17
C_x_PM_AND2_X1%A2_c2 VSS N_A2_M1_g 6.79463e-17
C_x_PM_AND2_X1%A2_c3 VSS N_A2_M4_g 5.41996e-17
R_x_PM_AND2_X1%A2_r4 x_PM_AND2_X1%A2_11 x_PM_AND2_X1%A2_16 4.42
R_x_PM_AND2_X1%A2_r5 x_PM_AND2_X1%A2_11 x_PM_AND2_X1%A2_9 25.0012
R_x_PM_AND2_X1%A2_r6 A2 x_PM_AND2_X1%A2_9 0.128929
R_x_PM_AND2_X1%A2_r7 x_PM_AND2_X1%A2_16 x_PM_AND2_X1%A2_5 1.95
R_x_PM_AND2_X1%A2_r8 N_A2_M1_g x_PM_AND2_X1%A2_5 85.41
R_x_PM_AND2_X1%A2_r9 x_PM_AND2_X1%A2_16 x_PM_AND2_X1%A2_VSS 1.95
R_x_PM_AND2_X1%A2_r10 N_A2_M4_g x_PM_AND2_X1%A2_VSS 56.16
C_x_PM_AND2_X1%ZN_c0 VSS x_PM_AND2_X1%ZN_17 2.58882e-18
C_x_PM_AND2_X1%ZN_c1 VSS N_ZN_M5_d 4.07013e-17
C_x_PM_AND2_X1%ZN_c2 VSS x_PM_AND2_X1%ZN_12 6.53238e-17
C_x_PM_AND2_X1%ZN_c3 VSS N_ZN_M2_d 4.12794e-17
C_x_PM_AND2_X1%ZN_c4 VSS x_PM_AND2_X1%ZN_3 3.96861e-17
R_x_PM_AND2_X1%ZN_r5 x_PM_AND2_X1%ZN_17 x_PM_AND2_X1%ZN_12 0.143785
R_x_PM_AND2_X1%ZN_r6 x_PM_AND2_X1%ZN_11 N_ZN_M5_d 0.30478
R_x_PM_AND2_X1%ZN_r7 x_PM_AND2_X1%ZN_12 x_PM_AND2_X1%ZN_11 3.96286
R_x_PM_AND2_X1%ZN_r8 x_PM_AND2_X1%ZN_17 x_PM_AND2_X1%ZN_7 0.143785
R_x_PM_AND2_X1%ZN_r9 N_ZN_M2_d x_PM_AND2_X1%ZN_7 0.411667
R_x_PM_AND2_X1%ZN_r10 x_PM_AND2_X1%ZN_17 x_PM_AND2_X1%ZN_3 0.0569232
R_x_PM_AND2_X1%ZN_r11 ZN x_PM_AND2_X1%ZN_3 0.868571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X2 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 7 N_A1_M3_g N_3_M3_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g 7 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AND2_X2%VSS_c0 VSS x_PM_AND2_X2%VSS_12 3.57664e-17
C_x_PM_AND2_X2%VSS_c1 VSS N_VSS_M4_d 3.3282e-17
C_x_PM_AND2_X2%VSS_c2 VSS x_PM_AND2_X2%VSS_2 5.54251e-17
R_x_PM_AND2_X2%VSS_r3 x_PM_AND2_X2%VSS_12 x_PM_AND2_X2%VSS_6 0.145286
R_x_PM_AND2_X2%VSS_r4 N_VSS_M4_d x_PM_AND2_X2%VSS_6 0.420714
R_x_PM_AND2_X2%VSS_r5 x_PM_AND2_X2%VSS_12 x_PM_AND2_X2%VSS_2 0.0731438
R_x_PM_AND2_X2%VSS_r6 VSS x_PM_AND2_X2%VSS_2 0.0782353
C_x_PM_AND2_X2%VDD_c0 VSS x_PM_AND2_X2%VDD_17 4.42012e-17
C_x_PM_AND2_X2%VDD_c1 VSS N_VDD_M1_d 3.53236e-17
C_x_PM_AND2_X2%VDD_c2 VSS x_PM_AND2_X2%VDD_8 1.07001e-17
C_x_PM_AND2_X2%VDD_c3 VSS x_PM_AND2_X2%VDD_7 3.2606e-17
C_x_PM_AND2_X2%VDD_c4 VSS N_VDD_M0_s 1.42739e-17
R_x_PM_AND2_X2%VDD_r5 x_PM_AND2_X2%VDD_17 x_PM_AND2_X2%VDD_11 0.145286
R_x_PM_AND2_X2%VDD_r6 N_VDD_M1_d x_PM_AND2_X2%VDD_11 0.420714
R_x_PM_AND2_X2%VDD_r7 VDD x_PM_AND2_X2%VDD_8 0.603529
R_x_PM_AND2_X2%VDD_r8 x_PM_AND2_X2%VDD_17 x_PM_AND2_X2%VDD_7 0.0731438
R_x_PM_AND2_X2%VDD_r9 VDD x_PM_AND2_X2%VDD_7 0.0894118
R_x_PM_AND2_X2%VDD_r10 x_PM_AND2_X2%VDD_8 x_PM_AND2_X2%VDD_3 0.264221
R_x_PM_AND2_X2%VDD_r11 N_VDD_M0_s x_PM_AND2_X2%VDD_3 0.420714
C_x_PM_AND2_X2%3_c0 VSS x_PM_AND2_X2%3_33 1.13133e-17
C_x_PM_AND2_X2%3_c1 VSS x_PM_AND2_X2%3_30 1.00152e-17
C_x_PM_AND2_X2%3_c2 VSS x_PM_AND2_X2%3_29 9.34287e-17
C_x_PM_AND2_X2%3_c3 VSS x_PM_AND2_X2%3_26 1.87365e-17
C_x_PM_AND2_X2%3_c4 VSS x_PM_AND2_X2%3_22 8.60574e-18
C_x_PM_AND2_X2%3_c5 VSS x_PM_AND2_X2%3_21 4.03179e-17
C_x_PM_AND2_X2%3_c6 VSS N_3_M0_d 3.31237e-17
C_x_PM_AND2_X2%3_c7 VSS x_PM_AND2_X2%3_16 5.73522e-18
C_x_PM_AND2_X2%3_c8 VSS x_PM_AND2_X2%3_15 6.02033e-17
C_x_PM_AND2_X2%3_c9 VSS N_3_M3_s 2.55776e-17
C_x_PM_AND2_X2%3_c10 VSS N_3_M2_g 9.71074e-17
C_x_PM_AND2_X2%3_c11 VSS N_3_M5_g 3.53623e-17
R_x_PM_AND2_X2%3_r12 x_PM_AND2_X2%3_33 x_PM_AND2_X2%3_31 3.38
R_x_PM_AND2_X2%3_r13 x_PM_AND2_X2%3_29 x_PM_AND2_X2%3_30 2.93143
R_x_PM_AND2_X2%3_r14 x_PM_AND2_X2%3_31 x_PM_AND2_X2%3_26 25.0012
R_x_PM_AND2_X2%3_r15 x_PM_AND2_X2%3_30 x_PM_AND2_X2%3_24 0.232321
R_x_PM_AND2_X2%3_r16 x_PM_AND2_X2%3_26 x_PM_AND2_X2%3_24 0.0542857
R_x_PM_AND2_X2%3_r17 x_PM_AND2_X2%3_26 x_PM_AND2_X2%3_23 0.22619
R_x_PM_AND2_X2%3_r18 x_PM_AND2_X2%3_29 x_PM_AND2_X2%3_21 0.212317
R_x_PM_AND2_X2%3_r19 x_PM_AND2_X2%3_22 x_PM_AND2_X2%3_21 0.76
R_x_PM_AND2_X2%3_r20 x_PM_AND2_X2%3_22 x_PM_AND2_X2%3_17 0.212317
R_x_PM_AND2_X2%3_r21 N_3_M0_d x_PM_AND2_X2%3_17 0.393571
R_x_PM_AND2_X2%3_r22 x_PM_AND2_X2%3_23 x_PM_AND2_X2%3_15 0.223553
R_x_PM_AND2_X2%3_r23 x_PM_AND2_X2%3_16 x_PM_AND2_X2%3_15 1.79143
R_x_PM_AND2_X2%3_r24 x_PM_AND2_X2%3_16 x_PM_AND2_X2%3_11 0.212317
R_x_PM_AND2_X2%3_r25 N_3_M3_s x_PM_AND2_X2%3_11 0.420714
R_x_PM_AND2_X2%3_r26 x_PM_AND2_X2%3_33 x_PM_AND2_X2%3_5 1.95
R_x_PM_AND2_X2%3_r27 N_3_M2_g x_PM_AND2_X2%3_5 105.3
R_x_PM_AND2_X2%3_r28 x_PM_AND2_X2%3_33 x_PM_AND2_X2%3_VSS 1.95
R_x_PM_AND2_X2%3_r29 N_3_M5_g x_PM_AND2_X2%3_VSS 27.3
C_x_PM_AND2_X2%A1_c0 VSS x_PM_AND2_X2%A1_13 7.02743e-18
C_x_PM_AND2_X2%A1_c1 VSS A1 1.56682e-17
C_x_PM_AND2_X2%A1_c2 VSS N_A1_M0_g 6.18939e-17
C_x_PM_AND2_X2%A1_c3 VSS N_A1_M3_g 5.49708e-17
R_x_PM_AND2_X2%A1_r4 x_PM_AND2_X2%A1_16 x_PM_AND2_X2%A1_13 4.74714
R_x_PM_AND2_X2%A1_r5 x_PM_AND2_X2%A1_15 x_PM_AND2_X2%A1_13 4.74714
R_x_PM_AND2_X2%A1_r6 x_PM_AND2_X2%A1_13 x_PM_AND2_X2%A1_11 25.0012
R_x_PM_AND2_X2%A1_r7 x_PM_AND2_X2%A1_11 A1 0.158563
R_x_PM_AND2_X2%A1_r8 N_A1_M0_g x_PM_AND2_X2%A1_16 83.85
R_x_PM_AND2_X2%A1_r9 N_A1_M3_g x_PM_AND2_X2%A1_15 63.18
C_x_PM_AND2_X2%A2_c0 VSS x_PM_AND2_X2%A2_14 8.64377e-18
C_x_PM_AND2_X2%A2_c1 VSS x_PM_AND2_X2%A2_12 4.37781e-17
C_x_PM_AND2_X2%A2_c2 VSS N_A2_M1_g 5.57959e-17
C_x_PM_AND2_X2%A2_c3 VSS N_A2_M4_g 7.00537e-17
R_x_PM_AND2_X2%A2_r4 x_PM_AND2_X2%A2_18 x_PM_AND2_X2%A2_14 4.7687
R_x_PM_AND2_X2%A2_r5 x_PM_AND2_X2%A2_17 x_PM_AND2_X2%A2_14 4.7687
R_x_PM_AND2_X2%A2_r6 x_PM_AND2_X2%A2_14 x_PM_AND2_X2%A2_12 25.0012
R_x_PM_AND2_X2%A2_r7 x_PM_AND2_X2%A2_12 A2 0.169643
R_x_PM_AND2_X2%A2_r8 N_A2_M1_g x_PM_AND2_X2%A2_18 62.01
R_x_PM_AND2_X2%A2_r9 N_A2_M4_g x_PM_AND2_X2%A2_17 85.02
C_x_PM_AND2_X2%ZN_c0 VSS N_ZN_M5_d 2.60988e-17
C_x_PM_AND2_X2%ZN_c1 VSS ZN 7.63258e-17
C_x_PM_AND2_X2%ZN_c2 VSS N_ZN_M2_d 5.16564e-17
C_x_PM_AND2_X2%ZN_c3 VSS x_PM_AND2_X2%ZN_3 6.61381e-18
R_x_PM_AND2_X2%ZN_r4 ZN x_PM_AND2_X2%ZN_8 1.87286
R_x_PM_AND2_X2%ZN_r5 x_PM_AND2_X2%ZN_7 N_ZN_M5_d 0.30478
R_x_PM_AND2_X2%ZN_r6 ZN x_PM_AND2_X2%ZN_7 1.60143
R_x_PM_AND2_X2%ZN_r7 x_PM_AND2_X2%ZN_8 x_PM_AND2_X2%ZN_3 0.20978
R_x_PM_AND2_X2%ZN_r8 N_ZN_M2_d x_PM_AND2_X2%ZN_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND2_X4 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 7 N_A1_M3_g N_3_M3_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g 7 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_AND2_X4%VSS_c0 VSS x_PM_AND2_X4%VSS_11 3.39882e-17
C_x_PM_AND2_X4%VSS_c1 VSS N_VSS_M4_d 2.83899e-17
C_x_PM_AND2_X4%VSS_c2 VSS x_PM_AND2_X4%VSS_2 7.24859e-17
R_x_PM_AND2_X4%VSS_r3 x_PM_AND2_X4%VSS_11 x_PM_AND2_X4%VSS_5 0.145286
R_x_PM_AND2_X4%VSS_r4 N_VSS_M4_d x_PM_AND2_X4%VSS_5 0.230714
R_x_PM_AND2_X4%VSS_r5 x_PM_AND2_X4%VSS_11 x_PM_AND2_X4%VSS_2 0.0731438
R_x_PM_AND2_X4%VSS_r6 VSS x_PM_AND2_X4%VSS_2 0.134118
C_x_PM_AND2_X4%VDD_c0 VSS x_PM_AND2_X4%VDD_17 2.86812e-17
C_x_PM_AND2_X4%VDD_c1 VSS N_VDD_M1_d 3.31862e-17
C_x_PM_AND2_X4%VDD_c2 VSS x_PM_AND2_X4%VDD_8 1.23932e-17
C_x_PM_AND2_X4%VDD_c3 VSS x_PM_AND2_X4%VDD_7 3.38633e-17
C_x_PM_AND2_X4%VDD_c4 VSS N_VDD_M0_s 1.45571e-17
R_x_PM_AND2_X4%VDD_r5 x_PM_AND2_X4%VDD_17 x_PM_AND2_X4%VDD_11 0.145286
R_x_PM_AND2_X4%VDD_r6 N_VDD_M1_d x_PM_AND2_X4%VDD_11 0.393571
R_x_PM_AND2_X4%VDD_r7 VDD x_PM_AND2_X4%VDD_8 0.547647
R_x_PM_AND2_X4%VDD_r8 x_PM_AND2_X4%VDD_17 x_PM_AND2_X4%VDD_7 0.0731438
R_x_PM_AND2_X4%VDD_r9 VDD x_PM_AND2_X4%VDD_7 0.134118
R_x_PM_AND2_X4%VDD_r10 x_PM_AND2_X4%VDD_8 x_PM_AND2_X4%VDD_3 0.264221
R_x_PM_AND2_X4%VDD_r11 N_VDD_M0_s x_PM_AND2_X4%VDD_3 0.393571
C_x_PM_AND2_X4%3_c0 VSS x_PM_AND2_X4%3_31 1.26773e-17
C_x_PM_AND2_X4%3_c1 VSS N_3_M3_s 4.5134e-17
C_x_PM_AND2_X4%3_c2 VSS x_PM_AND2_X4%3_22 1.59854e-16
C_x_PM_AND2_X4%3_c3 VSS x_PM_AND2_X4%3_18 9.17733e-18
C_x_PM_AND2_X4%3_c4 VSS x_PM_AND2_X4%3_17 3.0001e-17
C_x_PM_AND2_X4%3_c5 VSS N_3_M0_d 3.58392e-17
C_x_PM_AND2_X4%3_c6 VSS x_PM_AND2_X4%3_11 6.54271e-17
C_x_PM_AND2_X4%3_c7 VSS N_3_M2_g 7.41672e-17
C_x_PM_AND2_X4%3_c8 VSS N_3_M5_g 4.9499e-17
R_x_PM_AND2_X4%3_r9 x_PM_AND2_X4%3_31 x_PM_AND2_X4%3_29 4.42
R_x_PM_AND2_X4%3_r10 x_PM_AND2_X4%3_27 N_3_M3_s 0.316667
R_x_PM_AND2_X4%3_r11 x_PM_AND2_X4%3_29 x_PM_AND2_X4%3_22 25.0012
R_x_PM_AND2_X4%3_r12 x_PM_AND2_X4%3_22 x_PM_AND2_X4%3_20 2.72786
R_x_PM_AND2_X4%3_r13 x_PM_AND2_X4%3_22 x_PM_AND2_X4%3_19 1.12643
R_x_PM_AND2_X4%3_r14 x_PM_AND2_X4%3_20 x_PM_AND2_X4%3_17 0.212317
R_x_PM_AND2_X4%3_r15 x_PM_AND2_X4%3_18 x_PM_AND2_X4%3_17 0.895714
R_x_PM_AND2_X4%3_r16 x_PM_AND2_X4%3_18 x_PM_AND2_X4%3_13 0.212317
R_x_PM_AND2_X4%3_r17 N_3_M0_d x_PM_AND2_X4%3_13 0.393571
R_x_PM_AND2_X4%3_r18 x_PM_AND2_X4%3_27 x_PM_AND2_X4%3_12 0.095
R_x_PM_AND2_X4%3_r19 x_PM_AND2_X4%3_19 x_PM_AND2_X4%3_11 0.212317
R_x_PM_AND2_X4%3_r20 x_PM_AND2_X4%3_12 x_PM_AND2_X4%3_11 1.76429
R_x_PM_AND2_X4%3_r21 x_PM_AND2_X4%3_31 x_PM_AND2_X4%3_5 1.95
R_x_PM_AND2_X4%3_r22 N_3_M2_g x_PM_AND2_X4%3_5 67.86
R_x_PM_AND2_X4%3_r23 x_PM_AND2_X4%3_31 x_PM_AND2_X4%3_VSS 1.95
R_x_PM_AND2_X4%3_r24 N_3_M5_g x_PM_AND2_X4%3_VSS 35.88
C_x_PM_AND2_X4%A1_c0 VSS x_PM_AND2_X4%A1_20 9.07713e-18
C_x_PM_AND2_X4%A1_c1 VSS A1 4.61513e-17
C_x_PM_AND2_X4%A1_c2 VSS N_A1_M0_g 5.04244e-17
C_x_PM_AND2_X4%A1_c3 VSS N_A1_M3_g 6.821e-17
R_x_PM_AND2_X4%A1_r4 x_PM_AND2_X4%A1_20 x_PM_AND2_X4%A1_16 4.42
R_x_PM_AND2_X4%A1_r5 x_PM_AND2_X4%A1_16 x_PM_AND2_X4%A1_14 25.0012
R_x_PM_AND2_X4%A1_r6 x_PM_AND2_X4%A1_14 A1 0.0076
R_x_PM_AND2_X4%A1_r7 x_PM_AND2_X4%A1_20 x_PM_AND2_X4%A1_5 1.95
R_x_PM_AND2_X4%A1_r8 N_A1_M0_g x_PM_AND2_X4%A1_5 62.79
R_x_PM_AND2_X4%A1_r9 x_PM_AND2_X4%A1_20 x_PM_AND2_X4%A1_VSS 1.95
R_x_PM_AND2_X4%A1_r10 N_A1_M3_g x_PM_AND2_X4%A1_VSS 90.48
C_x_PM_AND2_X4%A2_c0 VSS x_PM_AND2_X4%A2_18 8.4484e-18
C_x_PM_AND2_X4%A2_c1 VSS x_PM_AND2_X4%A2_12 7.08081e-17
C_x_PM_AND2_X4%A2_c2 VSS N_A2_M1_g 5.51859e-17
C_x_PM_AND2_X4%A2_c3 VSS N_A2_M4_g 7.17971e-17
R_x_PM_AND2_X4%A2_r4 x_PM_AND2_X4%A2_18 x_PM_AND2_X4%A2_14 2.34
R_x_PM_AND2_X4%A2_r5 x_PM_AND2_X4%A2_14 x_PM_AND2_X4%A2_12 25.0012
R_x_PM_AND2_X4%A2_r6 x_PM_AND2_X4%A2_12 A2 0.210357
R_x_PM_AND2_X4%A2_r7 x_PM_AND2_X4%A2_18 x_PM_AND2_X4%A2_5 1.95
R_x_PM_AND2_X4%A2_r8 N_A2_M1_g x_PM_AND2_X4%A2_5 63.57
R_x_PM_AND2_X4%A2_r9 x_PM_AND2_X4%A2_18 x_PM_AND2_X4%A2_VSS 1.95
R_x_PM_AND2_X4%A2_r10 N_A2_M4_g x_PM_AND2_X4%A2_VSS 89.7
C_x_PM_AND2_X4%ZN_c0 VSS N_ZN_M5_d 1.57206e-16
R_x_PM_AND2_X4%ZN_r1 N_ZN_M2_d ZN 1.56071
R_x_PM_AND2_X4%ZN_r2 ZN N_ZN_M5_d 1.18071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X1 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 N_VDD_M0_d N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_3_M1_d N_A2_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g N_3_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 8 N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 9 N_A2_M5_g 8 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g 9 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AND3_X1%VSS_c0 VSS x_PM_AND3_X1%VSS_12 4.45502e-17
C_x_PM_AND3_X1%VSS_c1 VSS N_VSS_M6_d 3.72857e-17
C_x_PM_AND3_X1%VSS_c2 VSS x_PM_AND3_X1%VSS_2 5.95146e-17
R_x_PM_AND3_X1%VSS_r3 x_PM_AND3_X1%VSS_12 x_PM_AND3_X1%VSS_6 0.145286
R_x_PM_AND3_X1%VSS_r4 N_VSS_M6_d x_PM_AND3_X1%VSS_6 0.637857
R_x_PM_AND3_X1%VSS_r5 x_PM_AND3_X1%VSS_12 x_PM_AND3_X1%VSS_2 0.0731438
R_x_PM_AND3_X1%VSS_r6 VSS x_PM_AND3_X1%VSS_2 0.290588
C_x_PM_AND3_X1%VDD_c0 VSS x_PM_AND3_X1%VDD_20 4.54133e-17
C_x_PM_AND3_X1%VDD_c1 VSS x_PM_AND3_X1%VDD_19 3.84167e-17
C_x_PM_AND3_X1%VDD_c2 VSS N_VDD_M2_d 3.41527e-17
C_x_PM_AND3_X1%VDD_c3 VSS x_PM_AND3_X1%VDD_9 3.43883e-17
C_x_PM_AND3_X1%VDD_c4 VSS N_VDD_M0_d 3.50563e-17
R_x_PM_AND3_X1%VDD_r5 x_PM_AND3_X1%VDD_20 x_PM_AND3_X1%VDD_13 0.145286
R_x_PM_AND3_X1%VDD_r6 N_VDD_M2_d x_PM_AND3_X1%VDD_13 0.393571
R_x_PM_AND3_X1%VDD_r7 x_PM_AND3_X1%VDD_19 x_PM_AND3_X1%VDD_10 0.0731438
R_x_PM_AND3_X1%VDD_r8 VDD x_PM_AND3_X1%VDD_10 0.402353
R_x_PM_AND3_X1%VDD_r9 x_PM_AND3_X1%VDD_20 x_PM_AND3_X1%VDD_9 0.0731438
R_x_PM_AND3_X1%VDD_r10 VDD x_PM_AND3_X1%VDD_9 0.290588
R_x_PM_AND3_X1%VDD_r11 x_PM_AND3_X1%VDD_19 x_PM_AND3_X1%VDD_5 0.145286
R_x_PM_AND3_X1%VDD_r12 N_VDD_M0_d x_PM_AND3_X1%VDD_5 0.393571
C_x_PM_AND3_X1%3_c0 VSS x_PM_AND3_X1%3_39 9.85974e-18
C_x_PM_AND3_X1%3_c1 VSS x_PM_AND3_X1%3_33 5.01915e-17
C_x_PM_AND3_X1%3_c2 VSS x_PM_AND3_X1%3_32 2.98652e-18
C_x_PM_AND3_X1%3_c3 VSS x_PM_AND3_X1%3_31 1.00567e-16
C_x_PM_AND3_X1%3_c4 VSS x_PM_AND3_X1%3_28 4.29924e-17
C_x_PM_AND3_X1%3_c5 VSS N_3_M1_d 3.2129e-17
C_x_PM_AND3_X1%3_c6 VSS x_PM_AND3_X1%3_23 4.51272e-18
C_x_PM_AND3_X1%3_c7 VSS x_PM_AND3_X1%3_22 3.45092e-17
C_x_PM_AND3_X1%3_c8 VSS x_PM_AND3_X1%3_21 9.72919e-18
C_x_PM_AND3_X1%3_c9 VSS x_PM_AND3_X1%3_20 7.16528e-17
C_x_PM_AND3_X1%3_c10 VSS N_3_M0_s 2.73556e-17
C_x_PM_AND3_X1%3_c11 VSS N_3_M4_s 1.41491e-17
C_x_PM_AND3_X1%3_c12 VSS N_3_M3_g 9.4546e-17
C_x_PM_AND3_X1%3_c13 VSS N_3_M7_g 3.15868e-17
R_x_PM_AND3_X1%3_r14 x_PM_AND3_X1%3_41 x_PM_AND3_X1%3_39 4.74714
R_x_PM_AND3_X1%3_r15 x_PM_AND3_X1%3_38 x_PM_AND3_X1%3_36 0.297071
R_x_PM_AND3_X1%3_r16 x_PM_AND3_X1%3_39 x_PM_AND3_X1%3_36 25.0012
R_x_PM_AND3_X1%3_r17 x_PM_AND3_X1%3_36 x_PM_AND3_X1%3_33 0.13
R_x_PM_AND3_X1%3_r18 x_PM_AND3_X1%3_31 x_PM_AND3_X1%3_38 3.06714
R_x_PM_AND3_X1%3_r19 x_PM_AND3_X1%3_32 x_PM_AND3_X1%3_29 0.160909
R_x_PM_AND3_X1%3_r20 x_PM_AND3_X1%3_31 x_PM_AND3_X1%3_28 0.212317
R_x_PM_AND3_X1%3_r21 x_PM_AND3_X1%3_29 x_PM_AND3_X1%3_28 0.95
R_x_PM_AND3_X1%3_r22 x_PM_AND3_X1%3_32 x_PM_AND3_X1%3_24 0.0418175
R_x_PM_AND3_X1%3_r23 N_3_M1_d x_PM_AND3_X1%3_24 0.393571
R_x_PM_AND3_X1%3_r24 x_PM_AND3_X1%3_32 x_PM_AND3_X1%3_22 0.160909
R_x_PM_AND3_X1%3_r25 x_PM_AND3_X1%3_23 x_PM_AND3_X1%3_22 1.62857
R_x_PM_AND3_X1%3_r26 x_PM_AND3_X1%3_33 x_PM_AND3_X1%3_20 0.095
R_x_PM_AND3_X1%3_r27 x_PM_AND3_X1%3_21 x_PM_AND3_X1%3_20 2.98571
R_x_PM_AND3_X1%3_r28 x_PM_AND3_X1%3_23 x_PM_AND3_X1%3_16 0.212317
R_x_PM_AND3_X1%3_r29 N_3_M0_s x_PM_AND3_X1%3_16 0.393571
R_x_PM_AND3_X1%3_r30 x_PM_AND3_X1%3_21 x_PM_AND3_X1%3_12 0.212696
R_x_PM_AND3_X1%3_r31 N_3_M4_s x_PM_AND3_X1%3_12 0.306923
R_x_PM_AND3_X1%3_r32 N_3_M3_g x_PM_AND3_X1%3_41 119.73
R_x_PM_AND3_X1%3_r33 x_PM_AND3_X1%3_VSS x_PM_AND3_X1%3_39 4.74714
R_x_PM_AND3_X1%3_r34 N_3_M7_g x_PM_AND3_X1%3_VSS 24.96
C_x_PM_AND3_X1%A1_c0 VSS x_PM_AND3_X1%A1_13 7.31746e-18
C_x_PM_AND3_X1%A1_c1 VSS A1 5.9207e-17
C_x_PM_AND3_X1%A1_c2 VSS N_A1_M0_g 7.1909e-17
C_x_PM_AND3_X1%A1_c3 VSS N_A1_M4_g 4.46873e-17
R_x_PM_AND3_X1%A1_r4 x_PM_AND3_X1%A1_16 x_PM_AND3_X1%A1_13 4.7687
R_x_PM_AND3_X1%A1_r5 x_PM_AND3_X1%A1_15 x_PM_AND3_X1%A1_13 4.7687
R_x_PM_AND3_X1%A1_r6 x_PM_AND3_X1%A1_13 x_PM_AND3_X1%A1_11 25.0012
R_x_PM_AND3_X1%A1_r7 x_PM_AND3_X1%A1_11 A1 0.19958
R_x_PM_AND3_X1%A1_r8 N_A1_M0_g x_PM_AND3_X1%A1_16 95.55
R_x_PM_AND3_X1%A1_r9 N_A1_M4_g x_PM_AND3_X1%A1_15 42.9
C_x_PM_AND3_X1%A2_c0 VSS x_PM_AND3_X1%A2_19 8.9662e-18
C_x_PM_AND3_X1%A2_c1 VSS x_PM_AND3_X1%A2_17 4.43782e-17
C_x_PM_AND3_X1%A2_c2 VSS x_PM_AND3_X1%A2_13 4.24922e-18
C_x_PM_AND3_X1%A2_c3 VSS A2 2.95928e-17
C_x_PM_AND3_X1%A2_c4 VSS N_A2_M1_g 7.14557e-17
C_x_PM_AND3_X1%A2_c5 VSS N_A2_M5_g 4.64569e-17
R_x_PM_AND3_X1%A2_r6 x_PM_AND3_X1%A2_23 x_PM_AND3_X1%A2_19 4.7687
R_x_PM_AND3_X1%A2_r7 x_PM_AND3_X1%A2_22 x_PM_AND3_X1%A2_19 4.7687
R_x_PM_AND3_X1%A2_r8 x_PM_AND3_X1%A2_19 x_PM_AND3_X1%A2_17 25.0012
R_x_PM_AND3_X1%A2_r9 x_PM_AND3_X1%A2_17 x_PM_AND3_X1%A2_15 0.161852
R_x_PM_AND3_X1%A2_r10 x_PM_AND3_X1%A2_13 A2 0.30063
R_x_PM_AND3_X1%A2_r11 x_PM_AND3_X1%A2_15 x_PM_AND3_X1%A2_9 0.095
R_x_PM_AND3_X1%A2_r12 x_PM_AND3_X1%A2_13 x_PM_AND3_X1%A2_9 0.298571
R_x_PM_AND3_X1%A2_r13 N_A2_M1_g x_PM_AND3_X1%A2_23 93.21
R_x_PM_AND3_X1%A2_r14 N_A2_M5_g x_PM_AND3_X1%A2_22 45.24
C_x_PM_AND3_X1%A3_c0 VSS x_PM_AND3_X1%A3_14 8.52877e-18
C_x_PM_AND3_X1%A3_c1 VSS x_PM_AND3_X1%A3_12 5.72795e-17
C_x_PM_AND3_X1%A3_c2 VSS N_A3_M2_g 5.53287e-17
C_x_PM_AND3_X1%A3_c3 VSS N_A3_M6_g 6.46958e-17
R_x_PM_AND3_X1%A3_r4 x_PM_AND3_X1%A3_18 x_PM_AND3_X1%A3_14 4.7687
R_x_PM_AND3_X1%A3_r5 x_PM_AND3_X1%A3_17 x_PM_AND3_X1%A3_14 4.7687
R_x_PM_AND3_X1%A3_r6 x_PM_AND3_X1%A3_14 x_PM_AND3_X1%A3_12 25.0012
R_x_PM_AND3_X1%A3_r7 x_PM_AND3_X1%A3_12 A3 0.2375
R_x_PM_AND3_X1%A3_r8 N_A3_M2_g x_PM_AND3_X1%A3_18 63.57
R_x_PM_AND3_X1%A3_r9 N_A3_M6_g x_PM_AND3_X1%A3_17 74.88
C_x_PM_AND3_X1%ZN_c0 VSS N_ZN_M3_d 3.85768e-17
C_x_PM_AND3_X1%ZN_c1 VSS N_ZN_M7_d 4.02924e-17
C_x_PM_AND3_X1%ZN_c2 VSS ZN 1.1788e-16
R_x_PM_AND3_X1%ZN_r3 x_PM_AND3_X1%ZN_4 N_ZN_M3_d 0.30478
R_x_PM_AND3_X1%ZN_r4 ZN x_PM_AND3_X1%ZN_4 2.63286
R_x_PM_AND3_X1%ZN_r5 x_PM_AND3_X1%ZN_3 N_ZN_M7_d 0.30478
R_x_PM_AND3_X1%ZN_r6 ZN x_PM_AND3_X1%ZN_3 1.87286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X2 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 N_VDD_M0_d N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_3_M1_d N_A2_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g N_3_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 8 N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 9 N_A2_M5_g 8 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g 9 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AND3_X2%VSS_c0 VSS x_PM_AND3_X2%VSS_12 4.21405e-17
C_x_PM_AND3_X2%VSS_c1 VSS N_VSS_M6_d 2.36734e-17
C_x_PM_AND3_X2%VSS_c2 VSS x_PM_AND3_X2%VSS_2 7.71966e-17
R_x_PM_AND3_X2%VSS_r3 x_PM_AND3_X2%VSS_12 x_PM_AND3_X2%VSS_6 0.145286
R_x_PM_AND3_X2%VSS_r4 N_VSS_M6_d x_PM_AND3_X2%VSS_6 0.230714
R_x_PM_AND3_X2%VSS_r5 x_PM_AND3_X2%VSS_12 x_PM_AND3_X2%VSS_2 0.0731438
R_x_PM_AND3_X2%VSS_r6 VSS x_PM_AND3_X2%VSS_2 0.290588
C_x_PM_AND3_X2%VDD_c0 VSS x_PM_AND3_X2%VDD_20 4.53039e-17
C_x_PM_AND3_X2%VDD_c1 VSS x_PM_AND3_X2%VDD_19 3.68815e-17
C_x_PM_AND3_X2%VDD_c2 VSS N_VDD_M2_d 3.50284e-17
C_x_PM_AND3_X2%VDD_c3 VSS x_PM_AND3_X2%VDD_9 3.25732e-17
C_x_PM_AND3_X2%VDD_c4 VSS N_VDD_M0_d 3.52926e-17
R_x_PM_AND3_X2%VDD_r5 x_PM_AND3_X2%VDD_20 x_PM_AND3_X2%VDD_13 0.145286
R_x_PM_AND3_X2%VDD_r6 N_VDD_M2_d x_PM_AND3_X2%VDD_13 0.420714
R_x_PM_AND3_X2%VDD_r7 x_PM_AND3_X2%VDD_19 x_PM_AND3_X2%VDD_10 0.0731438
R_x_PM_AND3_X2%VDD_r8 VDD x_PM_AND3_X2%VDD_10 0.402353
R_x_PM_AND3_X2%VDD_r9 x_PM_AND3_X2%VDD_20 x_PM_AND3_X2%VDD_9 0.0731438
R_x_PM_AND3_X2%VDD_r10 VDD x_PM_AND3_X2%VDD_9 0.290588
R_x_PM_AND3_X2%VDD_r11 x_PM_AND3_X2%VDD_19 x_PM_AND3_X2%VDD_5 0.145286
R_x_PM_AND3_X2%VDD_r12 N_VDD_M0_d x_PM_AND3_X2%VDD_5 0.420714
C_x_PM_AND3_X2%3_c0 VSS x_PM_AND3_X2%3_44 1.14374e-17
C_x_PM_AND3_X2%3_c1 VSS x_PM_AND3_X2%3_41 1.04375e-17
C_x_PM_AND3_X2%3_c2 VSS x_PM_AND3_X2%3_40 3.30128e-17
C_x_PM_AND3_X2%3_c3 VSS x_PM_AND3_X2%3_39 3.47774e-18
C_x_PM_AND3_X2%3_c4 VSS x_PM_AND3_X2%3_38 7.12662e-17
C_x_PM_AND3_X2%3_c5 VSS x_PM_AND3_X2%3_35 9.3384e-18
C_x_PM_AND3_X2%3_c6 VSS x_PM_AND3_X2%3_32 6.87787e-18
C_x_PM_AND3_X2%3_c7 VSS x_PM_AND3_X2%3_28 4.77545e-17
C_x_PM_AND3_X2%3_c8 VSS N_3_M1_d 3.07979e-17
C_x_PM_AND3_X2%3_c9 VSS x_PM_AND3_X2%3_23 4.21984e-18
C_x_PM_AND3_X2%3_c10 VSS x_PM_AND3_X2%3_22 3.23292e-17
C_x_PM_AND3_X2%3_c11 VSS x_PM_AND3_X2%3_21 1.39555e-17
C_x_PM_AND3_X2%3_c12 VSS x_PM_AND3_X2%3_20 1.02137e-16
C_x_PM_AND3_X2%3_c13 VSS N_3_M0_s 2.59812e-17
C_x_PM_AND3_X2%3_c14 VSS N_3_M4_s 2.29228e-17
C_x_PM_AND3_X2%3_c15 VSS N_3_M3_g 7.13801e-17
C_x_PM_AND3_X2%3_c16 VSS N_3_M7_g 6.00305e-17
R_x_PM_AND3_X2%3_r17 x_PM_AND3_X2%3_44 x_PM_AND3_X2%3_42 3.38
R_x_PM_AND3_X2%3_r18 x_PM_AND3_X2%3_38 x_PM_AND3_X2%3_41 1.81857
R_x_PM_AND3_X2%3_r19 x_PM_AND3_X2%3_42 x_PM_AND3_X2%3_35 25.0012
R_x_PM_AND3_X2%3_r20 x_PM_AND3_X2%3_41 x_PM_AND3_X2%3_33 0.196927
R_x_PM_AND3_X2%3_r21 x_PM_AND3_X2%3_35 x_PM_AND3_X2%3_33 0.130625
R_x_PM_AND3_X2%3_r22 x_PM_AND3_X2%3_40 x_PM_AND3_X2%3_32 0.196927
R_x_PM_AND3_X2%3_r23 x_PM_AND3_X2%3_35 x_PM_AND3_X2%3_32 0.130625
R_x_PM_AND3_X2%3_r24 x_PM_AND3_X2%3_40 x_PM_AND3_X2%3_30 1.14
R_x_PM_AND3_X2%3_r25 x_PM_AND3_X2%3_39 x_PM_AND3_X2%3_29 0.160909
R_x_PM_AND3_X2%3_r26 x_PM_AND3_X2%3_38 x_PM_AND3_X2%3_28 0.212317
R_x_PM_AND3_X2%3_r27 x_PM_AND3_X2%3_29 x_PM_AND3_X2%3_28 0.922857
R_x_PM_AND3_X2%3_r28 x_PM_AND3_X2%3_39 x_PM_AND3_X2%3_24 0.0418175
R_x_PM_AND3_X2%3_r29 N_3_M1_d x_PM_AND3_X2%3_24 0.393571
R_x_PM_AND3_X2%3_r30 x_PM_AND3_X2%3_39 x_PM_AND3_X2%3_22 0.160909
R_x_PM_AND3_X2%3_r31 x_PM_AND3_X2%3_23 x_PM_AND3_X2%3_22 1.65571
R_x_PM_AND3_X2%3_r32 x_PM_AND3_X2%3_30 x_PM_AND3_X2%3_20 0.212317
R_x_PM_AND3_X2%3_r33 x_PM_AND3_X2%3_21 x_PM_AND3_X2%3_20 2.95857
R_x_PM_AND3_X2%3_r34 x_PM_AND3_X2%3_23 x_PM_AND3_X2%3_16 0.212317
R_x_PM_AND3_X2%3_r35 N_3_M0_s x_PM_AND3_X2%3_16 0.393571
R_x_PM_AND3_X2%3_r36 x_PM_AND3_X2%3_21 x_PM_AND3_X2%3_12 0.212317
R_x_PM_AND3_X2%3_r37 N_3_M4_s x_PM_AND3_X2%3_12 0.339286
R_x_PM_AND3_X2%3_r38 x_PM_AND3_X2%3_44 x_PM_AND3_X2%3_5 1.95
R_x_PM_AND3_X2%3_r39 N_3_M3_g x_PM_AND3_X2%3_5 73.32
R_x_PM_AND3_X2%3_r40 x_PM_AND3_X2%3_44 x_PM_AND3_X2%3_VSS 1.95
R_x_PM_AND3_X2%3_r41 N_3_M7_g x_PM_AND3_X2%3_VSS 64.74
C_x_PM_AND3_X2%A1_c0 VSS x_PM_AND3_X2%A1_14 7.47882e-18
C_x_PM_AND3_X2%A1_c1 VSS x_PM_AND3_X2%A1_12 5.57778e-17
C_x_PM_AND3_X2%A1_c2 VSS N_A1_M0_g 7.76e-17
C_x_PM_AND3_X2%A1_c3 VSS N_A1_M4_g 4.58756e-17
R_x_PM_AND3_X2%A1_r4 x_PM_AND3_X2%A1_18 x_PM_AND3_X2%A1_14 4.74714
R_x_PM_AND3_X2%A1_r5 x_PM_AND3_X2%A1_17 x_PM_AND3_X2%A1_14 4.74714
R_x_PM_AND3_X2%A1_r6 x_PM_AND3_X2%A1_14 x_PM_AND3_X2%A1_12 25.0012
R_x_PM_AND3_X2%A1_r7 x_PM_AND3_X2%A1_12 A1 0.156071
R_x_PM_AND3_X2%A1_r8 N_A1_M0_g x_PM_AND3_X2%A1_18 106.47
R_x_PM_AND3_X2%A1_r9 N_A1_M4_g x_PM_AND3_X2%A1_17 42.9
C_x_PM_AND3_X2%A2_c0 VSS x_PM_AND3_X2%A2_14 8.59743e-18
C_x_PM_AND3_X2%A2_c1 VSS x_PM_AND3_X2%A2_12 5.83497e-17
C_x_PM_AND3_X2%A2_c2 VSS N_A2_M1_g 8.11148e-17
C_x_PM_AND3_X2%A2_c3 VSS N_A2_M5_g 4.54734e-17
R_x_PM_AND3_X2%A2_r4 x_PM_AND3_X2%A2_18 x_PM_AND3_X2%A2_14 4.7687
R_x_PM_AND3_X2%A2_r5 x_PM_AND3_X2%A2_17 x_PM_AND3_X2%A2_14 4.7687
R_x_PM_AND3_X2%A2_r6 x_PM_AND3_X2%A2_14 x_PM_AND3_X2%A2_12 25.0012
R_x_PM_AND3_X2%A2_r7 x_PM_AND3_X2%A2_12 A2 0.169643
R_x_PM_AND3_X2%A2_r8 N_A2_M1_g x_PM_AND3_X2%A2_18 106.47
R_x_PM_AND3_X2%A2_r9 N_A2_M5_g x_PM_AND3_X2%A2_17 42.9
C_x_PM_AND3_X2%A3_c0 VSS x_PM_AND3_X2%A3_14 8.46766e-18
C_x_PM_AND3_X2%A3_c1 VSS x_PM_AND3_X2%A3_12 5.10428e-17
C_x_PM_AND3_X2%A3_c2 VSS N_A3_M2_g 5.76331e-17
C_x_PM_AND3_X2%A3_c3 VSS N_A3_M6_g 6.8921e-17
R_x_PM_AND3_X2%A3_r4 x_PM_AND3_X2%A3_18 x_PM_AND3_X2%A3_14 4.7687
R_x_PM_AND3_X2%A3_r5 x_PM_AND3_X2%A3_17 x_PM_AND3_X2%A3_14 4.7687
R_x_PM_AND3_X2%A3_r6 x_PM_AND3_X2%A3_14 x_PM_AND3_X2%A3_12 25.0012
R_x_PM_AND3_X2%A3_r7 x_PM_AND3_X2%A3_12 A3 0.246296
R_x_PM_AND3_X2%A3_r8 N_A3_M2_g x_PM_AND3_X2%A3_18 67.47
R_x_PM_AND3_X2%A3_r9 N_A3_M6_g x_PM_AND3_X2%A3_17 81.9
C_x_PM_AND3_X2%ZN_c0 VSS N_ZN_M7_d 3.25194e-17
C_x_PM_AND3_X2%ZN_c1 VSS ZN 9.50381e-17
C_x_PM_AND3_X2%ZN_c2 VSS N_ZN_M3_d 5.591e-17
C_x_PM_AND3_X2%ZN_c3 VSS x_PM_AND3_X2%ZN_3 8.95839e-18
R_x_PM_AND3_X2%ZN_r4 ZN x_PM_AND3_X2%ZN_8 1.87286
R_x_PM_AND3_X2%ZN_r5 x_PM_AND3_X2%ZN_7 N_ZN_M7_d 0.30478
R_x_PM_AND3_X2%ZN_r6 ZN x_PM_AND3_X2%ZN_7 1.79143
R_x_PM_AND3_X2%ZN_r7 x_PM_AND3_X2%ZN_8 x_PM_AND3_X2%ZN_3 0.20978
R_x_PM_AND3_X2%ZN_r8 N_ZN_M3_d x_PM_AND3_X2%ZN_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND3_X4 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 N_VDD_M0_d N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_3_M1_d N_A2_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g N_3_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 8 N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 9 N_A2_M5_g 8 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g 9 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_AND3_X4%VSS_c0 VSS x_PM_AND3_X4%VSS_12 3.40689e-17
C_x_PM_AND3_X4%VSS_c1 VSS N_VSS_M6_d 2.91031e-17
C_x_PM_AND3_X4%VSS_c2 VSS x_PM_AND3_X4%VSS_2 8.15989e-17
R_x_PM_AND3_X4%VSS_r3 x_PM_AND3_X4%VSS_12 x_PM_AND3_X4%VSS_6 0.145286
R_x_PM_AND3_X4%VSS_r4 N_VSS_M6_d x_PM_AND3_X4%VSS_6 0.230714
R_x_PM_AND3_X4%VSS_r5 x_PM_AND3_X4%VSS_12 x_PM_AND3_X4%VSS_2 0.0731438
R_x_PM_AND3_X4%VSS_r6 VSS x_PM_AND3_X4%VSS_2 0.346471
C_x_PM_AND3_X4%VDD_c0 VSS x_PM_AND3_X4%VDD_20 2.83667e-17
C_x_PM_AND3_X4%VDD_c1 VSS x_PM_AND3_X4%VDD_19 3.97626e-17
C_x_PM_AND3_X4%VDD_c2 VSS N_VDD_M2_d 2.51872e-17
C_x_PM_AND3_X4%VDD_c3 VSS x_PM_AND3_X4%VDD_9 3.39296e-17
C_x_PM_AND3_X4%VDD_c4 VSS N_VDD_M0_d 2.76446e-17
R_x_PM_AND3_X4%VDD_r5 x_PM_AND3_X4%VDD_20 x_PM_AND3_X4%VDD_13 0.145286
R_x_PM_AND3_X4%VDD_r6 N_VDD_M2_d x_PM_AND3_X4%VDD_13 0.393571
R_x_PM_AND3_X4%VDD_r7 x_PM_AND3_X4%VDD_19 x_PM_AND3_X4%VDD_10 0.0731438
R_x_PM_AND3_X4%VDD_r8 VDD x_PM_AND3_X4%VDD_10 0.346471
R_x_PM_AND3_X4%VDD_r9 x_PM_AND3_X4%VDD_20 x_PM_AND3_X4%VDD_9 0.0731438
R_x_PM_AND3_X4%VDD_r10 VDD x_PM_AND3_X4%VDD_9 0.346471
R_x_PM_AND3_X4%VDD_r11 x_PM_AND3_X4%VDD_19 x_PM_AND3_X4%VDD_5 0.145286
R_x_PM_AND3_X4%VDD_r12 N_VDD_M0_d x_PM_AND3_X4%VDD_5 0.393571
C_x_PM_AND3_X4%3_c0 VSS x_PM_AND3_X4%3_39 1.26988e-17
C_x_PM_AND3_X4%3_c1 VSS x_PM_AND3_X4%3_36 2.36205e-18
C_x_PM_AND3_X4%3_c2 VSS N_3_M4_s 3.79862e-17
C_x_PM_AND3_X4%3_c3 VSS x_PM_AND3_X4%3_29 1.56629e-16
C_x_PM_AND3_X4%3_c4 VSS x_PM_AND3_X4%3_24 2.19039e-17
C_x_PM_AND3_X4%3_c5 VSS N_3_M1_d 3.71088e-17
C_x_PM_AND3_X4%3_c6 VSS x_PM_AND3_X4%3_18 1.06545e-16
C_x_PM_AND3_X4%3_c7 VSS x_PM_AND3_X4%3_17 4.52132e-18
C_x_PM_AND3_X4%3_c8 VSS x_PM_AND3_X4%3_16 2.64804e-17
C_x_PM_AND3_X4%3_c9 VSS N_3_M0_s 3.00488e-17
C_x_PM_AND3_X4%3_c10 VSS N_3_M3_g 7.46703e-17
C_x_PM_AND3_X4%3_c11 VSS N_3_M7_g 4.95362e-17
R_x_PM_AND3_X4%3_r12 x_PM_AND3_X4%3_39 x_PM_AND3_X4%3_37 4.42
R_x_PM_AND3_X4%3_r13 x_PM_AND3_X4%3_34 N_3_M4_s 0.204074
R_x_PM_AND3_X4%3_r14 x_PM_AND3_X4%3_37 x_PM_AND3_X4%3_29 25.0012
R_x_PM_AND3_X4%3_r15 x_PM_AND3_X4%3_29 x_PM_AND3_X4%3_27 2.51071
R_x_PM_AND3_X4%3_r16 x_PM_AND3_X4%3_29 x_PM_AND3_X4%3_26 1.12643
R_x_PM_AND3_X4%3_r17 x_PM_AND3_X4%3_36 x_PM_AND3_X4%3_25 0.160909
R_x_PM_AND3_X4%3_r18 x_PM_AND3_X4%3_27 x_PM_AND3_X4%3_24 0.212317
R_x_PM_AND3_X4%3_r19 x_PM_AND3_X4%3_25 x_PM_AND3_X4%3_24 0.95
R_x_PM_AND3_X4%3_r20 x_PM_AND3_X4%3_36 x_PM_AND3_X4%3_20 0.0418175
R_x_PM_AND3_X4%3_r21 N_3_M1_d x_PM_AND3_X4%3_20 0.610714
R_x_PM_AND3_X4%3_r22 x_PM_AND3_X4%3_34 x_PM_AND3_X4%3_19 0.095
R_x_PM_AND3_X4%3_r23 x_PM_AND3_X4%3_26 x_PM_AND3_X4%3_18 0.212317
R_x_PM_AND3_X4%3_r24 x_PM_AND3_X4%3_19 x_PM_AND3_X4%3_18 2.79571
R_x_PM_AND3_X4%3_r25 x_PM_AND3_X4%3_36 x_PM_AND3_X4%3_16 0.160909
R_x_PM_AND3_X4%3_r26 x_PM_AND3_X4%3_17 x_PM_AND3_X4%3_16 1.62857
R_x_PM_AND3_X4%3_r27 x_PM_AND3_X4%3_17 x_PM_AND3_X4%3_12 0.212317
R_x_PM_AND3_X4%3_r28 N_3_M0_s x_PM_AND3_X4%3_12 0.610714
R_x_PM_AND3_X4%3_r29 x_PM_AND3_X4%3_39 x_PM_AND3_X4%3_5 1.95
R_x_PM_AND3_X4%3_r30 N_3_M3_g x_PM_AND3_X4%3_5 67.86
R_x_PM_AND3_X4%3_r31 x_PM_AND3_X4%3_39 x_PM_AND3_X4%3_VSS 1.95
R_x_PM_AND3_X4%3_r32 N_3_M7_g x_PM_AND3_X4%3_VSS 35.88
C_x_PM_AND3_X4%A1_c0 VSS x_PM_AND3_X4%A1_14 1.76443e-17
C_x_PM_AND3_X4%A1_c1 VSS x_PM_AND3_X4%A1_12 7.25392e-18
C_x_PM_AND3_X4%A1_c2 VSS x_PM_AND3_X4%A1_10 2.53421e-17
C_x_PM_AND3_X4%A1_c3 VSS N_A1_M0_g 8.32913e-17
C_x_PM_AND3_X4%A1_c4 VSS N_A1_M4_g 4.10232e-17
R_x_PM_AND3_X4%A1_r5 A1 x_PM_AND3_X4%A1_14 0.19
R_x_PM_AND3_X4%A1_r6 x_PM_AND3_X4%A1_21 x_PM_AND3_X4%A1_12 4.7687
R_x_PM_AND3_X4%A1_r7 x_PM_AND3_X4%A1_20 x_PM_AND3_X4%A1_12 4.7687
R_x_PM_AND3_X4%A1_r8 x_PM_AND3_X4%A1_12 x_PM_AND3_X4%A1_10 25.0012
R_x_PM_AND3_X4%A1_r9 x_PM_AND3_X4%A1_14 x_PM_AND3_X4%A1_9 0.095
R_x_PM_AND3_X4%A1_r10 x_PM_AND3_X4%A1_10 x_PM_AND3_X4%A1_9 0.420714
R_x_PM_AND3_X4%A1_r11 N_A1_M0_g x_PM_AND3_X4%A1_21 111.93
R_x_PM_AND3_X4%A1_r12 N_A1_M4_g x_PM_AND3_X4%A1_20 38.22
C_x_PM_AND3_X4%A2_c0 VSS x_PM_AND3_X4%A2_18 1.11844e-17
C_x_PM_AND3_X4%A2_c1 VSS x_PM_AND3_X4%A2_12 2.52715e-17
C_x_PM_AND3_X4%A2_c2 VSS N_A2_M1_g 6.83342e-17
C_x_PM_AND3_X4%A2_c3 VSS N_A2_M5_g 5.93733e-17
R_x_PM_AND3_X4%A2_r4 x_PM_AND3_X4%A2_18 x_PM_AND3_X4%A2_14 4.42
R_x_PM_AND3_X4%A2_r5 x_PM_AND3_X4%A2_14 x_PM_AND3_X4%A2_12 25.0012
R_x_PM_AND3_X4%A2_r6 x_PM_AND3_X4%A2_12 A2 0.156071
R_x_PM_AND3_X4%A2_r7 x_PM_AND3_X4%A2_18 x_PM_AND3_X4%A2_5 1.95
R_x_PM_AND3_X4%A2_r8 N_A2_M1_g x_PM_AND3_X4%A2_5 85.41
R_x_PM_AND3_X4%A2_r9 x_PM_AND3_X4%A2_18 x_PM_AND3_X4%A2_VSS 1.95
R_x_PM_AND3_X4%A2_r10 N_A2_M5_g x_PM_AND3_X4%A2_VSS 64.74
C_x_PM_AND3_X4%A3_c0 VSS x_PM_AND3_X4%A3_14 8.72393e-18
C_x_PM_AND3_X4%A3_c1 VSS x_PM_AND3_X4%A3_12 4.73136e-17
C_x_PM_AND3_X4%A3_c2 VSS N_A3_M2_g 8.11573e-17
C_x_PM_AND3_X4%A3_c3 VSS N_A3_M6_g 4.60391e-17
R_x_PM_AND3_X4%A3_r4 x_PM_AND3_X4%A3_18 x_PM_AND3_X4%A3_14 4.7687
R_x_PM_AND3_X4%A3_r5 x_PM_AND3_X4%A3_17 x_PM_AND3_X4%A3_14 4.7687
R_x_PM_AND3_X4%A3_r6 x_PM_AND3_X4%A3_14 x_PM_AND3_X4%A3_12 25.0012
R_x_PM_AND3_X4%A3_r7 x_PM_AND3_X4%A3_12 A3 0.2375
R_x_PM_AND3_X4%A3_r8 N_A3_M2_g x_PM_AND3_X4%A3_18 106.47
R_x_PM_AND3_X4%A3_r9 N_A3_M6_g x_PM_AND3_X4%A3_17 43.68
C_x_PM_AND3_X4%ZN_c0 VSS N_ZN_M7_d 1.57351e-16
R_x_PM_AND3_X4%ZN_r1 N_ZN_M3_d ZN 1.56071
R_x_PM_AND3_X4%ZN_r2 ZN N_ZN_M7_d 1.18071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X1 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_3_M2_d N_A3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g N_3_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M9 N_ZN_M4_d N_3_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 9 N_A1_M5_g N_3_M5_s VSS NMOS_VTL W=0.215000U L=0.050000U
M_M1 10 N_A2_M6_g 9 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M2 11 N_A3_M7_g 10 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g 11 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M4 N_ZN_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AND4_X1%VSS_c0 VSS x_PM_AND4_X1%VSS_12 4.50245e-17
C_x_PM_AND4_X1%VSS_c1 VSS N_VSS_M8_d 3.93091e-17
C_x_PM_AND4_X1%VSS_c2 VSS x_PM_AND4_X1%VSS_2 7.69904e-17
R_x_PM_AND4_X1%VSS_r3 x_PM_AND4_X1%VSS_12 x_PM_AND4_X1%VSS_6 0.145286
R_x_PM_AND4_X1%VSS_r4 N_VSS_M8_d x_PM_AND4_X1%VSS_6 0.637857
R_x_PM_AND4_X1%VSS_r5 x_PM_AND4_X1%VSS_12 x_PM_AND4_X1%VSS_2 0.0731438
R_x_PM_AND4_X1%VSS_r6 VSS x_PM_AND4_X1%VSS_2 0.514118
C_x_PM_AND4_X1%VDD_c0 VSS x_PM_AND4_X1%VDD_25 4.64695e-17
C_x_PM_AND4_X1%VDD_c1 VSS x_PM_AND4_X1%VDD_24 2.82055e-18
C_x_PM_AND4_X1%VDD_c2 VSS N_VDD_M3_d 3.41527e-17
C_x_PM_AND4_X1%VDD_c3 VSS x_PM_AND4_X1%VDD_14 3.45017e-17
C_x_PM_AND4_X1%VDD_c4 VSS N_VDD_M1_d 3.26926e-17
C_x_PM_AND4_X1%VDD_c5 VSS x_PM_AND4_X1%VDD_9 1.08262e-17
C_x_PM_AND4_X1%VDD_c6 VSS x_PM_AND4_X1%VDD_8 3.29331e-17
C_x_PM_AND4_X1%VDD_c7 VSS N_VDD_M0_s 1.40112e-17
R_x_PM_AND4_X1%VDD_r8 x_PM_AND4_X1%VDD_25 x_PM_AND4_X1%VDD_18 0.145286
R_x_PM_AND4_X1%VDD_r9 N_VDD_M3_d x_PM_AND4_X1%VDD_18 0.393571
R_x_PM_AND4_X1%VDD_r10 x_PM_AND4_X1%VDD_24 x_PM_AND4_X1%VDD_15 0.0731438
R_x_PM_AND4_X1%VDD_r11 VDD x_PM_AND4_X1%VDD_15 0.19
R_x_PM_AND4_X1%VDD_r12 x_PM_AND4_X1%VDD_25 x_PM_AND4_X1%VDD_14 0.0731438
R_x_PM_AND4_X1%VDD_r13 VDD x_PM_AND4_X1%VDD_14 0.502941
R_x_PM_AND4_X1%VDD_r14 x_PM_AND4_X1%VDD_24 x_PM_AND4_X1%VDD_10 0.145286
R_x_PM_AND4_X1%VDD_r15 N_VDD_M1_d x_PM_AND4_X1%VDD_10 0.393571
R_x_PM_AND4_X1%VDD_r16 x_PM_AND4_X1%VDD_24 x_PM_AND4_X1%VDD_8 0.0731438
R_x_PM_AND4_X1%VDD_r17 x_PM_AND4_X1%VDD_9 x_PM_AND4_X1%VDD_8 0.681765
R_x_PM_AND4_X1%VDD_r18 x_PM_AND4_X1%VDD_9 x_PM_AND4_X1%VDD_4 0.264221
R_x_PM_AND4_X1%VDD_r19 N_VDD_M0_s x_PM_AND4_X1%VDD_4 0.393571
C_x_PM_AND4_X1%3_c0 VSS x_PM_AND4_X1%3_44 1.0601e-17
C_x_PM_AND4_X1%3_c1 VSS x_PM_AND4_X1%3_41 7.79339e-18
C_x_PM_AND4_X1%3_c2 VSS x_PM_AND4_X1%3_40 3.61684e-17
C_x_PM_AND4_X1%3_c3 VSS x_PM_AND4_X1%3_39 9.02724e-18
C_x_PM_AND4_X1%3_c4 VSS x_PM_AND4_X1%3_38 5.71747e-17
C_x_PM_AND4_X1%3_c5 VSS x_PM_AND4_X1%3_35 9.40155e-18
C_x_PM_AND4_X1%3_c6 VSS x_PM_AND4_X1%3_32 8.01897e-18
C_x_PM_AND4_X1%3_c7 VSS x_PM_AND4_X1%3_28 5.02169e-17
C_x_PM_AND4_X1%3_c8 VSS N_3_M2_d 3.2129e-17
C_x_PM_AND4_X1%3_c9 VSS x_PM_AND4_X1%3_23 9.34991e-18
C_x_PM_AND4_X1%3_c10 VSS x_PM_AND4_X1%3_22 3.57054e-17
C_x_PM_AND4_X1%3_c11 VSS N_3_M0_d 3.34604e-17
C_x_PM_AND4_X1%3_c12 VSS x_PM_AND4_X1%3_17 6.18808e-18
C_x_PM_AND4_X1%3_c13 VSS x_PM_AND4_X1%3_16 9.93245e-17
C_x_PM_AND4_X1%3_c14 VSS N_3_M5_s 1.40183e-17
C_x_PM_AND4_X1%3_c15 VSS N_3_M4_g 6.6452e-17
C_x_PM_AND4_X1%3_c16 VSS N_3_M9_g 5.89404e-17
R_x_PM_AND4_X1%3_r17 x_PM_AND4_X1%3_44 x_PM_AND4_X1%3_42 2.34
R_x_PM_AND4_X1%3_r18 x_PM_AND4_X1%3_38 x_PM_AND4_X1%3_41 1.60143
R_x_PM_AND4_X1%3_r19 x_PM_AND4_X1%3_42 x_PM_AND4_X1%3_35 25.0012
R_x_PM_AND4_X1%3_r20 x_PM_AND4_X1%3_41 x_PM_AND4_X1%3_33 0.202958
R_x_PM_AND4_X1%3_r21 x_PM_AND4_X1%3_35 x_PM_AND4_X1%3_33 0.111765
R_x_PM_AND4_X1%3_r22 x_PM_AND4_X1%3_40 x_PM_AND4_X1%3_32 0.202958
R_x_PM_AND4_X1%3_r23 x_PM_AND4_X1%3_35 x_PM_AND4_X1%3_32 0.111765
R_x_PM_AND4_X1%3_r24 x_PM_AND4_X1%3_40 x_PM_AND4_X1%3_30 1.11286
R_x_PM_AND4_X1%3_r25 x_PM_AND4_X1%3_39 x_PM_AND4_X1%3_29 0.160909
R_x_PM_AND4_X1%3_r26 x_PM_AND4_X1%3_38 x_PM_AND4_X1%3_28 0.212317
R_x_PM_AND4_X1%3_r27 x_PM_AND4_X1%3_29 x_PM_AND4_X1%3_28 0.977143
R_x_PM_AND4_X1%3_r28 x_PM_AND4_X1%3_39 x_PM_AND4_X1%3_24 0.0418175
R_x_PM_AND4_X1%3_r29 N_3_M2_d x_PM_AND4_X1%3_24 0.393571
R_x_PM_AND4_X1%3_r30 x_PM_AND4_X1%3_39 x_PM_AND4_X1%3_22 0.160909
R_x_PM_AND4_X1%3_r31 x_PM_AND4_X1%3_23 x_PM_AND4_X1%3_22 1.62857
R_x_PM_AND4_X1%3_r32 x_PM_AND4_X1%3_23 x_PM_AND4_X1%3_18 0.212317
R_x_PM_AND4_X1%3_r33 N_3_M0_d x_PM_AND4_X1%3_18 0.393571
R_x_PM_AND4_X1%3_r34 x_PM_AND4_X1%3_30 x_PM_AND4_X1%3_16 0.212317
R_x_PM_AND4_X1%3_r35 x_PM_AND4_X1%3_17 x_PM_AND4_X1%3_16 4.04429
R_x_PM_AND4_X1%3_r36 x_PM_AND4_X1%3_17 x_PM_AND4_X1%3_12 0.212696
R_x_PM_AND4_X1%3_r37 N_3_M5_s x_PM_AND4_X1%3_12 0.277692
R_x_PM_AND4_X1%3_r38 x_PM_AND4_X1%3_44 x_PM_AND4_X1%3_5 1.95
R_x_PM_AND4_X1%3_r39 N_3_M4_g x_PM_AND4_X1%3_5 77.61
R_x_PM_AND4_X1%3_r40 x_PM_AND4_X1%3_44 x_PM_AND4_X1%3_VSS 1.95
R_x_PM_AND4_X1%3_r41 N_3_M9_g x_PM_AND4_X1%3_VSS 67.08
C_x_PM_AND4_X1%A1_c0 VSS x_PM_AND4_X1%A1_14 7.05096e-18
C_x_PM_AND4_X1%A1_c1 VSS x_PM_AND4_X1%A1_12 2.19358e-17
C_x_PM_AND4_X1%A1_c2 VSS N_A1_M0_g 6.0468e-17
C_x_PM_AND4_X1%A1_c3 VSS N_A1_M5_g 5.18663e-17
R_x_PM_AND4_X1%A1_r4 x_PM_AND4_X1%A1_18 x_PM_AND4_X1%A1_14 4.74714
R_x_PM_AND4_X1%A1_r5 x_PM_AND4_X1%A1_17 x_PM_AND4_X1%A1_14 4.74714
R_x_PM_AND4_X1%A1_r6 x_PM_AND4_X1%A1_14 x_PM_AND4_X1%A1_12 25.0012
R_x_PM_AND4_X1%A1_r7 x_PM_AND4_X1%A1_12 A1 0.136562
R_x_PM_AND4_X1%A1_r8 N_A1_M0_g x_PM_AND4_X1%A1_18 81.51
R_x_PM_AND4_X1%A1_r9 N_A1_M5_g x_PM_AND4_X1%A1_17 53.43
C_x_PM_AND4_X1%A2_c0 VSS x_PM_AND4_X1%A2_14 8.83824e-18
C_x_PM_AND4_X1%A2_c1 VSS x_PM_AND4_X1%A2_12 2.28944e-17
C_x_PM_AND4_X1%A2_c2 VSS N_A2_M1_g 5.4464e-17
C_x_PM_AND4_X1%A2_c3 VSS N_A2_M6_g 6.49159e-17
R_x_PM_AND4_X1%A2_r4 x_PM_AND4_X1%A2_18 x_PM_AND4_X1%A2_14 4.74714
R_x_PM_AND4_X1%A2_r5 x_PM_AND4_X1%A2_17 x_PM_AND4_X1%A2_14 4.74714
R_x_PM_AND4_X1%A2_r6 x_PM_AND4_X1%A2_14 x_PM_AND4_X1%A2_12 25.0012
R_x_PM_AND4_X1%A2_r7 x_PM_AND4_X1%A2_12 A2 0.156071
R_x_PM_AND4_X1%A2_r8 N_A2_M1_g x_PM_AND4_X1%A2_18 62.79
R_x_PM_AND4_X1%A2_r9 N_A2_M6_g x_PM_AND4_X1%A2_17 72.15
C_x_PM_AND4_X1%A3_c0 VSS x_PM_AND4_X1%A3_14 8.75898e-18
C_x_PM_AND4_X1%A3_c1 VSS x_PM_AND4_X1%A3_12 2.56732e-17
C_x_PM_AND4_X1%A3_c2 VSS N_A3_M2_g 6.85539e-17
C_x_PM_AND4_X1%A3_c3 VSS N_A3_M7_g 5.09308e-17
R_x_PM_AND4_X1%A3_r4 x_PM_AND4_X1%A3_18 x_PM_AND4_X1%A3_14 4.7687
R_x_PM_AND4_X1%A3_r5 x_PM_AND4_X1%A3_17 x_PM_AND4_X1%A3_14 4.7687
R_x_PM_AND4_X1%A3_r6 x_PM_AND4_X1%A3_14 x_PM_AND4_X1%A3_12 25.0012
R_x_PM_AND4_X1%A3_r7 x_PM_AND4_X1%A3_12 A3 0.2375
R_x_PM_AND4_X1%A3_r8 N_A3_M2_g x_PM_AND4_X1%A3_18 85.41
R_x_PM_AND4_X1%A3_r9 N_A3_M7_g x_PM_AND4_X1%A3_17 49.53
C_x_PM_AND4_X1%A4_c0 VSS x_PM_AND4_X1%A4_14 8.83042e-18
C_x_PM_AND4_X1%A4_c1 VSS x_PM_AND4_X1%A4_12 4.22435e-17
C_x_PM_AND4_X1%A4_c2 VSS N_A4_M3_g 4.31695e-17
C_x_PM_AND4_X1%A4_c3 VSS N_A4_M8_g 7.78353e-17
R_x_PM_AND4_X1%A4_r4 x_PM_AND4_X1%A4_18 x_PM_AND4_X1%A4_14 4.74714
R_x_PM_AND4_X1%A4_r5 x_PM_AND4_X1%A4_17 x_PM_AND4_X1%A4_14 4.74714
R_x_PM_AND4_X1%A4_r6 x_PM_AND4_X1%A4_14 x_PM_AND4_X1%A4_12 25.0012
R_x_PM_AND4_X1%A4_r7 x_PM_AND4_X1%A4_12 A4 0.312143
R_x_PM_AND4_X1%A4_r8 N_A4_M3_g x_PM_AND4_X1%A4_18 41.73
R_x_PM_AND4_X1%A4_r9 N_A4_M8_g x_PM_AND4_X1%A4_17 93.21
C_x_PM_AND4_X1%ZN_c0 VSS N_ZN_M4_d 4.023e-17
C_x_PM_AND4_X1%ZN_c1 VSS N_ZN_M9_d 4.24411e-17
C_x_PM_AND4_X1%ZN_c2 VSS ZN 1.23488e-16
R_x_PM_AND4_X1%ZN_r3 x_PM_AND4_X1%ZN_4 N_ZN_M4_d 0.287904
R_x_PM_AND4_X1%ZN_r4 ZN x_PM_AND4_X1%ZN_4 2.45733
R_x_PM_AND4_X1%ZN_r5 x_PM_AND4_X1%ZN_3 N_ZN_M9_d 0.287904
R_x_PM_AND4_X1%ZN_r6 ZN x_PM_AND4_X1%ZN_3 1.748
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X2 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_3_M2_d N_A3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g N_3_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M9 N_ZN_M4_d N_3_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 9 N_A1_M5_g N_3_M5_s VSS NMOS_VTL W=0.215000U L=0.050000U
M_M1 10 N_A2_M6_g 9 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M2 11 N_A3_M7_g 10 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g 11 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M4 N_ZN_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AND4_X2%VSS_c0 VSS x_PM_AND4_X2%VSS_12 4.48532e-17
C_x_PM_AND4_X2%VSS_c1 VSS N_VSS_M8_d 2.45741e-17
C_x_PM_AND4_X2%VSS_c2 VSS x_PM_AND4_X2%VSS_2 9.14419e-17
R_x_PM_AND4_X2%VSS_r3 x_PM_AND4_X2%VSS_12 x_PM_AND4_X2%VSS_6 0.145286
R_x_PM_AND4_X2%VSS_r4 N_VSS_M8_d x_PM_AND4_X2%VSS_6 0.230714
R_x_PM_AND4_X2%VSS_r5 x_PM_AND4_X2%VSS_12 x_PM_AND4_X2%VSS_2 0.0731438
R_x_PM_AND4_X2%VSS_r6 VSS x_PM_AND4_X2%VSS_2 0.502941
C_x_PM_AND4_X2%VDD_c0 VSS x_PM_AND4_X2%VDD_25 4.45927e-17
C_x_PM_AND4_X2%VDD_c1 VSS x_PM_AND4_X2%VDD_24 2.84978e-18
C_x_PM_AND4_X2%VDD_c2 VSS N_VDD_M3_d 2.75841e-17
C_x_PM_AND4_X2%VDD_c3 VSS x_PM_AND4_X2%VDD_14 3.21954e-17
C_x_PM_AND4_X2%VDD_c4 VSS N_VDD_M1_d 2.5303e-17
C_x_PM_AND4_X2%VDD_c5 VSS x_PM_AND4_X2%VDD_9 1.08478e-17
C_x_PM_AND4_X2%VDD_c6 VSS x_PM_AND4_X2%VDD_8 3.13029e-17
C_x_PM_AND4_X2%VDD_c7 VSS N_VDD_M0_s 1.41211e-17
R_x_PM_AND4_X2%VDD_r8 x_PM_AND4_X2%VDD_25 x_PM_AND4_X2%VDD_18 0.145286
R_x_PM_AND4_X2%VDD_r9 N_VDD_M3_d x_PM_AND4_X2%VDD_18 0.420714
R_x_PM_AND4_X2%VDD_r10 x_PM_AND4_X2%VDD_24 x_PM_AND4_X2%VDD_15 0.0731438
R_x_PM_AND4_X2%VDD_r11 VDD x_PM_AND4_X2%VDD_15 0.19
R_x_PM_AND4_X2%VDD_r12 x_PM_AND4_X2%VDD_25 x_PM_AND4_X2%VDD_14 0.0731438
R_x_PM_AND4_X2%VDD_r13 VDD x_PM_AND4_X2%VDD_14 0.502941
R_x_PM_AND4_X2%VDD_r14 x_PM_AND4_X2%VDD_24 x_PM_AND4_X2%VDD_10 0.145286
R_x_PM_AND4_X2%VDD_r15 N_VDD_M1_d x_PM_AND4_X2%VDD_10 0.420714
R_x_PM_AND4_X2%VDD_r16 x_PM_AND4_X2%VDD_24 x_PM_AND4_X2%VDD_8 0.0731438
R_x_PM_AND4_X2%VDD_r17 x_PM_AND4_X2%VDD_9 x_PM_AND4_X2%VDD_8 0.681765
R_x_PM_AND4_X2%VDD_r18 x_PM_AND4_X2%VDD_9 x_PM_AND4_X2%VDD_4 0.264221
R_x_PM_AND4_X2%VDD_r19 N_VDD_M0_s x_PM_AND4_X2%VDD_4 0.420714
C_x_PM_AND4_X2%3_c0 VSS x_PM_AND4_X2%3_40 1.12164e-17
C_x_PM_AND4_X2%3_c1 VSS x_PM_AND4_X2%3_33 2.06085e-18
C_x_PM_AND4_X2%3_c2 VSS N_3_M5_s 2.68504e-17
C_x_PM_AND4_X2%3_c3 VSS x_PM_AND4_X2%3_27 8.75385e-17
C_x_PM_AND4_X2%3_c4 VSS x_PM_AND4_X2%3_26 5.12014e-17
C_x_PM_AND4_X2%3_c5 VSS x_PM_AND4_X2%3_24 3.28897e-17
C_x_PM_AND4_X2%3_c6 VSS N_3_M2_d 3.41478e-17
C_x_PM_AND4_X2%3_c7 VSS x_PM_AND4_X2%3_19 1.0345e-17
C_x_PM_AND4_X2%3_c8 VSS x_PM_AND4_X2%3_18 2.94817e-17
C_x_PM_AND4_X2%3_c9 VSS N_3_M0_d 3.60348e-17
C_x_PM_AND4_X2%3_c10 VSS x_PM_AND4_X2%3_12 1.17003e-16
C_x_PM_AND4_X2%3_c11 VSS N_3_M4_g 1.01497e-16
C_x_PM_AND4_X2%3_c12 VSS N_3_M9_g 3.57135e-17
R_x_PM_AND4_X2%3_r13 x_PM_AND4_X2%3_40 x_PM_AND4_X2%3_38 3.38
R_x_PM_AND4_X2%3_r14 x_PM_AND4_X2%3_38 x_PM_AND4_X2%3_36 25.0012
R_x_PM_AND4_X2%3_r15 x_PM_AND4_X2%3_36 x_PM_AND4_X2%3_34 0.259615
R_x_PM_AND4_X2%3_r16 x_PM_AND4_X2%3_31 N_3_M5_s 0.285
R_x_PM_AND4_X2%3_r17 x_PM_AND4_X2%3_36 x_PM_AND4_X2%3_26 0.292415
R_x_PM_AND4_X2%3_r18 x_PM_AND4_X2%3_27 x_PM_AND4_X2%3_26 2.93143
R_x_PM_AND4_X2%3_r19 x_PM_AND4_X2%3_33 x_PM_AND4_X2%3_25 0.160909
R_x_PM_AND4_X2%3_r20 x_PM_AND4_X2%3_27 x_PM_AND4_X2%3_24 0.212317
R_x_PM_AND4_X2%3_r21 x_PM_AND4_X2%3_25 x_PM_AND4_X2%3_24 0.787143
R_x_PM_AND4_X2%3_r22 x_PM_AND4_X2%3_33 x_PM_AND4_X2%3_20 0.0418175
R_x_PM_AND4_X2%3_r23 N_3_M2_d x_PM_AND4_X2%3_20 0.610714
R_x_PM_AND4_X2%3_r24 x_PM_AND4_X2%3_33 x_PM_AND4_X2%3_18 0.160909
R_x_PM_AND4_X2%3_r25 x_PM_AND4_X2%3_19 x_PM_AND4_X2%3_18 1.65571
R_x_PM_AND4_X2%3_r26 x_PM_AND4_X2%3_19 x_PM_AND4_X2%3_14 0.212317
R_x_PM_AND4_X2%3_r27 N_3_M0_d x_PM_AND4_X2%3_14 0.610714
R_x_PM_AND4_X2%3_r28 x_PM_AND4_X2%3_31 x_PM_AND4_X2%3_13 0.095
R_x_PM_AND4_X2%3_r29 x_PM_AND4_X2%3_34 x_PM_AND4_X2%3_12 0.100962
R_x_PM_AND4_X2%3_r30 x_PM_AND4_X2%3_13 x_PM_AND4_X2%3_12 3.85429
R_x_PM_AND4_X2%3_r31 x_PM_AND4_X2%3_40 x_PM_AND4_X2%3_5 1.95
R_x_PM_AND4_X2%3_r32 N_3_M4_g x_PM_AND4_X2%3_5 111.54
R_x_PM_AND4_X2%3_r33 x_PM_AND4_X2%3_40 x_PM_AND4_X2%3_VSS 1.95
R_x_PM_AND4_X2%3_r34 N_3_M9_g x_PM_AND4_X2%3_VSS 26.52
C_x_PM_AND4_X2%A1_c0 VSS x_PM_AND4_X2%A1_14 7.4392e-18
C_x_PM_AND4_X2%A1_c1 VSS x_PM_AND4_X2%A1_12 4.24683e-17
C_x_PM_AND4_X2%A1_c2 VSS N_A1_M0_g 7.33374e-17
C_x_PM_AND4_X2%A1_c3 VSS N_A1_M5_g 4.39981e-17
R_x_PM_AND4_X2%A1_r4 x_PM_AND4_X2%A1_18 x_PM_AND4_X2%A1_14 4.7687
R_x_PM_AND4_X2%A1_r5 x_PM_AND4_X2%A1_17 x_PM_AND4_X2%A1_14 4.7687
R_x_PM_AND4_X2%A1_r6 x_PM_AND4_X2%A1_14 x_PM_AND4_X2%A1_12 25.0012
R_x_PM_AND4_X2%A1_r7 x_PM_AND4_X2%A1_12 A1 0.2375
R_x_PM_AND4_X2%A1_r8 N_A1_M0_g x_PM_AND4_X2%A1_18 106.47
R_x_PM_AND4_X2%A1_r9 N_A1_M5_g x_PM_AND4_X2%A1_17 39.39
C_x_PM_AND4_X2%A2_c0 VSS x_PM_AND4_X2%A2_14 8.42144e-18
C_x_PM_AND4_X2%A2_c1 VSS x_PM_AND4_X2%A2_12 2.222e-17
C_x_PM_AND4_X2%A2_c2 VSS N_A2_M1_g 5.45019e-17
C_x_PM_AND4_X2%A2_c3 VSS N_A2_M6_g 7.16293e-17
R_x_PM_AND4_X2%A2_r4 x_PM_AND4_X2%A2_18 x_PM_AND4_X2%A2_14 4.7687
R_x_PM_AND4_X2%A2_r5 x_PM_AND4_X2%A2_17 x_PM_AND4_X2%A2_14 4.7687
R_x_PM_AND4_X2%A2_r6 x_PM_AND4_X2%A2_14 x_PM_AND4_X2%A2_12 25.0012
R_x_PM_AND4_X2%A2_r7 x_PM_AND4_X2%A2_12 A2 0.169643
R_x_PM_AND4_X2%A2_r8 N_A2_M1_g x_PM_AND4_X2%A2_18 62.79
R_x_PM_AND4_X2%A2_r9 N_A2_M6_g x_PM_AND4_X2%A2_17 83.07
C_x_PM_AND4_X2%A3_c0 VSS x_PM_AND4_X2%A3_14 9.23042e-18
C_x_PM_AND4_X2%A3_c1 VSS x_PM_AND4_X2%A3_12 5.936e-17
C_x_PM_AND4_X2%A3_c2 VSS N_A3_M2_g 8.12259e-17
C_x_PM_AND4_X2%A3_c3 VSS N_A3_M7_g 4.54243e-17
R_x_PM_AND4_X2%A3_r4 x_PM_AND4_X2%A3_18 x_PM_AND4_X2%A3_14 4.74714
R_x_PM_AND4_X2%A3_r5 x_PM_AND4_X2%A3_17 x_PM_AND4_X2%A3_14 4.74714
R_x_PM_AND4_X2%A3_r6 x_PM_AND4_X2%A3_14 x_PM_AND4_X2%A3_12 25.0012
R_x_PM_AND4_X2%A3_r7 x_PM_AND4_X2%A3_12 A3 0.156071
R_x_PM_AND4_X2%A3_r8 N_A3_M2_g x_PM_AND4_X2%A3_18 106.47
R_x_PM_AND4_X2%A3_r9 N_A3_M7_g x_PM_AND4_X2%A3_17 39.39
C_x_PM_AND4_X2%A4_c0 VSS x_PM_AND4_X2%A4_14 8.80305e-18
C_x_PM_AND4_X2%A4_c1 VSS x_PM_AND4_X2%A4_12 8.0586e-17
C_x_PM_AND4_X2%A4_c2 VSS N_A4_M3_g 8.26834e-17
C_x_PM_AND4_X2%A4_c3 VSS N_A4_M8_g 4.63995e-17
R_x_PM_AND4_X2%A4_r4 x_PM_AND4_X2%A4_18 x_PM_AND4_X2%A4_14 4.7687
R_x_PM_AND4_X2%A4_r5 x_PM_AND4_X2%A4_17 x_PM_AND4_X2%A4_14 4.7687
R_x_PM_AND4_X2%A4_r6 x_PM_AND4_X2%A4_14 x_PM_AND4_X2%A4_12 25.0012
R_x_PM_AND4_X2%A4_r7 x_PM_AND4_X2%A4_12 A4 0.169643
R_x_PM_AND4_X2%A4_r8 N_A4_M3_g x_PM_AND4_X2%A4_18 106.47
R_x_PM_AND4_X2%A4_r9 N_A4_M8_g x_PM_AND4_X2%A4_17 39.39
C_x_PM_AND4_X2%ZN_c0 VSS N_ZN_M9_d 3.54907e-17
C_x_PM_AND4_X2%ZN_c1 VSS ZN 8.1492e-17
C_x_PM_AND4_X2%ZN_c2 VSS N_ZN_M4_d 4.91094e-17
C_x_PM_AND4_X2%ZN_c3 VSS x_PM_AND4_X2%ZN_3 6.62394e-18
R_x_PM_AND4_X2%ZN_r4 ZN x_PM_AND4_X2%ZN_8 1.87286
R_x_PM_AND4_X2%ZN_r5 x_PM_AND4_X2%ZN_7 N_ZN_M9_d 0.30478
R_x_PM_AND4_X2%ZN_r6 ZN x_PM_AND4_X2%ZN_7 1.84571
R_x_PM_AND4_X2%ZN_r7 x_PM_AND4_X2%ZN_8 x_PM_AND4_X2%ZN_3 0.20978
R_x_PM_AND4_X2%ZN_r8 N_ZN_M4_d x_PM_AND4_X2%ZN_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AND4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AND4_X4 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 N_3_M0_d N_A1_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M1_d N_A2_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_3_M2_d N_A3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g N_3_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M9 N_ZN_M4_d N_3_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 9 N_A1_M5_g N_3_M5_s VSS NMOS_VTL W=0.215000U L=0.050000U
M_M1 10 N_A2_M6_g 9 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M2 11 N_A3_M7_g 10 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g 11 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M4 N_ZN_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_AND4_X4%VSS_c0 VSS x_PM_AND4_X4%VSS_12 3.98411e-17
C_x_PM_AND4_X4%VSS_c1 VSS N_VSS_M8_d 2.41589e-17
C_x_PM_AND4_X4%VSS_c2 VSS x_PM_AND4_X4%VSS_2 9.14457e-17
R_x_PM_AND4_X4%VSS_r3 x_PM_AND4_X4%VSS_12 x_PM_AND4_X4%VSS_6 0.145286
R_x_PM_AND4_X4%VSS_r4 N_VSS_M8_d x_PM_AND4_X4%VSS_6 0.230714
R_x_PM_AND4_X4%VSS_r5 x_PM_AND4_X4%VSS_12 x_PM_AND4_X4%VSS_2 0.0731438
R_x_PM_AND4_X4%VSS_r6 VSS x_PM_AND4_X4%VSS_2 0.502941
C_x_PM_AND4_X4%VDD_c0 VSS x_PM_AND4_X4%VDD_25 2.99549e-17
C_x_PM_AND4_X4%VDD_c1 VSS x_PM_AND4_X4%VDD_24 2.82055e-18
C_x_PM_AND4_X4%VDD_c2 VSS N_VDD_M3_d 2.51815e-17
C_x_PM_AND4_X4%VDD_c3 VSS x_PM_AND4_X4%VDD_14 3.39393e-17
C_x_PM_AND4_X4%VDD_c4 VSS N_VDD_M1_d 2.52749e-17
C_x_PM_AND4_X4%VDD_c5 VSS x_PM_AND4_X4%VDD_9 1.08262e-17
C_x_PM_AND4_X4%VDD_c6 VSS x_PM_AND4_X4%VDD_8 3.28448e-17
C_x_PM_AND4_X4%VDD_c7 VSS N_VDD_M0_s 1.40075e-17
R_x_PM_AND4_X4%VDD_r8 x_PM_AND4_X4%VDD_25 x_PM_AND4_X4%VDD_18 0.145286
R_x_PM_AND4_X4%VDD_r9 N_VDD_M3_d x_PM_AND4_X4%VDD_18 0.393571
R_x_PM_AND4_X4%VDD_r10 x_PM_AND4_X4%VDD_24 x_PM_AND4_X4%VDD_15 0.0731438
R_x_PM_AND4_X4%VDD_r11 VDD x_PM_AND4_X4%VDD_15 0.19
R_x_PM_AND4_X4%VDD_r12 x_PM_AND4_X4%VDD_25 x_PM_AND4_X4%VDD_14 0.0731438
R_x_PM_AND4_X4%VDD_r13 VDD x_PM_AND4_X4%VDD_14 0.502941
R_x_PM_AND4_X4%VDD_r14 x_PM_AND4_X4%VDD_24 x_PM_AND4_X4%VDD_10 0.145286
R_x_PM_AND4_X4%VDD_r15 N_VDD_M1_d x_PM_AND4_X4%VDD_10 0.393571
R_x_PM_AND4_X4%VDD_r16 x_PM_AND4_X4%VDD_24 x_PM_AND4_X4%VDD_8 0.0731438
R_x_PM_AND4_X4%VDD_r17 x_PM_AND4_X4%VDD_9 x_PM_AND4_X4%VDD_8 0.681765
R_x_PM_AND4_X4%VDD_r18 x_PM_AND4_X4%VDD_9 x_PM_AND4_X4%VDD_4 0.264221
R_x_PM_AND4_X4%VDD_r19 N_VDD_M0_s x_PM_AND4_X4%VDD_4 0.393571
C_x_PM_AND4_X4%3_c0 VSS x_PM_AND4_X4%3_43 1.14972e-17
C_x_PM_AND4_X4%3_c1 VSS x_PM_AND4_X4%3_39 2.20028e-17
C_x_PM_AND4_X4%3_c2 VSS x_PM_AND4_X4%3_37 3.31822e-17
C_x_PM_AND4_X4%3_c3 VSS x_PM_AND4_X4%3_35 2.29355e-18
C_x_PM_AND4_X4%3_c4 VSS N_3_M5_s 2.68467e-17
C_x_PM_AND4_X4%3_c5 VSS x_PM_AND4_X4%3_29 6.83372e-17
C_x_PM_AND4_X4%3_c6 VSS x_PM_AND4_X4%3_24 2.42849e-17
C_x_PM_AND4_X4%3_c7 VSS N_3_M2_d 3.71088e-17
C_x_PM_AND4_X4%3_c8 VSS x_PM_AND4_X4%3_19 8.5695e-18
C_x_PM_AND4_X4%3_c9 VSS x_PM_AND4_X4%3_18 2.57408e-17
C_x_PM_AND4_X4%3_c10 VSS N_3_M0_d 3.74541e-17
C_x_PM_AND4_X4%3_c11 VSS x_PM_AND4_X4%3_12 1.3065e-16
C_x_PM_AND4_X4%3_c12 VSS N_3_M4_g 7.74182e-17
C_x_PM_AND4_X4%3_c13 VSS N_3_M9_g 5.26703e-17
R_x_PM_AND4_X4%3_r14 x_PM_AND4_X4%3_43 x_PM_AND4_X4%3_41 3.38
R_x_PM_AND4_X4%3_r15 x_PM_AND4_X4%3_40 x_PM_AND4_X4%3_37 0.286607
R_x_PM_AND4_X4%3_r16 x_PM_AND4_X4%3_39 x_PM_AND4_X4%3_37 0.286607
R_x_PM_AND4_X4%3_r17 x_PM_AND4_X4%3_41 x_PM_AND4_X4%3_37 25.0012
R_x_PM_AND4_X4%3_r18 x_PM_AND4_X4%3_33 N_3_M5_s 0.285
R_x_PM_AND4_X4%3_r19 x_PM_AND4_X4%3_29 x_PM_AND4_X4%3_40 2.11714
R_x_PM_AND4_X4%3_r20 x_PM_AND4_X4%3_39 x_PM_AND4_X4%3_26 0.651429
R_x_PM_AND4_X4%3_r21 x_PM_AND4_X4%3_35 x_PM_AND4_X4%3_25 0.160909
R_x_PM_AND4_X4%3_r22 x_PM_AND4_X4%3_29 x_PM_AND4_X4%3_24 0.212317
R_x_PM_AND4_X4%3_r23 x_PM_AND4_X4%3_25 x_PM_AND4_X4%3_24 0.814286
R_x_PM_AND4_X4%3_r24 x_PM_AND4_X4%3_35 x_PM_AND4_X4%3_20 0.0418175
R_x_PM_AND4_X4%3_r25 N_3_M2_d x_PM_AND4_X4%3_20 0.610714
R_x_PM_AND4_X4%3_r26 x_PM_AND4_X4%3_35 x_PM_AND4_X4%3_18 0.160909
R_x_PM_AND4_X4%3_r27 x_PM_AND4_X4%3_19 x_PM_AND4_X4%3_18 1.62857
R_x_PM_AND4_X4%3_r28 x_PM_AND4_X4%3_19 x_PM_AND4_X4%3_14 0.212317
R_x_PM_AND4_X4%3_r29 N_3_M0_d x_PM_AND4_X4%3_14 0.610714
R_x_PM_AND4_X4%3_r30 x_PM_AND4_X4%3_33 x_PM_AND4_X4%3_13 0.095
R_x_PM_AND4_X4%3_r31 x_PM_AND4_X4%3_26 x_PM_AND4_X4%3_12 0.212317
R_x_PM_AND4_X4%3_r32 x_PM_AND4_X4%3_13 x_PM_AND4_X4%3_12 3.85429
R_x_PM_AND4_X4%3_r33 x_PM_AND4_X4%3_43 x_PM_AND4_X4%3_5 1.95
R_x_PM_AND4_X4%3_r34 N_3_M4_g x_PM_AND4_X4%3_5 67.08
R_x_PM_AND4_X4%3_r35 x_PM_AND4_X4%3_43 x_PM_AND4_X4%3_VSS 1.95
R_x_PM_AND4_X4%3_r36 N_3_M9_g x_PM_AND4_X4%3_VSS 36.66
C_x_PM_AND4_X4%A1_c0 VSS x_PM_AND4_X4%A1_16 6.81281e-18
C_x_PM_AND4_X4%A1_c1 VSS x_PM_AND4_X4%A1_14 3.26631e-17
C_x_PM_AND4_X4%A1_c2 VSS A1 3.37964e-17
C_x_PM_AND4_X4%A1_c3 VSS N_A1_M0_g 6.017e-17
C_x_PM_AND4_X4%A1_c4 VSS N_A1_M5_g 5.85373e-17
R_x_PM_AND4_X4%A1_r5 x_PM_AND4_X4%A1_20 x_PM_AND4_X4%A1_16 4.7687
R_x_PM_AND4_X4%A1_r6 x_PM_AND4_X4%A1_19 x_PM_AND4_X4%A1_16 4.7687
R_x_PM_AND4_X4%A1_r7 x_PM_AND4_X4%A1_16 x_PM_AND4_X4%A1_14 25.0012
R_x_PM_AND4_X4%A1_r8 x_PM_AND4_X4%A1_14 A1 0.175926
R_x_PM_AND4_X4%A1_r9 N_A1_M0_g x_PM_AND4_X4%A1_20 81.51
R_x_PM_AND4_X4%A1_r10 N_A1_M5_g x_PM_AND4_X4%A1_19 65.13
C_x_PM_AND4_X4%A2_c0 VSS x_PM_AND4_X4%A2_14 8.50242e-18
C_x_PM_AND4_X4%A2_c1 VSS x_PM_AND4_X4%A2_9 7.79914e-17
C_x_PM_AND4_X4%A2_c2 VSS N_A2_M1_g 6.56144e-17
C_x_PM_AND4_X4%A2_c3 VSS N_A2_M6_g 6.08345e-17
R_x_PM_AND4_X4%A2_r4 x_PM_AND4_X4%A2_17 x_PM_AND4_X4%A2_14 4.7687
R_x_PM_AND4_X4%A2_r5 x_PM_AND4_X4%A2_16 x_PM_AND4_X4%A2_14 4.7687
R_x_PM_AND4_X4%A2_r6 x_PM_AND4_X4%A2_14 x_PM_AND4_X4%A2_12 25.0012
R_x_PM_AND4_X4%A2_r7 x_PM_AND4_X4%A2_12 x_PM_AND4_X4%A2_9 0.491869
R_x_PM_AND4_X4%A2_r8 A2 x_PM_AND4_X4%A2_9 0.164667
R_x_PM_AND4_X4%A2_r9 N_A2_M1_g x_PM_AND4_X4%A2_17 81.51
R_x_PM_AND4_X4%A2_r10 N_A2_M6_g x_PM_AND4_X4%A2_16 65.13
C_x_PM_AND4_X4%A3_c0 VSS x_PM_AND4_X4%A3_14 9.26143e-18
C_x_PM_AND4_X4%A3_c1 VSS x_PM_AND4_X4%A3_12 6.48753e-17
C_x_PM_AND4_X4%A3_c2 VSS N_A3_M2_g 8.18967e-17
C_x_PM_AND4_X4%A3_c3 VSS N_A3_M7_g 4.54176e-17
R_x_PM_AND4_X4%A3_r4 x_PM_AND4_X4%A3_18 x_PM_AND4_X4%A3_14 4.74714
R_x_PM_AND4_X4%A3_r5 x_PM_AND4_X4%A3_17 x_PM_AND4_X4%A3_14 4.74714
R_x_PM_AND4_X4%A3_r6 x_PM_AND4_X4%A3_14 x_PM_AND4_X4%A3_12 25.0012
R_x_PM_AND4_X4%A3_r7 x_PM_AND4_X4%A3_12 A3 0.156071
R_x_PM_AND4_X4%A3_r8 N_A3_M2_g x_PM_AND4_X4%A3_18 107.25
R_x_PM_AND4_X4%A3_r9 N_A3_M7_g x_PM_AND4_X4%A3_17 39.39
C_x_PM_AND4_X4%A4_c0 VSS x_PM_AND4_X4%A4_16 9.10346e-18
C_x_PM_AND4_X4%A4_c1 VSS x_PM_AND4_X4%A4_14 3.46126e-17
C_x_PM_AND4_X4%A4_c2 VSS x_PM_AND4_X4%A4_9 4.83941e-17
C_x_PM_AND4_X4%A4_c3 VSS N_A4_M3_g 7.01268e-17
C_x_PM_AND4_X4%A4_c4 VSS N_A4_M8_g 5.91215e-17
R_x_PM_AND4_X4%A4_r5 x_PM_AND4_X4%A4_20 x_PM_AND4_X4%A4_16 4.74714
R_x_PM_AND4_X4%A4_r6 x_PM_AND4_X4%A4_19 x_PM_AND4_X4%A4_16 4.74714
R_x_PM_AND4_X4%A4_r7 x_PM_AND4_X4%A4_16 x_PM_AND4_X4%A4_14 25.0012
R_x_PM_AND4_X4%A4_r8 x_PM_AND4_X4%A4_14 x_PM_AND4_X4%A4_12 0.161852
R_x_PM_AND4_X4%A4_r9 x_PM_AND4_X4%A4_12 x_PM_AND4_X4%A4_9 0.095
R_x_PM_AND4_X4%A4_r10 A4 x_PM_AND4_X4%A4_9 0.352857
R_x_PM_AND4_X4%A4_r11 N_A4_M3_g x_PM_AND4_X4%A4_20 86.19
R_x_PM_AND4_X4%A4_r12 N_A4_M8_g x_PM_AND4_X4%A4_19 60.45
C_x_PM_AND4_X4%ZN_c0 VSS ZN 3.45967e-17
C_x_PM_AND4_X4%ZN_c1 VSS x_PM_AND4_X4%ZN_11 6.49347e-18
C_x_PM_AND4_X4%ZN_c2 VSS N_ZN_M4_d 3.60056e-17
C_x_PM_AND4_X4%ZN_c3 VSS x_PM_AND4_X4%ZN_7 6.49347e-18
C_x_PM_AND4_X4%ZN_c4 VSS N_ZN_M9_d 4.19988e-17
R_x_PM_AND4_X4%ZN_r5 ZN x_PM_AND4_X4%ZN_12 0.434286
R_x_PM_AND4_X4%ZN_r6 ZN x_PM_AND4_X4%ZN_11 0.977143
R_x_PM_AND4_X4%ZN_r7 x_PM_AND4_X4%ZN_12 x_PM_AND4_X4%ZN_7 0.20978
R_x_PM_AND4_X4%ZN_r8 N_ZN_M4_d x_PM_AND4_X4%ZN_7 0.686111
R_x_PM_AND4_X4%ZN_r9 x_PM_AND4_X4%ZN_11 x_PM_AND4_X4%ZN_3 0.20978
R_x_PM_AND4_X4%ZN_r10 N_ZN_M9_d x_PM_AND4_X4%ZN_3 0.095
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   ANTENNA_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT ANTENNA_X1 VSS VDD A
*.PININFO A:I VDD:B VSS:B
c_1 0 VSS 3.43889e-17
c_2 0 VDD 2.31287e-17
c_3 0 A 7.37668e-17
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X1 VSS VDD C2 ZN C1 B A
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I B:I A:I
M_M4 N_ZN_M0_d N_C2_M0_g N_3_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M5 N_3_M1_d N_C1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M6 noxref_9 N_B_M2_g N_3_M1_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_VDD_M3_d N_A_M3_g noxref_9 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M0 noxref_10 N_C2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_ZN_M5_d N_C1_M5_g noxref_10 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_VSS_M6_d N_B_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_ZN_M7_d N_A_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AOI211_X1%VSS_c0 VSS x_PM_AOI211_X1%VSS_17 3.87216e-17
C_x_PM_AOI211_X1%VSS_c1 VSS N_VSS_M6_d 3.78888e-17
C_x_PM_AOI211_X1%VSS_c2 VSS x_PM_AOI211_X1%VSS_8 1.25203e-17
C_x_PM_AOI211_X1%VSS_c3 VSS x_PM_AOI211_X1%VSS_7 5.0749e-17
C_x_PM_AOI211_X1%VSS_c4 VSS N_VSS_M4_s 1.41336e-17
R_x_PM_AOI211_X1%VSS_r5 x_PM_AOI211_X1%VSS_17 x_PM_AOI211_X1%VSS_11 0.145286
R_x_PM_AOI211_X1%VSS_r6 N_VSS_M6_d x_PM_AOI211_X1%VSS_11 0.637857
R_x_PM_AOI211_X1%VSS_r7 VSS x_PM_AOI211_X1%VSS_8 0.76
R_x_PM_AOI211_X1%VSS_r8 x_PM_AOI211_X1%VSS_17 x_PM_AOI211_X1%VSS_7 0.0731438
R_x_PM_AOI211_X1%VSS_r9 VSS x_PM_AOI211_X1%VSS_7 0.357647
R_x_PM_AOI211_X1%VSS_r10 x_PM_AOI211_X1%VSS_8 x_PM_AOI211_X1%VSS_3 0.264221
R_x_PM_AOI211_X1%VSS_r11 N_VSS_M4_s x_PM_AOI211_X1%VSS_3 0.420714
C_x_PM_AOI211_X1%VDD_c0 VSS N_VDD_M3_d 1.52188e-17
C_x_PM_AOI211_X1%VDD_c1 VSS x_PM_AOI211_X1%VDD_2 1.70436e-16
R_x_PM_AOI211_X1%VDD_r2 N_VDD_M3_d x_PM_AOI211_X1%VDD_6 0.447857
R_x_PM_AOI211_X1%VDD_r3 x_PM_AOI211_X1%VDD_6 x_PM_AOI211_X1%VDD_2 0.264221
R_x_PM_AOI211_X1%VDD_r4 VDD x_PM_AOI211_X1%VDD_2 0.771176
C_x_PM_AOI211_X1%3_c0 VSS N_3_M1_d 1.26705e-16
R_x_PM_AOI211_X1%3_r1 N_3_M1_d N_3_M0_s 2.03571
C_x_PM_AOI211_X1%C2_c0 VSS x_PM_AOI211_X1%C2_14 7.50044e-18
C_x_PM_AOI211_X1%C2_c1 VSS x_PM_AOI211_X1%C2_12 2.42572e-17
C_x_PM_AOI211_X1%C2_c2 VSS N_C2_M0_g 7.06105e-17
C_x_PM_AOI211_X1%C2_c3 VSS N_C2_M4_g 3.73975e-17
R_x_PM_AOI211_X1%C2_r4 x_PM_AOI211_X1%C2_18 x_PM_AOI211_X1%C2_14 4.7687
R_x_PM_AOI211_X1%C2_r5 x_PM_AOI211_X1%C2_17 x_PM_AOI211_X1%C2_14 4.7687
R_x_PM_AOI211_X1%C2_r6 x_PM_AOI211_X1%C2_14 x_PM_AOI211_X1%C2_12 25.0012
R_x_PM_AOI211_X1%C2_r7 x_PM_AOI211_X1%C2_12 C2 0.305357
R_x_PM_AOI211_X1%C2_r8 N_C2_M0_g x_PM_AOI211_X1%C2_18 95.94
R_x_PM_AOI211_X1%C2_r9 N_C2_M4_g x_PM_AOI211_X1%C2_17 40.56
C_x_PM_AOI211_X1%ZN_c0 VSS N_ZN_M0_d 2.68417e-17
C_x_PM_AOI211_X1%ZN_c1 VSS x_PM_AOI211_X1%ZN_19 3.39496e-17
C_x_PM_AOI211_X1%ZN_c2 VSS x_PM_AOI211_X1%ZN_16 4.12386e-17
C_x_PM_AOI211_X1%ZN_c3 VSS x_PM_AOI211_X1%ZN_15 3.11986e-17
C_x_PM_AOI211_X1%ZN_c4 VSS ZN 6.91796e-18
C_x_PM_AOI211_X1%ZN_c5 VSS N_ZN_M5_d 4.72149e-17
C_x_PM_AOI211_X1%ZN_c6 VSS x_PM_AOI211_X1%ZN_7 1.06472e-17
C_x_PM_AOI211_X1%ZN_c7 VSS x_PM_AOI211_X1%ZN_6 3.98746e-17
C_x_PM_AOI211_X1%ZN_c8 VSS x_PM_AOI211_X1%ZN_5 4.26966e-17
R_x_PM_AOI211_X1%ZN_r9 N_ZN_M0_d x_PM_AOI211_X1%ZN_20 0.176429
R_x_PM_AOI211_X1%ZN_r10 x_PM_AOI211_X1%ZN_19 N_ZN_M7_d 0.543196
R_x_PM_AOI211_X1%ZN_r11 x_PM_AOI211_X1%ZN_19 x_PM_AOI211_X1%ZN_16 0.212317
R_x_PM_AOI211_X1%ZN_r12 x_PM_AOI211_X1%ZN_17 x_PM_AOI211_X1%ZN_16 1.68286
R_x_PM_AOI211_X1%ZN_r13 x_PM_AOI211_X1%ZN_15 x_PM_AOI211_X1%ZN_14 1.11286
R_x_PM_AOI211_X1%ZN_r14 ZN x_PM_AOI211_X1%ZN_17 0.0569232
R_x_PM_AOI211_X1%ZN_r15 ZN x_PM_AOI211_X1%ZN_14 0.143785
R_x_PM_AOI211_X1%ZN_r16 ZN N_ZN_M5_d 0.559022
R_x_PM_AOI211_X1%ZN_r17 x_PM_AOI211_X1%ZN_15 x_PM_AOI211_X1%ZN_6 0.212317
R_x_PM_AOI211_X1%ZN_r18 x_PM_AOI211_X1%ZN_7 x_PM_AOI211_X1%ZN_6 0.705714
R_x_PM_AOI211_X1%ZN_r19 x_PM_AOI211_X1%ZN_20 x_PM_AOI211_X1%ZN_5 0.095
R_x_PM_AOI211_X1%ZN_r20 x_PM_AOI211_X1%ZN_7 x_PM_AOI211_X1%ZN_4 0.212317
R_x_PM_AOI211_X1%ZN_r21 x_PM_AOI211_X1%ZN_5 x_PM_AOI211_X1%ZN_4 1.73714
C_x_PM_AOI211_X1%C1_c0 VSS C1 6.55548e-17
C_x_PM_AOI211_X1%C1_c1 VSS x_PM_AOI211_X1%C1_11 8.54029e-18
C_x_PM_AOI211_X1%C1_c2 VSS N_C1_M1_g 4.54816e-17
C_x_PM_AOI211_X1%C1_c3 VSS N_C1_M5_g 7.84651e-17
R_x_PM_AOI211_X1%C1_r4 x_PM_AOI211_X1%C1_18 x_PM_AOI211_X1%C1_11 4.7687
R_x_PM_AOI211_X1%C1_r5 x_PM_AOI211_X1%C1_17 x_PM_AOI211_X1%C1_11 4.7687
R_x_PM_AOI211_X1%C1_r6 x_PM_AOI211_X1%C1_11 x_PM_AOI211_X1%C1_9 25.0012
R_x_PM_AOI211_X1%C1_r7 C1 x_PM_AOI211_X1%C1_9 0.196333
R_x_PM_AOI211_X1%C1_r8 N_C1_M1_g x_PM_AOI211_X1%C1_18 37.44
R_x_PM_AOI211_X1%C1_r9 N_C1_M5_g x_PM_AOI211_X1%C1_17 99.06
C_x_PM_AOI211_X1%B_c0 VSS B 5.0917e-17
C_x_PM_AOI211_X1%B_c1 VSS x_PM_AOI211_X1%B_11 8.61562e-18
C_x_PM_AOI211_X1%B_c2 VSS N_B_M2_g 6.4655e-17
C_x_PM_AOI211_X1%B_c3 VSS N_B_M6_g 5.17856e-17
R_x_PM_AOI211_X1%B_r4 x_PM_AOI211_X1%B_18 x_PM_AOI211_X1%B_11 4.7687
R_x_PM_AOI211_X1%B_r5 x_PM_AOI211_X1%B_17 x_PM_AOI211_X1%B_11 4.7687
R_x_PM_AOI211_X1%B_r6 x_PM_AOI211_X1%B_11 x_PM_AOI211_X1%B_9 25.0012
R_x_PM_AOI211_X1%B_r7 B x_PM_AOI211_X1%B_9 0.210357
R_x_PM_AOI211_X1%B_r8 N_B_M2_g x_PM_AOI211_X1%B_18 73.32
R_x_PM_AOI211_X1%B_r9 N_B_M6_g x_PM_AOI211_X1%B_17 60.06
C_x_PM_AOI211_X1%A_c0 VSS x_PM_AOI211_X1%A_14 6.65676e-18
C_x_PM_AOI211_X1%A_c1 VSS x_PM_AOI211_X1%A_12 3.72232e-17
C_x_PM_AOI211_X1%A_c2 VSS N_A_M3_g 4.01808e-17
C_x_PM_AOI211_X1%A_c3 VSS N_A_M7_g 7.43081e-17
R_x_PM_AOI211_X1%A_r4 x_PM_AOI211_X1%A_18 x_PM_AOI211_X1%A_14 4.7687
R_x_PM_AOI211_X1%A_r5 x_PM_AOI211_X1%A_17 x_PM_AOI211_X1%A_14 4.7687
R_x_PM_AOI211_X1%A_r6 x_PM_AOI211_X1%A_14 x_PM_AOI211_X1%A_12 25.0012
R_x_PM_AOI211_X1%A_r7 x_PM_AOI211_X1%A_12 A 0.305357
R_x_PM_AOI211_X1%A_r8 N_A_M3_g x_PM_AOI211_X1%A_18 35.88
R_x_PM_AOI211_X1%A_r9 N_A_M7_g x_PM_AOI211_X1%A_17 97.5
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X2 VSS VDD C2 ZN C1 B A
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I B:I A:I
M_M4 N_ZN_M0_d N_C2_M0_g N_4_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M5 N_4_M1_d N_C1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M6 noxref_9 N_B_M2_g N_4_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M7 N_VDD_M3_d N_A_M3_g noxref_9 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 noxref_10 N_C2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M5_d N_C1_M5_g noxref_10 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_VSS_M6_d N_B_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_ZN_M7_d N_A_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AOI211_X2%VSS_c0 VSS N_VSS_M6_d 7.83321e-17
C_x_PM_AOI211_X2%VSS_c1 VSS x_PM_AOI211_X2%VSS_8 1.38982e-17
C_x_PM_AOI211_X2%VSS_c2 VSS x_PM_AOI211_X2%VSS_7 6.05283e-17
C_x_PM_AOI211_X2%VSS_c3 VSS N_VSS_M4_s 1.8215e-17
R_x_PM_AOI211_X2%VSS_r4 VSS x_PM_AOI211_X2%VSS_8 0.726471
R_x_PM_AOI211_X2%VSS_r5 x_PM_AOI211_X2%VSS_7 N_VSS_M6_d 0.140674
R_x_PM_AOI211_X2%VSS_r6 VSS x_PM_AOI211_X2%VSS_7 0.312941
R_x_PM_AOI211_X2%VSS_r7 x_PM_AOI211_X2%VSS_8 x_PM_AOI211_X2%VSS_3 0.264221
R_x_PM_AOI211_X2%VSS_r8 N_VSS_M4_s x_PM_AOI211_X2%VSS_3 0.230714
C_x_PM_AOI211_X2%VDD_c0 VSS N_VDD_M3_d 2.37279e-17
C_x_PM_AOI211_X2%VDD_c1 VSS x_PM_AOI211_X2%VDD_2 1.26292e-16
R_x_PM_AOI211_X2%VDD_r2 N_VDD_M3_d x_PM_AOI211_X2%VDD_6 0.230714
R_x_PM_AOI211_X2%VDD_r3 x_PM_AOI211_X2%VDD_6 x_PM_AOI211_X2%VDD_2 0.264221
R_x_PM_AOI211_X2%VDD_r4 VDD x_PM_AOI211_X2%VDD_2 0.804706
C_x_PM_AOI211_X2%C2_c0 VSS x_PM_AOI211_X2%C2_18 9.96658e-18
C_x_PM_AOI211_X2%C2_c1 VSS C2 6.50467e-17
C_x_PM_AOI211_X2%C2_c2 VSS N_C2_M0_g 8.85193e-17
C_x_PM_AOI211_X2%C2_c3 VSS N_C2_M4_g 3.66017e-17
R_x_PM_AOI211_X2%C2_r4 x_PM_AOI211_X2%C2_18 x_PM_AOI211_X2%C2_14 5.98
R_x_PM_AOI211_X2%C2_r5 x_PM_AOI211_X2%C2_14 x_PM_AOI211_X2%C2_12 25.0012
R_x_PM_AOI211_X2%C2_r6 x_PM_AOI211_X2%C2_12 C2 0.266
R_x_PM_AOI211_X2%C2_r7 x_PM_AOI211_X2%C2_18 x_PM_AOI211_X2%C2_5 1.95
R_x_PM_AOI211_X2%C2_r8 N_C2_M0_g x_PM_AOI211_X2%C2_5 89.7
R_x_PM_AOI211_X2%C2_r9 x_PM_AOI211_X2%C2_18 x_PM_AOI211_X2%C2_VSS 1.95
R_x_PM_AOI211_X2%C2_r10 N_C2_M4_g x_PM_AOI211_X2%C2_VSS 28.08
C_x_PM_AOI211_X2%4_c0 VSS N_4_M0_s 3.20478e-17
C_x_PM_AOI211_X2%4_c1 VSS x_PM_AOI211_X2%4_5 6.16989e-17
C_x_PM_AOI211_X2%4_c2 VSS N_4_M1_d 3.77668e-17
R_x_PM_AOI211_X2%4_r3 N_4_M0_s x_PM_AOI211_X2%4_6 0.198162
R_x_PM_AOI211_X2%4_r4 x_PM_AOI211_X2%4_6 x_PM_AOI211_X2%4_5 1.65571
R_x_PM_AOI211_X2%4_r5 N_4_M1_d x_PM_AOI211_X2%4_5 0.197151
C_x_PM_AOI211_X2%ZN_c0 VSS N_ZN_M7_d 2.00778e-17
C_x_PM_AOI211_X2%ZN_c1 VSS x_PM_AOI211_X2%ZN_20 2.30886e-17
C_x_PM_AOI211_X2%ZN_c2 VSS x_PM_AOI211_X2%ZN_14 5.27425e-17
C_x_PM_AOI211_X2%ZN_c3 VSS x_PM_AOI211_X2%ZN_13 1.69558e-17
C_x_PM_AOI211_X2%ZN_c4 VSS x_PM_AOI211_X2%ZN_12 1.34783e-17
C_x_PM_AOI211_X2%ZN_c5 VSS N_ZN_M0_d 4.67427e-17
C_x_PM_AOI211_X2%ZN_c6 VSS x_PM_AOI211_X2%ZN_8 5.00984e-18
C_x_PM_AOI211_X2%ZN_c7 VSS ZN 9.16659e-17
R_x_PM_AOI211_X2%ZN_r8 x_PM_AOI211_X2%ZN_24 N_ZN_M7_d 0.176429
R_x_PM_AOI211_X2%ZN_r9 x_PM_AOI211_X2%ZN_20 N_ZN_M5_d 0.297071
R_x_PM_AOI211_X2%ZN_r10 x_PM_AOI211_X2%ZN_24 x_PM_AOI211_X2%ZN_14 0.095
R_x_PM_AOI211_X2%ZN_r11 x_PM_AOI211_X2%ZN_20 x_PM_AOI211_X2%ZN_14 1.49286
R_x_PM_AOI211_X2%ZN_r12 x_PM_AOI211_X2%ZN_12 N_ZN_M5_d 0.297071
R_x_PM_AOI211_X2%ZN_r13 x_PM_AOI211_X2%ZN_13 x_PM_AOI211_X2%ZN_12 0.57
R_x_PM_AOI211_X2%ZN_r14 N_ZN_M0_d x_PM_AOI211_X2%ZN_8 0.737647
R_x_PM_AOI211_X2%ZN_r15 x_PM_AOI211_X2%ZN_5 x_PM_AOI211_X2%ZN_8 0.202958
R_x_PM_AOI211_X2%ZN_r16 ZN x_PM_AOI211_X2%ZN_5 2.22571
R_x_PM_AOI211_X2%ZN_r17 x_PM_AOI211_X2%ZN_13 x_PM_AOI211_X2%ZN_4 0.212317
R_x_PM_AOI211_X2%ZN_r18 ZN x_PM_AOI211_X2%ZN_4 0.298571
C_x_PM_AOI211_X2%C1_c0 VSS C1 6.46835e-17
C_x_PM_AOI211_X2%C1_c1 VSS x_PM_AOI211_X2%C1_11 9.0866e-18
C_x_PM_AOI211_X2%C1_c2 VSS N_C1_M1_g 8.55962e-17
C_x_PM_AOI211_X2%C1_c3 VSS N_C1_M5_g 4.63368e-17
R_x_PM_AOI211_X2%C1_r4 x_PM_AOI211_X2%C1_18 x_PM_AOI211_X2%C1_11 4.74714
R_x_PM_AOI211_X2%C1_r5 x_PM_AOI211_X2%C1_17 x_PM_AOI211_X2%C1_11 4.74714
R_x_PM_AOI211_X2%C1_r6 x_PM_AOI211_X2%C1_11 x_PM_AOI211_X2%C1_9 25.0012
R_x_PM_AOI211_X2%C1_r7 C1 x_PM_AOI211_X2%C1_9 0.156071
R_x_PM_AOI211_X2%C1_r8 N_C1_M1_g x_PM_AOI211_X2%C1_18 81.12
R_x_PM_AOI211_X2%C1_r9 N_C1_M5_g x_PM_AOI211_X2%C1_17 36.66
C_x_PM_AOI211_X2%B_c0 VSS B 4.61353e-17
C_x_PM_AOI211_X2%B_c1 VSS x_PM_AOI211_X2%B_11 9.0612e-18
C_x_PM_AOI211_X2%B_c2 VSS N_B_M2_g 8.21992e-17
C_x_PM_AOI211_X2%B_c3 VSS N_B_M6_g 4.53211e-17
R_x_PM_AOI211_X2%B_r4 x_PM_AOI211_X2%B_18 x_PM_AOI211_X2%B_11 4.74714
R_x_PM_AOI211_X2%B_r5 x_PM_AOI211_X2%B_17 x_PM_AOI211_X2%B_11 4.74714
R_x_PM_AOI211_X2%B_r6 x_PM_AOI211_X2%B_11 x_PM_AOI211_X2%B_9 25.0012
R_x_PM_AOI211_X2%B_r7 B x_PM_AOI211_X2%B_9 0.156071
R_x_PM_AOI211_X2%B_r8 N_B_M2_g x_PM_AOI211_X2%B_18 81.9
R_x_PM_AOI211_X2%B_r9 N_B_M6_g x_PM_AOI211_X2%B_17 42.12
C_x_PM_AOI211_X2%A_c0 VSS A 2.23231e-17
C_x_PM_AOI211_X2%A_c1 VSS x_PM_AOI211_X2%A_11 7.12706e-18
C_x_PM_AOI211_X2%A_c2 VSS N_A_M3_g 6.15194e-17
C_x_PM_AOI211_X2%A_c3 VSS N_A_M7_g 6.15951e-17
R_x_PM_AOI211_X2%A_r4 x_PM_AOI211_X2%A_18 x_PM_AOI211_X2%A_11 4.7687
R_x_PM_AOI211_X2%A_r5 x_PM_AOI211_X2%A_17 x_PM_AOI211_X2%A_11 4.7687
R_x_PM_AOI211_X2%A_r6 x_PM_AOI211_X2%A_11 x_PM_AOI211_X2%A_9 25.0012
R_x_PM_AOI211_X2%A_r7 A x_PM_AOI211_X2%A_9 0.158333
R_x_PM_AOI211_X2%A_r8 N_A_M3_g x_PM_AOI211_X2%A_18 49.14
R_x_PM_AOI211_X2%A_r9 N_A_M7_g x_PM_AOI211_X2%A_17 74.88
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI211_X4 VSS VDD C2 ZN C1 B A
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I B:I A:I
M_M6 N_ZN_M0_d N_C2_M0_g N_3_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M7 N_3_M1_d N_C1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M8 N_ZN_M2_d N_C1_M2_g N_3_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M9 N_3_M3_d N_C2_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M10 noxref_9 N_B_M4_g N_3_M3_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M11 N_VDD_M5_d N_A_M5_g noxref_9 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M12 noxref_10 N_A_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M13 N_3_M7_d N_B_M7_g noxref_10 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 11 N_C2_M8_g N_VSS_M8_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M9_d N_C1_M9_g 11 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 12 N_C1_M10_g N_ZN_M9_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M11_d N_C2_M11_g 12 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_ZN_M12_d N_B_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M5 N_VSS_M13_d N_A_M13_g N_ZN_M12_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_AOI211_X4%VSS_c0 VSS x_PM_AOI211_X4%VSS_24 4.10758e-17
C_x_PM_AOI211_X4%VSS_c1 VSS x_PM_AOI211_X4%VSS_23 2.39206e-17
C_x_PM_AOI211_X4%VSS_c2 VSS x_PM_AOI211_X4%VSS_20 6.46344e-17
C_x_PM_AOI211_X4%VSS_c3 VSS N_VSS_M13_d 3.32591e-17
C_x_PM_AOI211_X4%VSS_c4 VSS x_PM_AOI211_X4%VSS_10 2.99886e-17
C_x_PM_AOI211_X4%VSS_c5 VSS x_PM_AOI211_X4%VSS_9 1.08375e-17
C_x_PM_AOI211_X4%VSS_c6 VSS N_VSS_M8_s 2.02738e-17
R_x_PM_AOI211_X4%VSS_r7 x_PM_AOI211_X4%VSS_23 VSS 0.105776
R_x_PM_AOI211_X4%VSS_r8 VSS N_VSS_M11_d 0.034898
R_x_PM_AOI211_X4%VSS_r9 x_PM_AOI211_X4%VSS_20 N_VSS_M11_d 0.140674
R_x_PM_AOI211_X4%VSS_r10 x_PM_AOI211_X4%VSS_24 x_PM_AOI211_X4%VSS_12 0.145286
R_x_PM_AOI211_X4%VSS_r11 N_VSS_M13_d x_PM_AOI211_X4%VSS_12 0.990714
R_x_PM_AOI211_X4%VSS_r12 x_PM_AOI211_X4%VSS_24 x_PM_AOI211_X4%VSS_10 0.0731438
R_x_PM_AOI211_X4%VSS_r13 x_PM_AOI211_X4%VSS_23 x_PM_AOI211_X4%VSS_10 0.614706
R_x_PM_AOI211_X4%VSS_r14 x_PM_AOI211_X4%VSS_9 x_PM_AOI211_X4%VSS_20 1.46412
R_x_PM_AOI211_X4%VSS_r15 x_PM_AOI211_X4%VSS_9 x_PM_AOI211_X4%VSS_4 0.264221
R_x_PM_AOI211_X4%VSS_r16 N_VSS_M8_s x_PM_AOI211_X4%VSS_4 0.990714
C_x_PM_AOI211_X4%VDD_c0 VSS N_VDD_M5_d 9.82757e-17
C_x_PM_AOI211_X4%VDD_c1 VSS x_PM_AOI211_X4%VDD_2 1.48154e-16
R_x_PM_AOI211_X4%VDD_r2 x_PM_AOI211_X4%VDD_2 N_VDD_M5_d 0.140674
R_x_PM_AOI211_X4%VDD_r3 VDD x_PM_AOI211_X4%VDD_2 0.648235
C_x_PM_AOI211_X4%3_c0 VSS N_3_M0_s 3.26156e-17
C_x_PM_AOI211_X4%3_c1 VSS x_PM_AOI211_X4%3_7 2.15399e-16
C_x_PM_AOI211_X4%3_c2 VSS N_3_M7_d 2.16139e-17
R_x_PM_AOI211_X4%3_r3 N_3_M3_d N_3_M1_d 2.09
R_x_PM_AOI211_X4%3_r4 N_3_M0_s x_PM_AOI211_X4%3_8 0.198162
R_x_PM_AOI211_X4%3_r5 N_3_M1_d x_PM_AOI211_X4%3_8 1.83214
R_x_PM_AOI211_X4%3_r6 x_PM_AOI211_X4%3_13 x_PM_AOI211_X4%3_7 0.212317
R_x_PM_AOI211_X4%3_r7 N_3_M3_d x_PM_AOI211_X4%3_7 3.895
R_x_PM_AOI211_X4%3_r8 N_3_M7_d x_PM_AOI211_X4%3_13 0.149286
C_x_PM_AOI211_X4%C2_c0 VSS x_PM_AOI211_X4%C2_36 1.27633e-17
C_x_PM_AOI211_X4%C2_c1 VSS C2 3.81017e-17
C_x_PM_AOI211_X4%C2_c2 VSS x_PM_AOI211_X4%C2_25 3.42546e-17
C_x_PM_AOI211_X4%C2_c3 VSS x_PM_AOI211_X4%C2_23 5.03763e-18
C_x_PM_AOI211_X4%C2_c4 VSS x_PM_AOI211_X4%C2_22 1.27923e-16
C_x_PM_AOI211_X4%C2_c5 VSS x_PM_AOI211_X4%C2_20 7.47264e-18
C_x_PM_AOI211_X4%C2_c6 VSS x_PM_AOI211_X4%C2_18 9.60237e-18
C_x_PM_AOI211_X4%C2_c7 VSS N_C2_M3_g 6.81539e-17
C_x_PM_AOI211_X4%C2_c8 VSS N_C2_M11_g 6.53655e-17
C_x_PM_AOI211_X4%C2_c9 VSS N_C2_M0_g 6.42691e-17
C_x_PM_AOI211_X4%C2_c10 VSS N_C2_M8_g 6.24966e-17
R_x_PM_AOI211_X4%C2_r11 x_PM_AOI211_X4%C2_36 x_PM_AOI211_X4%C2_27 5.46
R_x_PM_AOI211_X4%C2_r12 x_PM_AOI211_X4%C2_27 x_PM_AOI211_X4%C2_25 25.0012
R_x_PM_AOI211_X4%C2_r13 C2 x_PM_AOI211_X4%C2_25 0.305689
R_x_PM_AOI211_X4%C2_r14 C2 x_PM_AOI211_X4%C2_22 0.189578
R_x_PM_AOI211_X4%C2_r15 x_PM_AOI211_X4%C2_23 x_PM_AOI211_X4%C2_22 2.22571
R_x_PM_AOI211_X4%C2_r16 x_PM_AOI211_X4%C2_33 x_PM_AOI211_X4%C2_20 4.7687
R_x_PM_AOI211_X4%C2_r17 x_PM_AOI211_X4%C2_32 x_PM_AOI211_X4%C2_20 4.7687
R_x_PM_AOI211_X4%C2_r18 x_PM_AOI211_X4%C2_20 x_PM_AOI211_X4%C2_18 25.0012
R_x_PM_AOI211_X4%C2_r19 x_PM_AOI211_X4%C2_23 x_PM_AOI211_X4%C2_17 0.212317
R_x_PM_AOI211_X4%C2_r20 x_PM_AOI211_X4%C2_18 x_PM_AOI211_X4%C2_17 0.393571
R_x_PM_AOI211_X4%C2_r21 x_PM_AOI211_X4%C2_36 x_PM_AOI211_X4%C2_13 1.95
R_x_PM_AOI211_X4%C2_r22 N_C2_M3_g x_PM_AOI211_X4%C2_13 49.14
R_x_PM_AOI211_X4%C2_r23 x_PM_AOI211_X4%C2_36 x_PM_AOI211_X4%C2_9 1.95
R_x_PM_AOI211_X4%C2_r24 N_C2_M11_g x_PM_AOI211_X4%C2_9 68.64
R_x_PM_AOI211_X4%C2_r25 N_C2_M0_g x_PM_AOI211_X4%C2_33 49.14
R_x_PM_AOI211_X4%C2_r26 N_C2_M8_g x_PM_AOI211_X4%C2_32 68.64
C_x_PM_AOI211_X4%ZN_c0 VSS ZN 5.42366e-17
C_x_PM_AOI211_X4%ZN_c1 VSS x_PM_AOI211_X4%ZN_16 8.90546e-17
C_x_PM_AOI211_X4%ZN_c2 VSS x_PM_AOI211_X4%ZN_11 4.45477e-17
C_x_PM_AOI211_X4%ZN_c3 VSS x_PM_AOI211_X4%ZN_5 1.68131e-16
R_x_PM_AOI211_X4%ZN_r4 N_ZN_M12_d ZN 0.677128
R_x_PM_AOI211_X4%ZN_r5 ZN x_PM_AOI211_X4%ZN_17 0.141489
R_x_PM_AOI211_X4%ZN_r6 x_PM_AOI211_X4%ZN_17 x_PM_AOI211_X4%ZN_15 0.141489
R_x_PM_AOI211_X4%ZN_r7 x_PM_AOI211_X4%ZN_16 x_PM_AOI211_X4%ZN_15 2.63286
R_x_PM_AOI211_X4%ZN_r8 x_PM_AOI211_X4%ZN_17 x_PM_AOI211_X4%ZN_11 0.167075
R_x_PM_AOI211_X4%ZN_r9 N_ZN_M9_d x_PM_AOI211_X4%ZN_11 1.77786
R_x_PM_AOI211_X4%ZN_r10 N_ZN_M2_d N_ZN_M0_d 2.03571
R_x_PM_AOI211_X4%ZN_r11 x_PM_AOI211_X4%ZN_16 x_PM_AOI211_X4%ZN_5 0.212317
R_x_PM_AOI211_X4%ZN_r12 N_ZN_M2_d x_PM_AOI211_X4%ZN_5 0.773571
C_x_PM_AOI211_X4%C1_c0 VSS C1 6.20853e-17
C_x_PM_AOI211_X4%C1_c1 VSS x_PM_AOI211_X4%C1_20 4.61826e-18
C_x_PM_AOI211_X4%C1_c2 VSS x_PM_AOI211_X4%C1_19 5.15466e-18
C_x_PM_AOI211_X4%C1_c3 VSS x_PM_AOI211_X4%C1_18 3.36087e-18
C_x_PM_AOI211_X4%C1_c4 VSS N_C1_M2_g 6.19245e-17
C_x_PM_AOI211_X4%C1_c5 VSS N_C1_M10_g 4.43238e-17
C_x_PM_AOI211_X4%C1_c6 VSS N_C1_M1_g 6.1023e-17
C_x_PM_AOI211_X4%C1_c7 VSS N_C1_M9_g 3.98629e-17
R_x_PM_AOI211_X4%C1_r8 x_PM_AOI211_X4%C1_23 x_PM_AOI211_X4%C1_21 25.0012
R_x_PM_AOI211_X4%C1_r9 C1 x_PM_AOI211_X4%C1_21 0.0475
R_x_PM_AOI211_X4%C1_r10 x_PM_AOI211_X4%C1_23 x_PM_AOI211_X4%C1_19 7.02
R_x_PM_AOI211_X4%C1_r11 x_PM_AOI211_X4%C1_20 x_PM_AOI211_X4%C1_19 0.043368
R_x_PM_AOI211_X4%C1_r12 x_PM_AOI211_X4%C1_23 x_PM_AOI211_X4%C1_17 7.54
R_x_PM_AOI211_X4%C1_r13 x_PM_AOI211_X4%C1_18 x_PM_AOI211_X4%C1_17 0.043368
R_x_PM_AOI211_X4%C1_r14 x_PM_AOI211_X4%C1_20 x_PM_AOI211_X4%C1_13 4.56151
R_x_PM_AOI211_X4%C1_r15 N_C1_M2_g x_PM_AOI211_X4%C1_13 59.28
R_x_PM_AOI211_X4%C1_r16 x_PM_AOI211_X4%C1_20 x_PM_AOI211_X4%C1_9 4.56151
R_x_PM_AOI211_X4%C1_r17 N_C1_M10_g x_PM_AOI211_X4%C1_9 58.5
R_x_PM_AOI211_X4%C1_r18 x_PM_AOI211_X4%C1_18 x_PM_AOI211_X4%C1_5 4.56151
R_x_PM_AOI211_X4%C1_r19 N_C1_M1_g x_PM_AOI211_X4%C1_5 59.28
R_x_PM_AOI211_X4%C1_r20 x_PM_AOI211_X4%C1_18 x_PM_AOI211_X4%C1_VSS 4.56151
R_x_PM_AOI211_X4%C1_r21 N_C1_M9_g x_PM_AOI211_X4%C1_VSS 58.5
C_x_PM_AOI211_X4%B_c0 VSS x_PM_AOI211_X4%B_26 8.50053e-18
C_x_PM_AOI211_X4%B_c1 VSS x_PM_AOI211_X4%B_21 9.29915e-18
C_x_PM_AOI211_X4%B_c2 VSS x_PM_AOI211_X4%B_19 3.44602e-17
C_x_PM_AOI211_X4%B_c3 VSS B 1.28893e-17
C_x_PM_AOI211_X4%B_c4 VSS x_PM_AOI211_X4%B_15 3.62788e-18
C_x_PM_AOI211_X4%B_c5 VSS x_PM_AOI211_X4%B_13 4.10653e-17
C_x_PM_AOI211_X4%B_c6 VSS N_B_M7_g 6.57251e-17
C_x_PM_AOI211_X4%B_c7 VSS N_B_M4_g 6.5404e-17
C_x_PM_AOI211_X4%B_c8 VSS N_B_M12_g 6.62272e-17
R_x_PM_AOI211_X4%B_r9 x_PM_AOI211_X4%B_33 x_PM_AOI211_X4%B_26 4.7687
R_x_PM_AOI211_X4%B_r10 x_PM_AOI211_X4%B_26 x_PM_AOI211_X4%B_25 25.0012
R_x_PM_AOI211_X4%B_r11 x_PM_AOI211_X4%B_21 x_PM_AOI211_X4%B_27 2.34
R_x_PM_AOI211_X4%B_r12 x_PM_AOI211_X4%B_21 x_PM_AOI211_X4%B_19 25.0012
R_x_PM_AOI211_X4%B_r13 x_PM_AOI211_X4%B_23 x_PM_AOI211_X4%B_19 0.176429
R_x_PM_AOI211_X4%B_r14 x_PM_AOI211_X4%B_25 x_PM_AOI211_X4%B_15 0.0505203
R_x_PM_AOI211_X4%B_r15 B x_PM_AOI211_X4%B_15 0.19
R_x_PM_AOI211_X4%B_r16 x_PM_AOI211_X4%B_23 x_PM_AOI211_X4%B_14 0.095
R_x_PM_AOI211_X4%B_r17 x_PM_AOI211_X4%B_25 x_PM_AOI211_X4%B_13 0.187647
R_x_PM_AOI211_X4%B_r18 x_PM_AOI211_X4%B_14 x_PM_AOI211_X4%B_13 2.17143
R_x_PM_AOI211_X4%B_r19 N_B_M7_g x_PM_AOI211_X4%B_33 49.14
R_x_PM_AOI211_X4%B_r20 x_PM_AOI211_X4%B_27 x_PM_AOI211_X4%B_5 1.95
R_x_PM_AOI211_X4%B_r21 N_B_M4_g x_PM_AOI211_X4%B_5 49.14
R_x_PM_AOI211_X4%B_r22 x_PM_AOI211_X4%B_27 x_PM_AOI211_X4%B_VSS 1.95
R_x_PM_AOI211_X4%B_r23 N_B_M12_g x_PM_AOI211_X4%B_VSS 60.84
C_x_PM_AOI211_X4%A_c0 VSS A 4.56436e-17
C_x_PM_AOI211_X4%A_c1 VSS x_PM_AOI211_X4%A_15 1.40847e-17
C_x_PM_AOI211_X4%A_c2 VSS x_PM_AOI211_X4%A_14 3.56639e-18
C_x_PM_AOI211_X4%A_c3 VSS N_A_M6_g 6.59049e-17
C_x_PM_AOI211_X4%A_c4 VSS N_A_M5_g 6.39253e-17
C_x_PM_AOI211_X4%A_c5 VSS N_A_M13_g 4.85331e-17
R_x_PM_AOI211_X4%A_r6 x_PM_AOI211_X4%A_18 x_PM_AOI211_X4%A_16 25.0012
R_x_PM_AOI211_X4%A_r7 A x_PM_AOI211_X4%A_16 0.202258
R_x_PM_AOI211_X4%A_r8 x_PM_AOI211_X4%A_18 x_PM_AOI211_X4%A_15 13.78
R_x_PM_AOI211_X4%A_r9 x_PM_AOI211_X4%A_18 x_PM_AOI211_X4%A_13 0.78
R_x_PM_AOI211_X4%A_r10 x_PM_AOI211_X4%A_14 x_PM_AOI211_X4%A_13 0.043368
R_x_PM_AOI211_X4%A_r11 x_PM_AOI211_X4%A_15 x_PM_AOI211_X4%A_9 4.58872
R_x_PM_AOI211_X4%A_r12 N_A_M6_g x_PM_AOI211_X4%A_9 74.1
R_x_PM_AOI211_X4%A_r13 x_PM_AOI211_X4%A_14 x_PM_AOI211_X4%A_5 4.56151
R_x_PM_AOI211_X4%A_r14 N_A_M5_g x_PM_AOI211_X4%A_5 74.1
R_x_PM_AOI211_X4%A_r15 x_PM_AOI211_X4%A_14 x_PM_AOI211_X4%A_VSS 4.56151
R_x_PM_AOI211_X4%A_r16 N_A_M13_g x_PM_AOI211_X4%A_VSS 35.88
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X1 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B B2:I ZN:O B1:I A:I
M_M3 N_ZN_M0_d N_B2_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M4 N_3_M1_d N_B1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_VDD_M2_d N_A_M2_g N_3_M1_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 noxref_8 N_B2_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_ZN_M4_d N_B1_M4_g noxref_8 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_VSS_M5_d N_A_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_AOI21_X1%VSS_c0 VSS N_VSS_M5_d 1.96656e-17
C_x_PM_AOI21_X1%VSS_c1 VSS x_PM_AOI21_X1%VSS_8 1.07554e-17
C_x_PM_AOI21_X1%VSS_c2 VSS x_PM_AOI21_X1%VSS_7 8.94888e-17
C_x_PM_AOI21_X1%VSS_c3 VSS N_VSS_M3_s 2.15137e-17
R_x_PM_AOI21_X1%VSS_r4 N_VSS_M5_d x_PM_AOI21_X1%VSS_11 0.637857
R_x_PM_AOI21_X1%VSS_r5 VSS x_PM_AOI21_X1%VSS_8 0.603529
R_x_PM_AOI21_X1%VSS_r6 x_PM_AOI21_X1%VSS_11 x_PM_AOI21_X1%VSS_7 0.264221
R_x_PM_AOI21_X1%VSS_r7 VSS x_PM_AOI21_X1%VSS_7 0.502941
R_x_PM_AOI21_X1%VSS_r8 x_PM_AOI21_X1%VSS_8 x_PM_AOI21_X1%VSS_3 0.264221
R_x_PM_AOI21_X1%VSS_r9 N_VSS_M3_s x_PM_AOI21_X1%VSS_3 0.637857
C_x_PM_AOI21_X1%VDD_c0 VSS N_VDD_M2_d 2.43122e-17
C_x_PM_AOI21_X1%VDD_c1 VSS x_PM_AOI21_X1%VDD_2 1.38352e-16
R_x_PM_AOI21_X1%VDD_r2 N_VDD_M2_d x_PM_AOI21_X1%VDD_6 0.800714
R_x_PM_AOI21_X1%VDD_r3 x_PM_AOI21_X1%VDD_6 x_PM_AOI21_X1%VDD_2 0.264221
R_x_PM_AOI21_X1%VDD_r4 VDD x_PM_AOI21_X1%VDD_2 0.676176
C_x_PM_AOI21_X1%3_c0 VSS N_3_M0_s 2.31271e-17
C_x_PM_AOI21_X1%3_c1 VSS x_PM_AOI21_X1%3_3 7.6419e-17
C_x_PM_AOI21_X1%3_c2 VSS N_3_M1_d 3.42205e-17
R_x_PM_AOI21_X1%3_r3 x_PM_AOI21_X1%3_8 N_3_M0_s 0.257857
R_x_PM_AOI21_X1%3_r4 x_PM_AOI21_X1%3_8 x_PM_AOI21_X1%3_4 0.095
R_x_PM_AOI21_X1%3_r5 x_PM_AOI21_X1%3_13 x_PM_AOI21_X1%3_3 0.095
R_x_PM_AOI21_X1%3_r6 x_PM_AOI21_X1%3_4 x_PM_AOI21_X1%3_3 1.62857
R_x_PM_AOI21_X1%3_r7 x_PM_AOI21_X1%3_13 N_3_M1_d 0.257857
C_x_PM_AOI21_X1%B2_c0 VSS x_PM_AOI21_X1%B2_18 8.00781e-18
C_x_PM_AOI21_X1%B2_c1 VSS x_PM_AOI21_X1%B2_12 3.51074e-17
C_x_PM_AOI21_X1%B2_c2 VSS N_B2_M0_g 7.07995e-17
C_x_PM_AOI21_X1%B2_c3 VSS N_B2_M3_g 3.58176e-17
R_x_PM_AOI21_X1%B2_r4 x_PM_AOI21_X1%B2_18 x_PM_AOI21_X1%B2_14 3.38
R_x_PM_AOI21_X1%B2_r5 x_PM_AOI21_X1%B2_14 x_PM_AOI21_X1%B2_12 25.0012
R_x_PM_AOI21_X1%B2_r6 x_PM_AOI21_X1%B2_12 B2 0.115357
R_x_PM_AOI21_X1%B2_r7 x_PM_AOI21_X1%B2_18 x_PM_AOI21_X1%B2_5 1.95
R_x_PM_AOI21_X1%B2_r8 N_B2_M0_g x_PM_AOI21_X1%B2_5 90.09
R_x_PM_AOI21_X1%B2_r9 x_PM_AOI21_X1%B2_18 x_PM_AOI21_X1%B2_VSS 1.95
R_x_PM_AOI21_X1%B2_r10 N_B2_M3_g x_PM_AOI21_X1%B2_VSS 35.1
C_x_PM_AOI21_X1%ZN_c0 VSS x_PM_AOI21_X1%ZN_13 9.91401e-17
C_x_PM_AOI21_X1%ZN_c1 VSS x_PM_AOI21_X1%ZN_12 1.02002e-16
C_x_PM_AOI21_X1%ZN_c2 VSS ZN 5.49481e-17
C_x_PM_AOI21_X1%ZN_c3 VSS x_PM_AOI21_X1%ZN_5 5.76237e-18
R_x_PM_AOI21_X1%ZN_r4 x_PM_AOI21_X1%ZN_12 N_ZN_M4_d 0.347287
R_x_PM_AOI21_X1%ZN_r5 N_ZN_M0_d ZN 0.614706
R_x_PM_AOI21_X1%ZN_r6 x_PM_AOI21_X1%ZN_13 x_PM_AOI21_X1%ZN_5 0.202958
R_x_PM_AOI21_X1%ZN_r7 ZN x_PM_AOI21_X1%ZN_5 0.122941
R_x_PM_AOI21_X1%ZN_r8 x_PM_AOI21_X1%ZN_12 x_PM_AOI21_X1%ZN_3 0.241334
R_x_PM_AOI21_X1%ZN_r9 x_PM_AOI21_X1%ZN_13 x_PM_AOI21_X1%ZN_3 3.01286
C_x_PM_AOI21_X1%B1_c0 VSS B1 6.27218e-17
C_x_PM_AOI21_X1%B1_c1 VSS x_PM_AOI21_X1%B1_11 1.15297e-17
C_x_PM_AOI21_X1%B1_c2 VSS N_B1_M1_g 7.91698e-17
C_x_PM_AOI21_X1%B1_c3 VSS N_B1_M4_g 3.67129e-17
R_x_PM_AOI21_X1%B1_r4 x_PM_AOI21_X1%B1_11 x_PM_AOI21_X1%B1_16 4.42
R_x_PM_AOI21_X1%B1_r5 x_PM_AOI21_X1%B1_11 x_PM_AOI21_X1%B1_9 25.0012
R_x_PM_AOI21_X1%B1_r6 B1 x_PM_AOI21_X1%B1_9 0.157429
R_x_PM_AOI21_X1%B1_r7 x_PM_AOI21_X1%B1_16 x_PM_AOI21_X1%B1_5 1.95
R_x_PM_AOI21_X1%B1_r8 N_B1_M1_g x_PM_AOI21_X1%B1_5 96.33
R_x_PM_AOI21_X1%B1_r9 x_PM_AOI21_X1%B1_16 x_PM_AOI21_X1%B1_VSS 1.95
R_x_PM_AOI21_X1%B1_r10 N_B1_M4_g x_PM_AOI21_X1%B1_VSS 28.86
C_x_PM_AOI21_X1%A_c0 VSS A 1.771e-17
C_x_PM_AOI21_X1%A_c1 VSS x_PM_AOI21_X1%A_11 6.60297e-18
C_x_PM_AOI21_X1%A_c2 VSS N_A_M2_g 4.52709e-17
C_x_PM_AOI21_X1%A_c3 VSS N_A_M5_g 5.95109e-17
R_x_PM_AOI21_X1%A_r4 x_PM_AOI21_X1%A_18 x_PM_AOI21_X1%A_11 4.7687
R_x_PM_AOI21_X1%A_r5 x_PM_AOI21_X1%A_17 x_PM_AOI21_X1%A_11 4.7687
R_x_PM_AOI21_X1%A_r6 x_PM_AOI21_X1%A_11 x_PM_AOI21_X1%A_9 25.0012
R_x_PM_AOI21_X1%A_r7 A x_PM_AOI21_X1%A_9 0.278214
R_x_PM_AOI21_X1%A_r8 N_A_M2_g x_PM_AOI21_X1%A_18 46.41
R_x_PM_AOI21_X1%A_r9 N_A_M5_g x_PM_AOI21_X1%A_17 81.9
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X2 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A:I
M_M3 N_ZN_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M4 N_4_M1_d N_B1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_VDD_M2_d N_A_M2_g N_4_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 noxref_8 N_B2_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M4_d N_B1_M4_g noxref_8 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_VSS_M5_d N_A_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_AOI21_X2%VSS_c0 VSS N_VSS_M5_d 1.96247e-17
C_x_PM_AOI21_X2%VSS_c1 VSS x_PM_AOI21_X2%VSS_8 1.15635e-17
C_x_PM_AOI21_X2%VSS_c2 VSS x_PM_AOI21_X2%VSS_7 6.95795e-17
C_x_PM_AOI21_X2%VSS_c3 VSS N_VSS_M3_s 1.75183e-17
R_x_PM_AOI21_X2%VSS_r4 N_VSS_M5_d x_PM_AOI21_X2%VSS_11 0.230714
R_x_PM_AOI21_X2%VSS_r5 VSS x_PM_AOI21_X2%VSS_8 0.57
R_x_PM_AOI21_X2%VSS_r6 x_PM_AOI21_X2%VSS_11 x_PM_AOI21_X2%VSS_7 0.264221
R_x_PM_AOI21_X2%VSS_r7 VSS x_PM_AOI21_X2%VSS_7 0.536471
R_x_PM_AOI21_X2%VSS_r8 x_PM_AOI21_X2%VSS_8 x_PM_AOI21_X2%VSS_3 0.264221
R_x_PM_AOI21_X2%VSS_r9 N_VSS_M3_s x_PM_AOI21_X2%VSS_3 0.230714
C_x_PM_AOI21_X2%VDD_c0 VSS N_VDD_M2_d 3.46512e-17
C_x_PM_AOI21_X2%VDD_c1 VSS x_PM_AOI21_X2%VDD_2 1.38921e-16
R_x_PM_AOI21_X2%VDD_r2 N_VDD_M2_d x_PM_AOI21_X2%VDD_6 0.502143
R_x_PM_AOI21_X2%VDD_r3 x_PM_AOI21_X2%VDD_6 x_PM_AOI21_X2%VDD_2 0.264221
R_x_PM_AOI21_X2%VDD_r4 VDD x_PM_AOI21_X2%VDD_2 0.692941
C_x_PM_AOI21_X2%B2_c0 VSS x_PM_AOI21_X2%B2_18 8.47439e-18
C_x_PM_AOI21_X2%B2_c1 VSS B2 6.27256e-17
C_x_PM_AOI21_X2%B2_c2 VSS N_B2_M0_g 8.26488e-17
C_x_PM_AOI21_X2%B2_c3 VSS N_B2_M3_g 3.61799e-17
R_x_PM_AOI21_X2%B2_r4 x_PM_AOI21_X2%B2_18 x_PM_AOI21_X2%B2_14 3.38
R_x_PM_AOI21_X2%B2_r5 x_PM_AOI21_X2%B2_14 x_PM_AOI21_X2%B2_12 25.0012
R_x_PM_AOI21_X2%B2_r6 x_PM_AOI21_X2%B2_12 B2 0.266
R_x_PM_AOI21_X2%B2_r7 x_PM_AOI21_X2%B2_18 x_PM_AOI21_X2%B2_5 1.95
R_x_PM_AOI21_X2%B2_r8 N_B2_M0_g x_PM_AOI21_X2%B2_5 92.04
R_x_PM_AOI21_X2%B2_r9 x_PM_AOI21_X2%B2_18 x_PM_AOI21_X2%B2_VSS 1.95
R_x_PM_AOI21_X2%B2_r10 N_B2_M3_g x_PM_AOI21_X2%B2_VSS 28.08
C_x_PM_AOI21_X2%4_c0 VSS N_4_M0_s 3.94486e-17
C_x_PM_AOI21_X2%4_c1 VSS x_PM_AOI21_X2%4_5 9.3569e-17
C_x_PM_AOI21_X2%4_c2 VSS N_4_M1_d 7.07659e-17
R_x_PM_AOI21_X2%4_r3 N_4_M0_s x_PM_AOI21_X2%4_6 0.198162
R_x_PM_AOI21_X2%4_r4 x_PM_AOI21_X2%4_6 x_PM_AOI21_X2%4_5 1.62857
R_x_PM_AOI21_X2%4_r5 N_4_M1_d x_PM_AOI21_X2%4_5 0.198162
C_x_PM_AOI21_X2%B1_c0 VSS x_PM_AOI21_X2%B1_18 1.03997e-17
C_x_PM_AOI21_X2%B1_c1 VSS B1 9.4718e-17
C_x_PM_AOI21_X2%B1_c2 VSS N_B1_M1_g 8.9669e-17
C_x_PM_AOI21_X2%B1_c3 VSS N_B1_M4_g 3.73017e-17
R_x_PM_AOI21_X2%B1_r4 x_PM_AOI21_X2%B1_18 x_PM_AOI21_X2%B1_14 3.38
R_x_PM_AOI21_X2%B1_r5 x_PM_AOI21_X2%B1_14 x_PM_AOI21_X2%B1_12 25.0012
R_x_PM_AOI21_X2%B1_r6 x_PM_AOI21_X2%B1_12 B1 0.266
R_x_PM_AOI21_X2%B1_r7 x_PM_AOI21_X2%B1_18 x_PM_AOI21_X2%B1_5 1.95
R_x_PM_AOI21_X2%B1_r8 N_B1_M1_g x_PM_AOI21_X2%B1_5 92.04
R_x_PM_AOI21_X2%B1_r9 x_PM_AOI21_X2%B1_18 x_PM_AOI21_X2%B1_VSS 1.95
R_x_PM_AOI21_X2%B1_r10 N_B1_M4_g x_PM_AOI21_X2%B1_VSS 28.08
C_x_PM_AOI21_X2%ZN_c0 VSS N_ZN_M4_d 1.36891e-16
C_x_PM_AOI21_X2%ZN_c1 VSS x_PM_AOI21_X2%ZN_8 7.87972e-18
C_x_PM_AOI21_X2%ZN_c2 VSS x_PM_AOI21_X2%ZN_7 3.43627e-17
C_x_PM_AOI21_X2%ZN_c3 VSS N_ZN_M0_d 4.85229e-17
R_x_PM_AOI21_X2%ZN_r4 ZN N_ZN_M4_d 2.91786
R_x_PM_AOI21_X2%ZN_r5 ZN x_PM_AOI21_X2%ZN_9 0.38
R_x_PM_AOI21_X2%ZN_r6 x_PM_AOI21_X2%ZN_9 x_PM_AOI21_X2%ZN_7 0.212317
R_x_PM_AOI21_X2%ZN_r7 x_PM_AOI21_X2%ZN_8 x_PM_AOI21_X2%ZN_7 0.651429
R_x_PM_AOI21_X2%ZN_r8 x_PM_AOI21_X2%ZN_8 x_PM_AOI21_X2%ZN_3 0.212317
R_x_PM_AOI21_X2%ZN_r9 N_ZN_M0_d x_PM_AOI21_X2%ZN_3 0.746429
C_x_PM_AOI21_X2%A_c0 VSS A 4.55803e-17
C_x_PM_AOI21_X2%A_c1 VSS x_PM_AOI21_X2%A_11 9.00721e-18
C_x_PM_AOI21_X2%A_c2 VSS N_A_M2_g 9.08264e-17
C_x_PM_AOI21_X2%A_c3 VSS N_A_M5_g 3.07841e-17
R_x_PM_AOI21_X2%A_r4 x_PM_AOI21_X2%A_11 x_PM_AOI21_X2%A_16 4.42
R_x_PM_AOI21_X2%A_r5 x_PM_AOI21_X2%A_11 x_PM_AOI21_X2%A_9 25.0012
R_x_PM_AOI21_X2%A_r6 A x_PM_AOI21_X2%A_9 0.15069
R_x_PM_AOI21_X2%A_r7 x_PM_AOI21_X2%A_16 x_PM_AOI21_X2%A_5 1.95
R_x_PM_AOI21_X2%A_r8 N_A_M2_g x_PM_AOI21_X2%A_5 104.52
R_x_PM_AOI21_X2%A_r9 x_PM_AOI21_X2%A_16 x_PM_AOI21_X2%A_VSS 1.95
R_x_PM_AOI21_X2%A_r10 N_A_M5_g x_PM_AOI21_X2%A_VSS 21.84
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI21_X4 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B ZN:O B1:I B2:I A:I
M_M5 N_ZN_M0_d N_B1_M0_g N_4_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_4_M1_d N_B2_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_ZN_M2_d N_B2_M2_g N_4_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M8 N_4_M3_d N_B1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_VDD_M4_d N_A_M4_g N_4_M3_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 N_4_M5_d N_A_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 8 N_B1_M6_g N_ZN_M6_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_VSS_M7_d N_B2_M7_g 8 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 9 N_B2_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_ZN_M9_d N_B1_M9_g 9 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M10_d N_A_M10_g N_ZN_M9_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_AOI21_X4%VSS_c0 VSS x_PM_AOI21_X4%VSS_19 2.56278e-17
C_x_PM_AOI21_X4%VSS_c1 VSS N_VSS_M7_d 5.17329e-17
C_x_PM_AOI21_X4%VSS_c2 VSS N_VSS_M10_d 2.64986e-17
C_x_PM_AOI21_X4%VSS_c3 VSS x_PM_AOI21_X4%VSS_6 3.3883e-17
C_x_PM_AOI21_X4%VSS_c4 VSS x_PM_AOI21_X4%VSS_5 5.43258e-17
R_x_PM_AOI21_X4%VSS_r5 x_PM_AOI21_X4%VSS_19 x_PM_AOI21_X4%VSS_9 0.145286
R_x_PM_AOI21_X4%VSS_r6 N_VSS_M10_d x_PM_AOI21_X4%VSS_9 0.990714
R_x_PM_AOI21_X4%VSS_r7 x_PM_AOI21_X4%VSS_6 N_VSS_M7_d 0.140674
R_x_PM_AOI21_X4%VSS_r8 VSS x_PM_AOI21_X4%VSS_6 0.279412
R_x_PM_AOI21_X4%VSS_r9 x_PM_AOI21_X4%VSS_19 x_PM_AOI21_X4%VSS_5 0.0731438
R_x_PM_AOI21_X4%VSS_r10 VSS x_PM_AOI21_X4%VSS_5 0.76
C_x_PM_AOI21_X4%VDD_c0 VSS N_VDD_M4_d 6.59668e-17
C_x_PM_AOI21_X4%VDD_c1 VSS x_PM_AOI21_X4%VDD_2 1.20273e-16
R_x_PM_AOI21_X4%VDD_r2 x_PM_AOI21_X4%VDD_2 N_VDD_M4_d 0.141744
R_x_PM_AOI21_X4%VDD_r3 VDD x_PM_AOI21_X4%VDD_2 0.692941
C_x_PM_AOI21_X4%ZN_c0 VSS x_PM_AOI21_X4%ZN_20 4.801e-17
C_x_PM_AOI21_X4%ZN_c1 VSS ZN 1.99045e-17
C_x_PM_AOI21_X4%ZN_c2 VSS N_ZN_M2_d 9.54457e-17
C_x_PM_AOI21_X4%ZN_c3 VSS N_ZN_M9_d 1.42429e-16
C_x_PM_AOI21_X4%ZN_c4 VSS x_PM_AOI21_X4%ZN_5 8.60984e-18
R_x_PM_AOI21_X4%ZN_r5 x_PM_AOI21_X4%ZN_21 ZN 0.168889
R_x_PM_AOI21_X4%ZN_r6 x_PM_AOI21_X4%ZN_20 ZN 0.315335
R_x_PM_AOI21_X4%ZN_r7 N_ZN_M2_d N_ZN_M0_d 2.06286
R_x_PM_AOI21_X4%ZN_r8 x_PM_AOI21_X4%ZN_21 x_PM_AOI21_X4%ZN_11 0.095
R_x_PM_AOI21_X4%ZN_r9 N_ZN_M0_d x_PM_AOI21_X4%ZN_11 0.827857
R_x_PM_AOI21_X4%ZN_r10 N_ZN_M6_s x_PM_AOI21_X4%ZN_7 0.197151
R_x_PM_AOI21_X4%ZN_r11 N_ZN_M9_d x_PM_AOI21_X4%ZN_7 4.03071
R_x_PM_AOI21_X4%ZN_r12 N_ZN_M6_s x_PM_AOI21_X4%ZN_5 0.0151655
R_x_PM_AOI21_X4%ZN_r13 x_PM_AOI21_X4%ZN_20 x_PM_AOI21_X4%ZN_5 2.85
C_x_PM_AOI21_X4%4_c0 VSS x_PM_AOI21_X4%4_15 2.51992e-17
C_x_PM_AOI21_X4%4_c1 VSS x_PM_AOI21_X4%4_5 1.72997e-16
C_x_PM_AOI21_X4%4_c2 VSS N_4_M5_d 1.51109e-17
R_x_PM_AOI21_X4%4_r3 N_4_M0_s x_PM_AOI21_X4%4_15 0.203571
R_x_PM_AOI21_X4%4_r4 N_4_M3_d N_4_M1_d 2.06286
R_x_PM_AOI21_X4%4_r5 x_PM_AOI21_X4%4_15 x_PM_AOI21_X4%4_6 0.095
R_x_PM_AOI21_X4%4_r6 N_4_M1_d x_PM_AOI21_X4%4_6 1.83214
R_x_PM_AOI21_X4%4_r7 x_PM_AOI21_X4%4_11 x_PM_AOI21_X4%4_5 0.212317
R_x_PM_AOI21_X4%4_r8 N_4_M3_d x_PM_AOI21_X4%4_5 1.85929
R_x_PM_AOI21_X4%4_r9 N_4_M5_d x_PM_AOI21_X4%4_11 0.502143
C_x_PM_AOI21_X4%B1_c0 VSS x_PM_AOI21_X4%B1_27 8.27655e-18
C_x_PM_AOI21_X4%B1_c1 VSS x_PM_AOI21_X4%B1_25 2.44139e-17
C_x_PM_AOI21_X4%B1_c2 VSS x_PM_AOI21_X4%B1_24 8.58555e-17
C_x_PM_AOI21_X4%B1_c3 VSS x_PM_AOI21_X4%B1_20 1.56138e-17
C_x_PM_AOI21_X4%B1_c4 VSS N_B1_M3_g 8.41414e-17
C_x_PM_AOI21_X4%B1_c5 VSS N_B1_M9_g 4.5835e-17
C_x_PM_AOI21_X4%B1_c6 VSS N_B1_M0_g 9.78625e-17
C_x_PM_AOI21_X4%B1_c7 VSS N_B1_M6_g 4.20275e-17
R_x_PM_AOI21_X4%B1_r8 x_PM_AOI21_X4%B1_35 x_PM_AOI21_X4%B1_27 4.7687
R_x_PM_AOI21_X4%B1_r9 x_PM_AOI21_X4%B1_34 x_PM_AOI21_X4%B1_27 4.7687
R_x_PM_AOI21_X4%B1_r10 x_PM_AOI21_X4%B1_27 x_PM_AOI21_X4%B1_25 25.0012
R_x_PM_AOI21_X4%B1_r11 x_PM_AOI21_X4%B1_25 B1 0.223929
R_x_PM_AOI21_X4%B1_r12 x_PM_AOI21_X4%B1_24 B1 0.189936
R_x_PM_AOI21_X4%B1_r13 x_PM_AOI21_X4%B1_20 x_PM_AOI21_X4%B1_29 5.46
R_x_PM_AOI21_X4%B1_r14 x_PM_AOI21_X4%B1_20 x_PM_AOI21_X4%B1_18 25.0012
R_x_PM_AOI21_X4%B1_r15 x_PM_AOI21_X4%B1_18 x_PM_AOI21_X4%B1_24 2.10357
R_x_PM_AOI21_X4%B1_r16 N_B1_M3_g x_PM_AOI21_X4%B1_35 90.48
R_x_PM_AOI21_X4%B1_r17 N_B1_M9_g x_PM_AOI21_X4%B1_34 36.66
R_x_PM_AOI21_X4%B1_r18 x_PM_AOI21_X4%B1_29 x_PM_AOI21_X4%B1_5 1.95
R_x_PM_AOI21_X4%B1_r19 N_B1_M0_g x_PM_AOI21_X4%B1_5 96.72
R_x_PM_AOI21_X4%B1_r20 x_PM_AOI21_X4%B1_29 x_PM_AOI21_X4%B1_VSS 1.95
R_x_PM_AOI21_X4%B1_r21 N_B1_M6_g x_PM_AOI21_X4%B1_VSS 30.42
C_x_PM_AOI21_X4%B2_c0 VSS x_PM_AOI21_X4%B2_21 2.14969e-17
C_x_PM_AOI21_X4%B2_c1 VSS x_PM_AOI21_X4%B2_20 4.23234e-18
C_x_PM_AOI21_X4%B2_c2 VSS x_PM_AOI21_X4%B2_19 5.14639e-18
C_x_PM_AOI21_X4%B2_c3 VSS x_PM_AOI21_X4%B2_18 4.41706e-18
C_x_PM_AOI21_X4%B2_c4 VSS N_B2_M2_g 5.72767e-17
C_x_PM_AOI21_X4%B2_c5 VSS N_B2_M8_g 4.90559e-17
C_x_PM_AOI21_X4%B2_c6 VSS N_B2_M1_g 5.71609e-17
C_x_PM_AOI21_X4%B2_c7 VSS N_B2_M7_g 4.94243e-17
R_x_PM_AOI21_X4%B2_r8 x_PM_AOI21_X4%B2_23 x_PM_AOI21_X4%B2_21 25.0012
R_x_PM_AOI21_X4%B2_r9 B2 x_PM_AOI21_X4%B2_21 0.0135714
R_x_PM_AOI21_X4%B2_r10 x_PM_AOI21_X4%B2_23 x_PM_AOI21_X4%B2_19 7.54
R_x_PM_AOI21_X4%B2_r11 x_PM_AOI21_X4%B2_20 x_PM_AOI21_X4%B2_19 0.043368
R_x_PM_AOI21_X4%B2_r12 x_PM_AOI21_X4%B2_23 x_PM_AOI21_X4%B2_17 7.02
R_x_PM_AOI21_X4%B2_r13 x_PM_AOI21_X4%B2_18 x_PM_AOI21_X4%B2_17 0.043368
R_x_PM_AOI21_X4%B2_r14 x_PM_AOI21_X4%B2_20 x_PM_AOI21_X4%B2_13 4.56151
R_x_PM_AOI21_X4%B2_r15 N_B2_M2_g x_PM_AOI21_X4%B2_13 69.42
R_x_PM_AOI21_X4%B2_r16 x_PM_AOI21_X4%B2_20 x_PM_AOI21_X4%B2_9 4.56151
R_x_PM_AOI21_X4%B2_r17 N_B2_M8_g x_PM_AOI21_X4%B2_9 57.72
R_x_PM_AOI21_X4%B2_r18 x_PM_AOI21_X4%B2_18 x_PM_AOI21_X4%B2_5 4.56151
R_x_PM_AOI21_X4%B2_r19 N_B2_M1_g x_PM_AOI21_X4%B2_5 69.42
R_x_PM_AOI21_X4%B2_r20 x_PM_AOI21_X4%B2_18 x_PM_AOI21_X4%B2_VSS 4.56151
R_x_PM_AOI21_X4%B2_r21 N_B2_M7_g x_PM_AOI21_X4%B2_VSS 57.72
C_x_PM_AOI21_X4%A_c0 VSS x_PM_AOI21_X4%A_20 3.48252e-18
C_x_PM_AOI21_X4%A_c1 VSS x_PM_AOI21_X4%A_18 2.72272e-17
C_x_PM_AOI21_X4%A_c2 VSS N_A_M5_g 4.12855e-17
C_x_PM_AOI21_X4%A_c3 VSS x_PM_AOI21_X4%A_9 1.55045e-17
C_x_PM_AOI21_X4%A_c4 VSS N_A_M4_g 3.97001e-17
C_x_PM_AOI21_X4%A_c5 VSS N_A_M10_g 7.21715e-17
R_x_PM_AOI21_X4%A_r6 x_PM_AOI21_X4%A_20 x_PM_AOI21_X4%A_18 25.0012
R_x_PM_AOI21_X4%A_r7 x_PM_AOI21_X4%A_18 A 0.209487
R_x_PM_AOI21_X4%A_r8 N_A_M5_g x_PM_AOI21_X4%A_11 38.22
R_x_PM_AOI21_X4%A_r9 x_PM_AOI21_X4%A_20 x_PM_AOI21_X4%A_10 0.043368
R_x_PM_AOI21_X4%A_r10 x_PM_AOI21_X4%A_11 x_PM_AOI21_X4%A_9 4.58872
R_x_PM_AOI21_X4%A_r11 x_PM_AOI21_X4%A_10 x_PM_AOI21_X4%A_9 14.56
R_x_PM_AOI21_X4%A_r12 x_PM_AOI21_X4%A_20 x_PM_AOI21_X4%A_5 4.56151
R_x_PM_AOI21_X4%A_r13 N_A_M4_g x_PM_AOI21_X4%A_5 38.22
R_x_PM_AOI21_X4%A_r14 x_PM_AOI21_X4%A_20 x_PM_AOI21_X4%A_VSS 4.56151
R_x_PM_AOI21_X4%A_r15 N_A_M10_g x_PM_AOI21_X4%A_VSS 81.12
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X1 VSS VDD B2 B1 A ZN C2 C1
*.PININFO VSS:B VDD:B B2:I B1:I A:I ZN:O C2:I C1:I
M_M5 N_VDD_M0_d N_B2_M0_g N_3_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M6 N_3_M1_d N_B1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_8_M2_d N_A_M2_g N_3_M1_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M8 N_ZN_M3_d N_C2_M3_g N_8_M2_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M9 N_8_M4_d N_C1_M4_g N_ZN_M3_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M0 noxref_11 N_B2_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_ZN_M6_d N_B1_M6_g noxref_11 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_VSS_M7_d N_A_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 noxref_12 N_C2_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_ZN_M9_d N_C1_M9_g noxref_12 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_AOI221_X1%VSS_c0 VSS x_PM_AOI221_X1%VSS_17 5.15058e-17
C_x_PM_AOI221_X1%VSS_c1 VSS N_VSS_M7_d 3.96015e-17
C_x_PM_AOI221_X1%VSS_c2 VSS x_PM_AOI221_X1%VSS_8 1.0903e-17
C_x_PM_AOI221_X1%VSS_c3 VSS x_PM_AOI221_X1%VSS_7 4.81364e-17
C_x_PM_AOI221_X1%VSS_c4 VSS N_VSS_M5_s 1.72123e-17
R_x_PM_AOI221_X1%VSS_r5 x_PM_AOI221_X1%VSS_17 x_PM_AOI221_X1%VSS_11 0.145286
R_x_PM_AOI221_X1%VSS_r6 N_VSS_M7_d x_PM_AOI221_X1%VSS_11 0.637857
R_x_PM_AOI221_X1%VSS_r7 VSS x_PM_AOI221_X1%VSS_8 1.02824
R_x_PM_AOI221_X1%VSS_r8 x_PM_AOI221_X1%VSS_17 x_PM_AOI221_X1%VSS_7 0.0731438
R_x_PM_AOI221_X1%VSS_r9 VSS x_PM_AOI221_X1%VSS_7 0.0782353
R_x_PM_AOI221_X1%VSS_r10 x_PM_AOI221_X1%VSS_8 x_PM_AOI221_X1%VSS_3 0.264221
R_x_PM_AOI221_X1%VSS_r11 N_VSS_M5_s x_PM_AOI221_X1%VSS_3 0.637857
C_x_PM_AOI221_X1%VDD_c0 VSS x_PM_AOI221_X1%VDD_12 3.66728e-17
C_x_PM_AOI221_X1%VDD_c1 VSS VDD 1.51996e-16
C_x_PM_AOI221_X1%VDD_c2 VSS N_VDD_M0_d 3.17338e-17
R_x_PM_AOI221_X1%VDD_r3 x_PM_AOI221_X1%VDD_12 x_PM_AOI221_X1%VDD_8 0.0731438
R_x_PM_AOI221_X1%VDD_r4 VDD x_PM_AOI221_X1%VDD_8 0.603529
R_x_PM_AOI221_X1%VDD_r5 x_PM_AOI221_X1%VDD_12 x_PM_AOI221_X1%VDD_4 0.145286
R_x_PM_AOI221_X1%VDD_r6 N_VDD_M0_d x_PM_AOI221_X1%VDD_4 0.475
C_x_PM_AOI221_X1%3_c0 VSS x_PM_AOI221_X1%3_8 5.18672e-18
C_x_PM_AOI221_X1%3_c1 VSS x_PM_AOI221_X1%3_7 5.17051e-17
C_x_PM_AOI221_X1%3_c2 VSS N_3_M0_s 3.23343e-17
C_x_PM_AOI221_X1%3_c3 VSS N_3_M1_d 4.26227e-17
R_x_PM_AOI221_X1%3_r4 x_PM_AOI221_X1%3_9 x_PM_AOI221_X1%3_7 0.212317
R_x_PM_AOI221_X1%3_r5 x_PM_AOI221_X1%3_8 x_PM_AOI221_X1%3_7 1.62857
R_x_PM_AOI221_X1%3_r6 x_PM_AOI221_X1%3_8 x_PM_AOI221_X1%3_3 0.212317
R_x_PM_AOI221_X1%3_r7 N_3_M0_s x_PM_AOI221_X1%3_3 0.746429
R_x_PM_AOI221_X1%3_r8 N_3_M1_d x_PM_AOI221_X1%3_9 0.746429
C_x_PM_AOI221_X1%B2_c0 VSS x_PM_AOI221_X1%B2_16 6.85761e-18
C_x_PM_AOI221_X1%B2_c1 VSS x_PM_AOI221_X1%B2_14 3.36882e-17
C_x_PM_AOI221_X1%B2_c2 VSS B2 2.24601e-17
C_x_PM_AOI221_X1%B2_c3 VSS N_B2_M0_g 6.52767e-17
C_x_PM_AOI221_X1%B2_c4 VSS N_B2_M5_g 4.88279e-17
R_x_PM_AOI221_X1%B2_r5 x_PM_AOI221_X1%B2_20 x_PM_AOI221_X1%B2_16 4.7687
R_x_PM_AOI221_X1%B2_r6 x_PM_AOI221_X1%B2_19 x_PM_AOI221_X1%B2_16 4.7687
R_x_PM_AOI221_X1%B2_r7 x_PM_AOI221_X1%B2_16 x_PM_AOI221_X1%B2_14 25.0012
R_x_PM_AOI221_X1%B2_r8 x_PM_AOI221_X1%B2_14 B2 0.175926
R_x_PM_AOI221_X1%B2_r9 N_B2_M0_g x_PM_AOI221_X1%B2_20 69.42
R_x_PM_AOI221_X1%B2_r10 N_B2_M5_g x_PM_AOI221_X1%B2_19 60.06
C_x_PM_AOI221_X1%B1_c0 VSS x_PM_AOI221_X1%B1_19 8.69846e-18
C_x_PM_AOI221_X1%B1_c1 VSS x_PM_AOI221_X1%B1_17 2.91964e-17
C_x_PM_AOI221_X1%B1_c2 VSS x_PM_AOI221_X1%B1_14 4.29973e-18
C_x_PM_AOI221_X1%B1_c3 VSS x_PM_AOI221_X1%B1_13 3.83428e-17
C_x_PM_AOI221_X1%B1_c4 VSS x_PM_AOI221_X1%B1_9 1.44468e-17
C_x_PM_AOI221_X1%B1_c5 VSS N_B1_M1_g 5.13432e-17
C_x_PM_AOI221_X1%B1_c6 VSS N_B1_M6_g 6.38596e-17
R_x_PM_AOI221_X1%B1_r7 x_PM_AOI221_X1%B1_23 x_PM_AOI221_X1%B1_19 4.7687
R_x_PM_AOI221_X1%B1_r8 x_PM_AOI221_X1%B1_22 x_PM_AOI221_X1%B1_19 4.7687
R_x_PM_AOI221_X1%B1_r9 x_PM_AOI221_X1%B1_19 x_PM_AOI221_X1%B1_17 25.0012
R_x_PM_AOI221_X1%B1_r10 x_PM_AOI221_X1%B1_17 x_PM_AOI221_X1%B1_15 0.232222
R_x_PM_AOI221_X1%B1_r11 x_PM_AOI221_X1%B1_15 x_PM_AOI221_X1%B1_13 0.095
R_x_PM_AOI221_X1%B1_r12 x_PM_AOI221_X1%B1_13 x_PM_AOI221_X1%B1_14 0.922857
R_x_PM_AOI221_X1%B1_r13 x_PM_AOI221_X1%B1_14 x_PM_AOI221_X1%B1_9 0.192227
R_x_PM_AOI221_X1%B1_r14 B1 x_PM_AOI221_X1%B1_9 0.164667
R_x_PM_AOI221_X1%B1_r15 N_B1_M1_g x_PM_AOI221_X1%B1_23 46.8
R_x_PM_AOI221_X1%B1_r16 N_B1_M6_g x_PM_AOI221_X1%B1_22 82.68
C_x_PM_AOI221_X1%A_c0 VSS x_PM_AOI221_X1%A_13 9.20008e-18
C_x_PM_AOI221_X1%A_c1 VSS A 4.50952e-17
C_x_PM_AOI221_X1%A_c2 VSS N_A_M2_g 6.18161e-17
C_x_PM_AOI221_X1%A_c3 VSS N_A_M7_g 5.39135e-17
R_x_PM_AOI221_X1%A_r4 x_PM_AOI221_X1%A_16 x_PM_AOI221_X1%A_13 4.74714
R_x_PM_AOI221_X1%A_r5 x_PM_AOI221_X1%A_15 x_PM_AOI221_X1%A_13 4.74714
R_x_PM_AOI221_X1%A_r6 x_PM_AOI221_X1%A_13 x_PM_AOI221_X1%A_11 25.0012
R_x_PM_AOI221_X1%A_r7 x_PM_AOI221_X1%A_11 A 0.222053
R_x_PM_AOI221_X1%A_r8 N_A_M2_g x_PM_AOI221_X1%A_16 67.86
R_x_PM_AOI221_X1%A_r9 N_A_M7_g x_PM_AOI221_X1%A_15 64.74
C_x_PM_AOI221_X1%ZN_c0 VSS x_PM_AOI221_X1%ZN_21 5.28972e-18
C_x_PM_AOI221_X1%ZN_c1 VSS N_ZN_M9_d 1.79148e-17
C_x_PM_AOI221_X1%ZN_c2 VSS x_PM_AOI221_X1%ZN_14 1.98172e-17
C_x_PM_AOI221_X1%ZN_c3 VSS N_ZN_M3_d 1.3352e-16
C_x_PM_AOI221_X1%ZN_c4 VSS x_PM_AOI221_X1%ZN_8 4.24468e-17
C_x_PM_AOI221_X1%ZN_c5 VSS N_ZN_M6_d 4.4714e-17
C_x_PM_AOI221_X1%ZN_c6 VSS x_PM_AOI221_X1%ZN_4 1.28216e-17
R_x_PM_AOI221_X1%ZN_r7 N_ZN_M9_d x_PM_AOI221_X1%ZN_16 0.420714
R_x_PM_AOI221_X1%ZN_r8 x_PM_AOI221_X1%ZN_21 x_PM_AOI221_X1%ZN_15 0.14772
R_x_PM_AOI221_X1%ZN_r9 x_PM_AOI221_X1%ZN_16 x_PM_AOI221_X1%ZN_14 0.212317
R_x_PM_AOI221_X1%ZN_r10 x_PM_AOI221_X1%ZN_15 x_PM_AOI221_X1%ZN_14 0.597143
R_x_PM_AOI221_X1%ZN_r11 x_PM_AOI221_X1%ZN_21 x_PM_AOI221_X1%ZN_10 0.0533096
R_x_PM_AOI221_X1%ZN_r12 N_ZN_M3_d x_PM_AOI221_X1%ZN_10 3.37929
R_x_PM_AOI221_X1%ZN_r13 ZN x_PM_AOI221_X1%ZN_9 0.156115
R_x_PM_AOI221_X1%ZN_r14 x_PM_AOI221_X1%ZN_21 x_PM_AOI221_X1%ZN_8 0.14772
R_x_PM_AOI221_X1%ZN_r15 x_PM_AOI221_X1%ZN_9 x_PM_AOI221_X1%ZN_8 1.31882
R_x_PM_AOI221_X1%ZN_r16 ZN x_PM_AOI221_X1%ZN_4 0.0562015
R_x_PM_AOI221_X1%ZN_r17 N_ZN_M6_d x_PM_AOI221_X1%ZN_4 0.525294
C_x_PM_AOI221_X1%8_c0 VSS N_8_M2_d 5.56479e-17
C_x_PM_AOI221_X1%8_c1 VSS x_PM_AOI221_X1%8_5 9.66872e-17
C_x_PM_AOI221_X1%8_c2 VSS N_8_M4_d 4.10792e-17
R_x_PM_AOI221_X1%8_r3 N_8_M2_d x_PM_AOI221_X1%8_6 0.198162
R_x_PM_AOI221_X1%8_r4 x_PM_AOI221_X1%8_6 x_PM_AOI221_X1%8_5 1.62857
R_x_PM_AOI221_X1%8_r5 N_8_M4_d x_PM_AOI221_X1%8_5 0.198162
C_x_PM_AOI221_X1%C2_c0 VSS x_PM_AOI221_X1%C2_18 1.05263e-17
C_x_PM_AOI221_X1%C2_c1 VSS x_PM_AOI221_X1%C2_12 5.62534e-17
C_x_PM_AOI221_X1%C2_c2 VSS N_C2_M3_g 6.77201e-17
C_x_PM_AOI221_X1%C2_c3 VSS N_C2_M8_g 5.32096e-17
R_x_PM_AOI221_X1%C2_r4 x_PM_AOI221_X1%C2_18 x_PM_AOI221_X1%C2_14 3.38
R_x_PM_AOI221_X1%C2_r5 x_PM_AOI221_X1%C2_14 x_PM_AOI221_X1%C2_12 25.0012
R_x_PM_AOI221_X1%C2_r6 x_PM_AOI221_X1%C2_12 C2 0.115357
R_x_PM_AOI221_X1%C2_r7 x_PM_AOI221_X1%C2_18 x_PM_AOI221_X1%C2_5 1.95
R_x_PM_AOI221_X1%C2_r8 N_C2_M3_g x_PM_AOI221_X1%C2_5 72.54
R_x_PM_AOI221_X1%C2_r9 x_PM_AOI221_X1%C2_18 x_PM_AOI221_X1%C2_VSS 1.95
R_x_PM_AOI221_X1%C2_r10 N_C2_M8_g x_PM_AOI221_X1%C2_VSS 56.94
C_x_PM_AOI221_X1%C1_c0 VSS C1 4.26269e-17
C_x_PM_AOI221_X1%C1_c1 VSS x_PM_AOI221_X1%C1_11 9.18001e-18
C_x_PM_AOI221_X1%C1_c2 VSS N_C1_M4_g 6.76323e-17
C_x_PM_AOI221_X1%C1_c3 VSS N_C1_M9_g 5.14909e-17
R_x_PM_AOI221_X1%C1_r4 x_PM_AOI221_X1%C1_11 x_PM_AOI221_X1%C1_16 4.42
R_x_PM_AOI221_X1%C1_r5 x_PM_AOI221_X1%C1_11 x_PM_AOI221_X1%C1_9 25.0012
R_x_PM_AOI221_X1%C1_r6 C1 x_PM_AOI221_X1%C1_9 0.196786
R_x_PM_AOI221_X1%C1_r7 x_PM_AOI221_X1%C1_16 x_PM_AOI221_X1%C1_5 1.95
R_x_PM_AOI221_X1%C1_r8 N_C1_M4_g x_PM_AOI221_X1%C1_5 73.32
R_x_PM_AOI221_X1%C1_r9 x_PM_AOI221_X1%C1_16 x_PM_AOI221_X1%C1_VSS 1.95
R_x_PM_AOI221_X1%C1_r10 N_C1_M9_g x_PM_AOI221_X1%C1_VSS 56.16
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X2 VSS VDD B2 B1 A ZN C2 C1
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A:I C2:I C1:I
M_M5 N_VDD_M0_d N_B2_M0_g N_3_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M6 N_3_M1_d N_B1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M7 N_8_M2_d N_A_M2_g N_3_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M8 N_ZN_M3_d N_C2_M3_g N_8_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M9 N_8_M4_d N_C1_M4_g N_ZN_M3_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 noxref_11 N_B2_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M6_d N_B1_M6_g noxref_11 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_VSS_M7_d N_A_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 noxref_12 N_C2_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_ZN_M9_d N_C1_M9_g noxref_12 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI221_X2%VSS_c0 VSS x_PM_AOI221_X2%VSS_17 5.58407e-17
C_x_PM_AOI221_X2%VSS_c1 VSS N_VSS_M7_d 2.31617e-17
C_x_PM_AOI221_X2%VSS_c2 VSS x_PM_AOI221_X2%VSS_8 1.06964e-17
C_x_PM_AOI221_X2%VSS_c3 VSS x_PM_AOI221_X2%VSS_7 5.49757e-17
C_x_PM_AOI221_X2%VSS_c4 VSS N_VSS_M5_s 1.56034e-17
R_x_PM_AOI221_X2%VSS_r5 x_PM_AOI221_X2%VSS_17 x_PM_AOI221_X2%VSS_11 0.145286
R_x_PM_AOI221_X2%VSS_r6 N_VSS_M7_d x_PM_AOI221_X2%VSS_11 0.230714
R_x_PM_AOI221_X2%VSS_r7 VSS x_PM_AOI221_X2%VSS_8 1.02824
R_x_PM_AOI221_X2%VSS_r8 x_PM_AOI221_X2%VSS_17 x_PM_AOI221_X2%VSS_7 0.0731438
R_x_PM_AOI221_X2%VSS_r9 VSS x_PM_AOI221_X2%VSS_7 0.0782353
R_x_PM_AOI221_X2%VSS_r10 x_PM_AOI221_X2%VSS_8 x_PM_AOI221_X2%VSS_3 0.264221
R_x_PM_AOI221_X2%VSS_r11 N_VSS_M5_s x_PM_AOI221_X2%VSS_3 0.230714
C_x_PM_AOI221_X2%VDD_c0 VSS x_PM_AOI221_X2%VDD_12 3.05898e-17
C_x_PM_AOI221_X2%VDD_c1 VSS VDD 1.50185e-16
C_x_PM_AOI221_X2%VDD_c2 VSS N_VDD_M0_d 2.31077e-17
R_x_PM_AOI221_X2%VDD_r3 x_PM_AOI221_X2%VDD_12 x_PM_AOI221_X2%VDD_8 0.0731438
R_x_PM_AOI221_X2%VDD_r4 VDD x_PM_AOI221_X2%VDD_8 0.614706
R_x_PM_AOI221_X2%VDD_r5 x_PM_AOI221_X2%VDD_12 x_PM_AOI221_X2%VDD_4 0.145286
R_x_PM_AOI221_X2%VDD_r6 N_VDD_M0_d x_PM_AOI221_X2%VDD_4 0.230714
C_x_PM_AOI221_X2%3_c0 VSS x_PM_AOI221_X2%3_7 6.4323e-18
C_x_PM_AOI221_X2%3_c1 VSS N_3_M0_s 2.54074e-17
C_x_PM_AOI221_X2%3_c2 VSS N_3_M1_d 4.91855e-17
R_x_PM_AOI221_X2%3_r3 x_PM_AOI221_X2%3_7 x_PM_AOI221_X2%3_3 0.212317
R_x_PM_AOI221_X2%3_r4 N_3_M0_s x_PM_AOI221_X2%3_3 1.12643
R_x_PM_AOI221_X2%3_r5 N_3_M1_d x_PM_AOI221_X2%3_7 1.83214
C_x_PM_AOI221_X2%B2_c0 VSS x_PM_AOI221_X2%B2_13 7.15869e-18
C_x_PM_AOI221_X2%B2_c1 VSS B2 2.92297e-17
C_x_PM_AOI221_X2%B2_c2 VSS N_B2_M0_g 9.0356e-17
C_x_PM_AOI221_X2%B2_c3 VSS N_B2_M5_g 3.68849e-17
R_x_PM_AOI221_X2%B2_r4 x_PM_AOI221_X2%B2_16 x_PM_AOI221_X2%B2_13 4.7687
R_x_PM_AOI221_X2%B2_r5 x_PM_AOI221_X2%B2_15 x_PM_AOI221_X2%B2_13 4.7687
R_x_PM_AOI221_X2%B2_r6 x_PM_AOI221_X2%B2_13 x_PM_AOI221_X2%B2_11 25.0012
R_x_PM_AOI221_X2%B2_r7 x_PM_AOI221_X2%B2_11 B2 0.274793
R_x_PM_AOI221_X2%B2_r8 N_B2_M0_g x_PM_AOI221_X2%B2_16 89.7
R_x_PM_AOI221_X2%B2_r9 N_B2_M5_g x_PM_AOI221_X2%B2_15 28.08
C_x_PM_AOI221_X2%B1_c0 VSS x_PM_AOI221_X2%B1_11 8.84491e-18
C_x_PM_AOI221_X2%B1_c1 VSS x_PM_AOI221_X2%B1_9 3.88124e-17
C_x_PM_AOI221_X2%B1_c2 VSS N_B1_M1_g 6.54222e-17
C_x_PM_AOI221_X2%B1_c3 VSS N_B1_M6_g 6.24398e-17
R_x_PM_AOI221_X2%B1_r4 x_PM_AOI221_X2%B1_18 x_PM_AOI221_X2%B1_11 4.74714
R_x_PM_AOI221_X2%B1_r5 x_PM_AOI221_X2%B1_17 x_PM_AOI221_X2%B1_11 4.74714
R_x_PM_AOI221_X2%B1_r6 x_PM_AOI221_X2%B1_11 x_PM_AOI221_X2%B1_9 25.0012
R_x_PM_AOI221_X2%B1_r7 B1 x_PM_AOI221_X2%B1_9 0.2204
R_x_PM_AOI221_X2%B1_r8 N_B1_M1_g x_PM_AOI221_X2%B1_18 49.14
R_x_PM_AOI221_X2%B1_r9 N_B1_M6_g x_PM_AOI221_X2%B1_17 68.64
C_x_PM_AOI221_X2%ZN_c0 VSS x_PM_AOI221_X2%ZN_19 3.54541e-17
C_x_PM_AOI221_X2%ZN_c1 VSS x_PM_AOI221_X2%ZN_17 1.13061e-16
C_x_PM_AOI221_X2%ZN_c2 VSS N_ZN_M3_d 3.12239e-17
C_x_PM_AOI221_X2%ZN_c3 VSS x_PM_AOI221_X2%ZN_12 4.21759e-18
C_x_PM_AOI221_X2%ZN_c4 VSS x_PM_AOI221_X2%ZN_9 1.41172e-17
C_x_PM_AOI221_X2%ZN_c5 VSS x_PM_AOI221_X2%ZN_8 5.00116e-17
C_x_PM_AOI221_X2%ZN_c6 VSS N_ZN_M6_d 2.62808e-17
R_x_PM_AOI221_X2%ZN_r7 N_ZN_M9_d x_PM_AOI221_X2%ZN_19 0.770857
R_x_PM_AOI221_X2%ZN_r8 x_PM_AOI221_X2%ZN_19 x_PM_AOI221_X2%ZN_16 0.152
R_x_PM_AOI221_X2%ZN_r9 x_PM_AOI221_X2%ZN_17 x_PM_AOI221_X2%ZN_16 2.98571
R_x_PM_AOI221_X2%ZN_r10 x_PM_AOI221_X2%ZN_17 x_PM_AOI221_X2%ZN_12 0.192227
R_x_PM_AOI221_X2%ZN_r11 N_ZN_M3_d x_PM_AOI221_X2%ZN_12 0.152
R_x_PM_AOI221_X2%ZN_r12 ZN x_PM_AOI221_X2%ZN_9 0.461429
R_x_PM_AOI221_X2%ZN_r13 x_PM_AOI221_X2%ZN_19 x_PM_AOI221_X2%ZN_8 0.148146
R_x_PM_AOI221_X2%ZN_r14 ZN x_PM_AOI221_X2%ZN_8 0.393571
R_x_PM_AOI221_X2%ZN_r15 x_PM_AOI221_X2%ZN_9 x_PM_AOI221_X2%ZN_4 0.244544
R_x_PM_AOI221_X2%ZN_r16 N_ZN_M6_d x_PM_AOI221_X2%ZN_4 0.257857
C_x_PM_AOI221_X2%A_c0 VSS x_PM_AOI221_X2%A_14 8.72615e-18
C_x_PM_AOI221_X2%A_c1 VSS x_PM_AOI221_X2%A_12 4.62018e-17
C_x_PM_AOI221_X2%A_c2 VSS N_A_M2_g 6.83158e-17
C_x_PM_AOI221_X2%A_c3 VSS N_A_M7_g 6.07374e-17
R_x_PM_AOI221_X2%A_r4 x_PM_AOI221_X2%A_18 x_PM_AOI221_X2%A_14 4.7687
R_x_PM_AOI221_X2%A_r5 x_PM_AOI221_X2%A_17 x_PM_AOI221_X2%A_14 4.7687
R_x_PM_AOI221_X2%A_r6 x_PM_AOI221_X2%A_14 x_PM_AOI221_X2%A_12 25.0012
R_x_PM_AOI221_X2%A_r7 x_PM_AOI221_X2%A_12 A 0.2375
R_x_PM_AOI221_X2%A_r8 N_A_M2_g x_PM_AOI221_X2%A_18 59.28
R_x_PM_AOI221_X2%A_r9 N_A_M7_g x_PM_AOI221_X2%A_17 64.74
C_x_PM_AOI221_X2%8_c0 VSS N_8_M4_d 1.12945e-16
R_x_PM_AOI221_X2%8_r1 N_8_M4_d N_8_M2_d 2.03571
C_x_PM_AOI221_X2%C2_c0 VSS x_PM_AOI221_X2%C2_21 9.97551e-18
C_x_PM_AOI221_X2%C2_c1 VSS x_PM_AOI221_X2%C2_17 2.56238e-17
C_x_PM_AOI221_X2%C2_c2 VSS x_PM_AOI221_X2%C2_10 5.60909e-17
C_x_PM_AOI221_X2%C2_c3 VSS N_C2_M3_g 6.48732e-17
C_x_PM_AOI221_X2%C2_c4 VSS N_C2_M8_g 6.74998e-17
R_x_PM_AOI221_X2%C2_r5 x_PM_AOI221_X2%C2_17 C2 0.244286
R_x_PM_AOI221_X2%C2_r6 x_PM_AOI221_X2%C2_21 x_PM_AOI221_X2%C2_12 2.86
R_x_PM_AOI221_X2%C2_r7 x_PM_AOI221_X2%C2_12 x_PM_AOI221_X2%C2_10 25.0012
R_x_PM_AOI221_X2%C2_r8 x_PM_AOI221_X2%C2_17 x_PM_AOI221_X2%C2_9 0.095
R_x_PM_AOI221_X2%C2_r9 x_PM_AOI221_X2%C2_10 x_PM_AOI221_X2%C2_9 0.963571
R_x_PM_AOI221_X2%C2_r10 x_PM_AOI221_X2%C2_21 x_PM_AOI221_X2%C2_5 1.95
R_x_PM_AOI221_X2%C2_r11 N_C2_M3_g x_PM_AOI221_X2%C2_5 49.14
R_x_PM_AOI221_X2%C2_r12 x_PM_AOI221_X2%C2_21 x_PM_AOI221_X2%C2_VSS 1.95
R_x_PM_AOI221_X2%C2_r13 N_C2_M8_g x_PM_AOI221_X2%C2_VSS 68.64
C_x_PM_AOI221_X2%C1_c0 VSS C1 4.01616e-17
C_x_PM_AOI221_X2%C1_c1 VSS x_PM_AOI221_X2%C1_11 9.3621e-18
C_x_PM_AOI221_X2%C1_c2 VSS N_C1_M4_g 6.63503e-17
C_x_PM_AOI221_X2%C1_c3 VSS N_C1_M9_g 5.49167e-17
R_x_PM_AOI221_X2%C1_r4 x_PM_AOI221_X2%C1_11 x_PM_AOI221_X2%C1_16 4.94
R_x_PM_AOI221_X2%C1_r5 x_PM_AOI221_X2%C1_11 x_PM_AOI221_X2%C1_9 25.0012
R_x_PM_AOI221_X2%C1_r6 C1 x_PM_AOI221_X2%C1_9 0.183214
R_x_PM_AOI221_X2%C1_r7 x_PM_AOI221_X2%C1_16 x_PM_AOI221_X2%C1_5 1.95
R_x_PM_AOI221_X2%C1_r8 N_C1_M4_g x_PM_AOI221_X2%C1_5 59.28
R_x_PM_AOI221_X2%C1_r9 x_PM_AOI221_X2%C1_16 x_PM_AOI221_X2%C1_VSS 1.95
R_x_PM_AOI221_X2%C1_r10 N_C1_M9_g x_PM_AOI221_X2%C1_VSS 58.5
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI221_X4 VSS VDD B2 B1 A ZN C2 C1
*.PININFO VSS:B VDD:B ZN:O C1:I C2:I A:I B2:I B1:I
M_M9 N_ZN_M0_d N_C1_M0_g N_3_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M10 N_3_M1_d N_C2_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M11 N_ZN_M2_d N_C2_M2_g N_3_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M12 N_3_M3_d N_C1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M13 N_8_M4_d N_A_M4_g N_3_M3_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M14 N_VDD_M5_d N_B2_M5_g N_8_M4_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M15 N_8_M6_d N_B1_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M16 N_VDD_M7_d N_B1_M7_g N_8_M6_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M17 N_8_M8_d N_B2_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M18 N_3_M9_d N_A_M9_g N_8_M8_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 11 N_C1_M10_g N_ZN_M10_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_VSS_M11_d N_C2_M11_g 11 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 12 N_C2_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_ZN_M13_d N_C1_M13_g 12 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M14_d N_A_M14_g N_ZN_M13_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M5 13 N_B2_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 N_ZN_M16_d N_B1_M16_g 13 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 14 N_B1_M17_g N_ZN_M16_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M8 N_VSS_M18_d N_B2_M18_g 14 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI221_X4%VSS_c0 VSS x_PM_AOI221_X4%VSS_27 2.46707e-17
C_x_PM_AOI221_X4%VSS_c1 VSS VSS 2.64443e-18
C_x_PM_AOI221_X4%VSS_c2 VSS x_PM_AOI221_X4%VSS_24 5.60382e-17
C_x_PM_AOI221_X4%VSS_c3 VSS N_VSS_M18_d 1.08467e-17
C_x_PM_AOI221_X4%VSS_c4 VSS x_PM_AOI221_X4%VSS_16 7.58699e-17
C_x_PM_AOI221_X4%VSS_c5 VSS N_VSS_M14_d 2.37166e-17
C_x_PM_AOI221_X4%VSS_c6 VSS x_PM_AOI221_X4%VSS_10 5.97164e-17
C_x_PM_AOI221_X4%VSS_c7 VSS N_VSS_M11_d 2.61311e-17
R_x_PM_AOI221_X4%VSS_r8 x_PM_AOI221_X4%VSS_27 x_PM_AOI221_X4%VSS_18 0.145286
R_x_PM_AOI221_X4%VSS_r9 N_VSS_M18_d x_PM_AOI221_X4%VSS_18 0.230714
R_x_PM_AOI221_X4%VSS_r10 VSS x_PM_AOI221_X4%VSS_17 0.0731438
R_x_PM_AOI221_X4%VSS_r11 x_PM_AOI221_X4%VSS_27 x_PM_AOI221_X4%VSS_16 0.0731438
R_x_PM_AOI221_X4%VSS_r12 x_PM_AOI221_X4%VSS_17 x_PM_AOI221_X4%VSS_16 1.53118
R_x_PM_AOI221_X4%VSS_r13 VSS x_PM_AOI221_X4%VSS_12 0.145286
R_x_PM_AOI221_X4%VSS_r14 N_VSS_M14_d x_PM_AOI221_X4%VSS_12 0.230714
R_x_PM_AOI221_X4%VSS_r15 x_PM_AOI221_X4%VSS_24 x_PM_AOI221_X4%VSS_11 0.0731438
R_x_PM_AOI221_X4%VSS_r16 VSS x_PM_AOI221_X4%VSS_10 0.0731438
R_x_PM_AOI221_X4%VSS_r17 x_PM_AOI221_X4%VSS_11 x_PM_AOI221_X4%VSS_10 1.16235
R_x_PM_AOI221_X4%VSS_r18 x_PM_AOI221_X4%VSS_24 x_PM_AOI221_X4%VSS_6 0.145286
R_x_PM_AOI221_X4%VSS_r19 N_VSS_M11_d x_PM_AOI221_X4%VSS_6 0.230714
C_x_PM_AOI221_X4%VDD_c0 VSS N_VDD_M7_d 8.64728e-17
C_x_PM_AOI221_X4%VDD_c1 VSS x_PM_AOI221_X4%VDD_7 3.78431e-17
C_x_PM_AOI221_X4%VDD_c2 VSS x_PM_AOI221_X4%VDD_6 3.351e-17
C_x_PM_AOI221_X4%VDD_c3 VSS x_PM_AOI221_X4%VDD_3 1.32299e-16
R_x_PM_AOI221_X4%VDD_r4 N_VDD_M5_d x_PM_AOI221_X4%VDD_7 0.145893
R_x_PM_AOI221_X4%VDD_r5 N_VDD_M7_d x_PM_AOI221_X4%VDD_6 0.145893
R_x_PM_AOI221_X4%VDD_r6 x_PM_AOI221_X4%VDD_7 x_PM_AOI221_X4%VDD_6 0.217143
R_x_PM_AOI221_X4%VDD_r7 x_PM_AOI221_X4%VDD_3 N_VDD_M5_d 0.102329
R_x_PM_AOI221_X4%VDD_r8 VDD x_PM_AOI221_X4%VDD_3 0.402353
C_x_PM_AOI221_X4%3_c0 VSS x_PM_AOI221_X4%3_5 3.37251e-16
C_x_PM_AOI221_X4%3_c1 VSS N_3_M9_d 1.49826e-17
R_x_PM_AOI221_X4%3_r2 N_3_M3_d N_3_M1_d 2.14429
R_x_PM_AOI221_X4%3_r3 N_3_M1_d N_3_M0_s 2.03571
R_x_PM_AOI221_X4%3_r4 x_PM_AOI221_X4%3_16 x_PM_AOI221_X4%3_5 0.095
R_x_PM_AOI221_X4%3_r5 N_3_M3_d x_PM_AOI221_X4%3_5 5.985
R_x_PM_AOI221_X4%3_r6 x_PM_AOI221_X4%3_16 N_3_M9_d 0.176429
C_x_PM_AOI221_X4%ZN_c0 VSS N_ZN_M16_d 3.83677e-17
C_x_PM_AOI221_X4%ZN_c1 VSS N_ZN_M13_d 5.64496e-18
C_x_PM_AOI221_X4%ZN_c2 VSS x_PM_AOI221_X4%ZN_18 1.7969e-17
C_x_PM_AOI221_X4%ZN_c3 VSS x_PM_AOI221_X4%ZN_16 6.2945e-17
C_x_PM_AOI221_X4%ZN_c4 VSS x_PM_AOI221_X4%ZN_15 1.00561e-16
C_x_PM_AOI221_X4%ZN_c5 VSS x_PM_AOI221_X4%ZN_8 1.82919e-16
C_x_PM_AOI221_X4%ZN_c6 VSS x_PM_AOI221_X4%ZN_6 1.0352e-16
R_x_PM_AOI221_X4%ZN_r7 x_PM_AOI221_X4%ZN_30 N_ZN_M16_d 0.176429
R_x_PM_AOI221_X4%ZN_r8 ZN N_ZN_M10_s 0.19
R_x_PM_AOI221_X4%ZN_r9 N_ZN_M10_s x_PM_AOI221_X4%ZN_18 0.0886667
R_x_PM_AOI221_X4%ZN_r10 N_ZN_M13_d x_PM_AOI221_X4%ZN_17 0.160909
R_x_PM_AOI221_X4%ZN_r11 x_PM_AOI221_X4%ZN_30 x_PM_AOI221_X4%ZN_16 0.095
R_x_PM_AOI221_X4%ZN_r12 x_PM_AOI221_X4%ZN_17 x_PM_AOI221_X4%ZN_16 2.76857
R_x_PM_AOI221_X4%ZN_r13 N_ZN_M13_d x_PM_AOI221_X4%ZN_14 0.0418175
R_x_PM_AOI221_X4%ZN_r14 x_PM_AOI221_X4%ZN_15 x_PM_AOI221_X4%ZN_14 3.12143
R_x_PM_AOI221_X4%ZN_r15 N_ZN_M2_d N_ZN_M0_d 2.11714
R_x_PM_AOI221_X4%ZN_r16 x_PM_AOI221_X4%ZN_15 x_PM_AOI221_X4%ZN_8 0.212317
R_x_PM_AOI221_X4%ZN_r17 N_ZN_M2_d x_PM_AOI221_X4%ZN_8 0.773571
R_x_PM_AOI221_X4%ZN_r18 x_PM_AOI221_X4%ZN_18 x_PM_AOI221_X4%ZN_7 0.095
R_x_PM_AOI221_X4%ZN_r19 N_ZN_M13_d x_PM_AOI221_X4%ZN_6 0.160909
R_x_PM_AOI221_X4%ZN_r20 x_PM_AOI221_X4%ZN_7 x_PM_AOI221_X4%ZN_6 3.74571
C_x_PM_AOI221_X4%C1_c0 VSS x_PM_AOI221_X4%C1_38 1.26431e-17
C_x_PM_AOI221_X4%C1_c1 VSS C1 6.78895e-17
C_x_PM_AOI221_X4%C1_c2 VSS x_PM_AOI221_X4%C1_23 7.45672e-18
C_x_PM_AOI221_X4%C1_c3 VSS x_PM_AOI221_X4%C1_19 6.96494e-18
C_x_PM_AOI221_X4%C1_c4 VSS x_PM_AOI221_X4%C1_17 5.67151e-17
C_x_PM_AOI221_X4%C1_c5 VSS N_C1_M3_g 8.90793e-17
C_x_PM_AOI221_X4%C1_c6 VSS N_C1_M13_g 4.62505e-17
C_x_PM_AOI221_X4%C1_c7 VSS N_C1_M0_g 7.26244e-17
C_x_PM_AOI221_X4%C1_c8 VSS N_C1_M10_g 4.95112e-17
R_x_PM_AOI221_X4%C1_r9 x_PM_AOI221_X4%C1_38 x_PM_AOI221_X4%C1_30 5.46
R_x_PM_AOI221_X4%C1_r10 x_PM_AOI221_X4%C1_30 x_PM_AOI221_X4%C1_28 25.0012
R_x_PM_AOI221_X4%C1_r11 x_PM_AOI221_X4%C1_31 x_PM_AOI221_X4%C1_28 0.0730769
R_x_PM_AOI221_X4%C1_r12 x_PM_AOI221_X4%C1_28 C1 0.00730769
R_x_PM_AOI221_X4%C1_r13 x_PM_AOI221_X4%C1_35 x_PM_AOI221_X4%C1_23 4.7687
R_x_PM_AOI221_X4%C1_r14 x_PM_AOI221_X4%C1_34 x_PM_AOI221_X4%C1_23 4.7687
R_x_PM_AOI221_X4%C1_r15 x_PM_AOI221_X4%C1_23 x_PM_AOI221_X4%C1_21 25.0012
R_x_PM_AOI221_X4%C1_r16 x_PM_AOI221_X4%C1_21 x_PM_AOI221_X4%C1_19 0.135714
R_x_PM_AOI221_X4%C1_r17 x_PM_AOI221_X4%C1_19 x_PM_AOI221_X4%C1_18 0.095
R_x_PM_AOI221_X4%C1_r18 x_PM_AOI221_X4%C1_31 x_PM_AOI221_X4%C1_17 0.095
R_x_PM_AOI221_X4%C1_r19 x_PM_AOI221_X4%C1_18 x_PM_AOI221_X4%C1_17 1.72118
R_x_PM_AOI221_X4%C1_r20 x_PM_AOI221_X4%C1_38 x_PM_AOI221_X4%C1_13 1.95
R_x_PM_AOI221_X4%C1_r21 N_C1_M3_g x_PM_AOI221_X4%C1_13 81.12
R_x_PM_AOI221_X4%C1_r22 x_PM_AOI221_X4%C1_38 x_PM_AOI221_X4%C1_9 1.95
R_x_PM_AOI221_X4%C1_r23 N_C1_M13_g x_PM_AOI221_X4%C1_9 36.66
R_x_PM_AOI221_X4%C1_r24 N_C1_M0_g x_PM_AOI221_X4%C1_35 73.32
R_x_PM_AOI221_X4%C1_r25 N_C1_M10_g x_PM_AOI221_X4%C1_34 44.46
C_x_PM_AOI221_X4%C2_c0 VSS C2 8.4683e-17
C_x_PM_AOI221_X4%C2_c1 VSS x_PM_AOI221_X4%C2_22 3.48842e-18
C_x_PM_AOI221_X4%C2_c2 VSS x_PM_AOI221_X4%C2_19 4.24723e-18
C_x_PM_AOI221_X4%C2_c3 VSS N_C2_M2_g 5.19265e-17
C_x_PM_AOI221_X4%C2_c4 VSS N_C2_M12_g 5.47303e-17
C_x_PM_AOI221_X4%C2_c5 VSS x_PM_AOI221_X4%C2_9 9.95265e-18
C_x_PM_AOI221_X4%C2_c6 VSS N_C2_M1_g 5.3377e-17
C_x_PM_AOI221_X4%C2_c7 VSS N_C2_M11_g 5.43468e-17
R_x_PM_AOI221_X4%C2_r8 x_PM_AOI221_X4%C2_22 x_PM_AOI221_X4%C2_20 25.0012
R_x_PM_AOI221_X4%C2_r9 C2 x_PM_AOI221_X4%C2_20 0.158333
R_x_PM_AOI221_X4%C2_r10 x_PM_AOI221_X4%C2_22 x_PM_AOI221_X4%C2_15 4.56151
R_x_PM_AOI221_X4%C2_r11 N_C2_M2_g x_PM_AOI221_X4%C2_15 49.14
R_x_PM_AOI221_X4%C2_r12 x_PM_AOI221_X4%C2_22 x_PM_AOI221_X4%C2_11 4.56151
R_x_PM_AOI221_X4%C2_r13 N_C2_M12_g x_PM_AOI221_X4%C2_11 68.64
R_x_PM_AOI221_X4%C2_r14 x_PM_AOI221_X4%C2_19 x_PM_AOI221_X4%C2_10 0.043368
R_x_PM_AOI221_X4%C2_r15 x_PM_AOI221_X4%C2_22 x_PM_AOI221_X4%C2_9 0.043368
R_x_PM_AOI221_X4%C2_r16 x_PM_AOI221_X4%C2_10 x_PM_AOI221_X4%C2_9 16.12
R_x_PM_AOI221_X4%C2_r17 x_PM_AOI221_X4%C2_19 x_PM_AOI221_X4%C2_5 4.56151
R_x_PM_AOI221_X4%C2_r18 N_C2_M1_g x_PM_AOI221_X4%C2_5 49.14
R_x_PM_AOI221_X4%C2_r19 x_PM_AOI221_X4%C2_19 x_PM_AOI221_X4%C2_VSS 4.56151
R_x_PM_AOI221_X4%C2_r20 N_C2_M11_g x_PM_AOI221_X4%C2_VSS 68.64
C_x_PM_AOI221_X4%A_c0 VSS x_PM_AOI221_X4%A_24 9.60966e-18
C_x_PM_AOI221_X4%A_c1 VSS x_PM_AOI221_X4%A_22 4.63289e-17
C_x_PM_AOI221_X4%A_c2 VSS x_PM_AOI221_X4%A_21 7.88158e-18
C_x_PM_AOI221_X4%A_c3 VSS A 2.46768e-17
C_x_PM_AOI221_X4%A_c4 VSS x_PM_AOI221_X4%A_13 2.92685e-16
C_x_PM_AOI221_X4%A_c5 VSS N_A_M9_g 6.10738e-17
C_x_PM_AOI221_X4%A_c6 VSS N_A_M4_g 6.56823e-17
C_x_PM_AOI221_X4%A_c7 VSS N_A_M14_g 6.59553e-17
R_x_PM_AOI221_X4%A_r8 x_PM_AOI221_X4%A_24 x_PM_AOI221_X4%A_28 2.34
R_x_PM_AOI221_X4%A_r9 x_PM_AOI221_X4%A_24 x_PM_AOI221_X4%A_22 25.0012
R_x_PM_AOI221_X4%A_r10 x_PM_AOI221_X4%A_26 x_PM_AOI221_X4%A_22 0.230714
R_x_PM_AOI221_X4%A_r11 x_PM_AOI221_X4%A_21 x_PM_AOI221_X4%A_32 1.82
R_x_PM_AOI221_X4%A_r12 x_PM_AOI221_X4%A_21 x_PM_AOI221_X4%A_19 25.0012
R_x_PM_AOI221_X4%A_r13 x_PM_AOI221_X4%A_19 A 0.2052
R_x_PM_AOI221_X4%A_r14 x_PM_AOI221_X4%A_19 x_PM_AOI221_X4%A_15 0.0228
R_x_PM_AOI221_X4%A_r15 x_PM_AOI221_X4%A_26 x_PM_AOI221_X4%A_14 0.095
R_x_PM_AOI221_X4%A_r16 x_PM_AOI221_X4%A_15 x_PM_AOI221_X4%A_13 0.235058
R_x_PM_AOI221_X4%A_r17 x_PM_AOI221_X4%A_14 x_PM_AOI221_X4%A_13 4.75
R_x_PM_AOI221_X4%A_r18 x_PM_AOI221_X4%A_32 x_PM_AOI221_X4%A_9 1.95
R_x_PM_AOI221_X4%A_r19 N_A_M9_g x_PM_AOI221_X4%A_9 49.14
R_x_PM_AOI221_X4%A_r20 x_PM_AOI221_X4%A_28 x_PM_AOI221_X4%A_5 1.95
R_x_PM_AOI221_X4%A_r21 N_A_M4_g x_PM_AOI221_X4%A_5 49.14
R_x_PM_AOI221_X4%A_r22 x_PM_AOI221_X4%A_28 x_PM_AOI221_X4%A_VSS 1.95
R_x_PM_AOI221_X4%A_r23 N_A_M14_g x_PM_AOI221_X4%A_VSS 60.84
C_x_PM_AOI221_X4%8_c0 VSS N_8_M8_d 2.44146e-16
R_x_PM_AOI221_X4%8_r1 N_8_M6_d N_8_M4_d 2.03571
R_x_PM_AOI221_X4%8_r2 N_8_M8_d N_8_M6_d 2.06286
C_x_PM_AOI221_X4%B2_c0 VSS x_PM_AOI221_X4%B2_26 7.11625e-18
C_x_PM_AOI221_X4%B2_c1 VSS x_PM_AOI221_X4%B2_24 6.13219e-17
C_x_PM_AOI221_X4%B2_c2 VSS x_PM_AOI221_X4%B2_20 8.4903e-18
C_x_PM_AOI221_X4%B2_c3 VSS x_PM_AOI221_X4%B2_17 1.45058e-16
C_x_PM_AOI221_X4%B2_c4 VSS N_B2_M8_g 8.37209e-17
C_x_PM_AOI221_X4%B2_c5 VSS N_B2_M18_g 4.89179e-17
C_x_PM_AOI221_X4%B2_c6 VSS N_B2_M5_g 8.18451e-17
C_x_PM_AOI221_X4%B2_c7 VSS N_B2_M15_g 5.66192e-17
R_x_PM_AOI221_X4%B2_r8 x_PM_AOI221_X4%B2_33 x_PM_AOI221_X4%B2_26 4.7687
R_x_PM_AOI221_X4%B2_r9 x_PM_AOI221_X4%B2_32 x_PM_AOI221_X4%B2_26 4.7687
R_x_PM_AOI221_X4%B2_r10 x_PM_AOI221_X4%B2_26 x_PM_AOI221_X4%B2_24 25.0012
R_x_PM_AOI221_X4%B2_r11 x_PM_AOI221_X4%B2_27 x_PM_AOI221_X4%B2_24 0.113615
R_x_PM_AOI221_X4%B2_r12 x_PM_AOI221_X4%B2_24 B2 0.288408
R_x_PM_AOI221_X4%B2_r13 x_PM_AOI221_X4%B2_30 x_PM_AOI221_X4%B2_20 4.7687
R_x_PM_AOI221_X4%B2_r14 x_PM_AOI221_X4%B2_29 x_PM_AOI221_X4%B2_20 4.7687
R_x_PM_AOI221_X4%B2_r15 x_PM_AOI221_X4%B2_20 x_PM_AOI221_X4%B2_18 25.0012
R_x_PM_AOI221_X4%B2_r16 x_PM_AOI221_X4%B2_27 x_PM_AOI221_X4%B2_17 0.113615
R_x_PM_AOI221_X4%B2_r17 x_PM_AOI221_X4%B2_18 x_PM_AOI221_X4%B2_17 2.91786
R_x_PM_AOI221_X4%B2_r18 N_B2_M8_g x_PM_AOI221_X4%B2_33 68.64
R_x_PM_AOI221_X4%B2_r19 N_B2_M18_g x_PM_AOI221_X4%B2_32 49.14
R_x_PM_AOI221_X4%B2_r20 N_B2_M5_g x_PM_AOI221_X4%B2_30 63.96
R_x_PM_AOI221_X4%B2_r21 N_B2_M15_g x_PM_AOI221_X4%B2_29 53.82
C_x_PM_AOI221_X4%B1_c0 VSS x_PM_AOI221_X4%B1_24 7.48781e-18
C_x_PM_AOI221_X4%B1_c1 VSS B1 4.63551e-17
C_x_PM_AOI221_X4%B1_c2 VSS x_PM_AOI221_X4%B1_19 4.33983e-18
C_x_PM_AOI221_X4%B1_c3 VSS N_B1_M7_g 8.03979e-17
C_x_PM_AOI221_X4%B1_c4 VSS N_B1_M17_g 2.70845e-17
C_x_PM_AOI221_X4%B1_c5 VSS x_PM_AOI221_X4%B1_9 8.57114e-18
C_x_PM_AOI221_X4%B1_c6 VSS N_B1_M6_g 8.08902e-17
C_x_PM_AOI221_X4%B1_c7 VSS N_B1_M16_g 3.20054e-17
R_x_PM_AOI221_X4%B1_r8 x_PM_AOI221_X4%B1_24 x_PM_AOI221_X4%B1_25 3.38
R_x_PM_AOI221_X4%B1_r9 x_PM_AOI221_X4%B1_24 x_PM_AOI221_X4%B1_22 25.0012
R_x_PM_AOI221_X4%B1_r10 x_PM_AOI221_X4%B1_22 B1 0.350738
R_x_PM_AOI221_X4%B1_r11 x_PM_AOI221_X4%B1_25 x_PM_AOI221_X4%B1_15 1.95
R_x_PM_AOI221_X4%B1_r12 N_B1_M7_g x_PM_AOI221_X4%B1_15 89.7
R_x_PM_AOI221_X4%B1_r13 x_PM_AOI221_X4%B1_25 x_PM_AOI221_X4%B1_11 1.95
R_x_PM_AOI221_X4%B1_r14 N_B1_M17_g x_PM_AOI221_X4%B1_11 28.08
R_x_PM_AOI221_X4%B1_r15 x_PM_AOI221_X4%B1_19 x_PM_AOI221_X4%B1_10 0.043368
R_x_PM_AOI221_X4%B1_r16 x_PM_AOI221_X4%B1_25 x_PM_AOI221_X4%B1_9 2.6
R_x_PM_AOI221_X4%B1_r17 x_PM_AOI221_X4%B1_10 x_PM_AOI221_X4%B1_9 14.56
R_x_PM_AOI221_X4%B1_r18 x_PM_AOI221_X4%B1_19 x_PM_AOI221_X4%B1_5 4.56151
R_x_PM_AOI221_X4%B1_r19 N_B1_M6_g x_PM_AOI221_X4%B1_5 89.7
R_x_PM_AOI221_X4%B1_r20 x_PM_AOI221_X4%B1_19 x_PM_AOI221_X4%B1_VSS 4.56151
R_x_PM_AOI221_X4%B1_r21 N_B1_M16_g x_PM_AOI221_X4%B1_VSS 28.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X1 VSS VDD B2 C2 C1 ZN B1 A2 A1
*.PININFO VSS:B VDD:B B2:I C2:I C1:I ZN:O B1:I A2:I A1:I
M_M6 N_6_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_VDD_M1_d N_C2_M1_g N_6_M0_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M8 N_6_M2_d N_C1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M9 N_4_M3_d N_B1_M3_g N_6_M2_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M10 N_ZN_M4_d N_A2_M4_g N_4_M3_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M11 N_4_M5_d N_A1_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M0 N_VSS_M6_d N_B2_M6_g N_3_M6_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 noxref_13 N_C2_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M8_d N_C1_M8_g noxref_13 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_3_M9_d N_B1_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 noxref_14 N_A2_M10_g N_VSS_M10_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M5 N_ZN_M11_d N_A1_M11_g noxref_14 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_AOI222_X1%VSS_c0 VSS x_PM_AOI222_X1%VSS_16 8.38888e-17
C_x_PM_AOI222_X1%VSS_c1 VSS x_PM_AOI222_X1%VSS_15 2.65117e-17
C_x_PM_AOI222_X1%VSS_c2 VSS x_PM_AOI222_X1%VSS_9 4.43772e-17
C_x_PM_AOI222_X1%VSS_c3 VSS N_VSS_M6_d 7.13443e-17
R_x_PM_AOI222_X1%VSS_r4 N_VSS_M10_s x_PM_AOI222_X1%VSS_16 0.457407
R_x_PM_AOI222_X1%VSS_r5 x_PM_AOI222_X1%VSS_15 x_PM_AOI222_X1%VSS_10 0.132285
R_x_PM_AOI222_X1%VSS_r6 VSS x_PM_AOI222_X1%VSS_10 0.737647
R_x_PM_AOI222_X1%VSS_r7 x_PM_AOI222_X1%VSS_16 x_PM_AOI222_X1%VSS_9 0.095
R_x_PM_AOI222_X1%VSS_r8 VSS x_PM_AOI222_X1%VSS_9 0.290588
R_x_PM_AOI222_X1%VSS_r9 x_PM_AOI222_X1%VSS_15 x_PM_AOI222_X1%VSS_5 0.0680382
R_x_PM_AOI222_X1%VSS_r10 N_VSS_M6_d x_PM_AOI222_X1%VSS_5 0.809259
C_x_PM_AOI222_X1%VDD_c0 VSS x_PM_AOI222_X1%VDD_11 4.88858e-17
C_x_PM_AOI222_X1%VDD_c1 VSS N_VDD_M1_d 5.03742e-17
C_x_PM_AOI222_X1%VDD_c2 VSS VDD 1.50128e-16
R_x_PM_AOI222_X1%VDD_r3 x_PM_AOI222_X1%VDD_11 N_VDD_M1_d 0.485556
R_x_PM_AOI222_X1%VDD_r4 x_PM_AOI222_X1%VDD_11 x_PM_AOI222_X1%VDD_4 0.095
R_x_PM_AOI222_X1%VDD_r5 VDD x_PM_AOI222_X1%VDD_4 0.324118
C_x_PM_AOI222_X1%3_c0 VSS x_PM_AOI222_X1%3_12 1.37254e-17
C_x_PM_AOI222_X1%3_c1 VSS x_PM_AOI222_X1%3_11 6.82734e-17
C_x_PM_AOI222_X1%3_c2 VSS x_PM_AOI222_X1%3_10 2.2314e-17
C_x_PM_AOI222_X1%3_c3 VSS x_PM_AOI222_X1%3_8 6.39376e-18
C_x_PM_AOI222_X1%3_c4 VSS x_PM_AOI222_X1%3_7 7.61064e-17
C_x_PM_AOI222_X1%3_c5 VSS N_3_M6_s 1.30744e-17
C_x_PM_AOI222_X1%3_c6 VSS N_3_M9_d 2.64453e-17
R_x_PM_AOI222_X1%3_r7 x_PM_AOI222_X1%3_13 x_PM_AOI222_X1%3_11 0.212317
R_x_PM_AOI222_X1%3_r8 x_PM_AOI222_X1%3_12 x_PM_AOI222_X1%3_11 1.52
R_x_PM_AOI222_X1%3_r9 x_PM_AOI222_X1%3_12 x_PM_AOI222_X1%3_9 0.212317
R_x_PM_AOI222_X1%3_r10 x_PM_AOI222_X1%3_10 x_PM_AOI222_X1%3_9 0.76
R_x_PM_AOI222_X1%3_r11 x_PM_AOI222_X1%3_10 x_PM_AOI222_X1%3_7 0.212317
R_x_PM_AOI222_X1%3_r12 x_PM_AOI222_X1%3_8 x_PM_AOI222_X1%3_7 1.79143
R_x_PM_AOI222_X1%3_r13 x_PM_AOI222_X1%3_8 x_PM_AOI222_X1%3_3 0.212317
R_x_PM_AOI222_X1%3_r14 N_3_M6_s x_PM_AOI222_X1%3_3 0.230714
R_x_PM_AOI222_X1%3_r15 N_3_M9_d x_PM_AOI222_X1%3_13 0.230714
C_x_PM_AOI222_X1%4_c0 VSS x_PM_AOI222_X1%4_11 4.71609e-17
C_x_PM_AOI222_X1%4_c1 VSS x_PM_AOI222_X1%4_9 1.17022e-17
C_x_PM_AOI222_X1%4_c2 VSS x_PM_AOI222_X1%4_8 1.87503e-16
C_x_PM_AOI222_X1%4_c3 VSS N_4_M0_s 3.91529e-17
C_x_PM_AOI222_X1%4_c4 VSS N_4_M5_d 1.11365e-16
R_x_PM_AOI222_X1%4_r5 N_4_M3_d x_PM_AOI222_X1%4_12 0.197151
R_x_PM_AOI222_X1%4_r6 N_4_M3_d x_PM_AOI222_X1%4_11 0.0151655
R_x_PM_AOI222_X1%4_r7 x_PM_AOI222_X1%4_11 x_PM_AOI222_X1%4_10 1.00429
R_x_PM_AOI222_X1%4_r8 x_PM_AOI222_X1%4_10 x_PM_AOI222_X1%4_8 0.212317
R_x_PM_AOI222_X1%4_r9 x_PM_AOI222_X1%4_9 x_PM_AOI222_X1%4_8 3.69143
R_x_PM_AOI222_X1%4_r10 x_PM_AOI222_X1%4_9 x_PM_AOI222_X1%4_4 0.212317
R_x_PM_AOI222_X1%4_r11 N_4_M0_s x_PM_AOI222_X1%4_4 1.01786
R_x_PM_AOI222_X1%4_r12 N_4_M5_d x_PM_AOI222_X1%4_12 1.88643
C_x_PM_AOI222_X1%B2_c0 VSS x_PM_AOI222_X1%B2_14 7.6954e-18
C_x_PM_AOI222_X1%B2_c1 VSS x_PM_AOI222_X1%B2_12 5.25664e-17
C_x_PM_AOI222_X1%B2_c2 VSS N_B2_M0_g 5.63631e-17
C_x_PM_AOI222_X1%B2_c3 VSS N_B2_M6_g 4.73892e-17
R_x_PM_AOI222_X1%B2_r4 x_PM_AOI222_X1%B2_18 x_PM_AOI222_X1%B2_14 4.74714
R_x_PM_AOI222_X1%B2_r5 x_PM_AOI222_X1%B2_17 x_PM_AOI222_X1%B2_14 4.74714
R_x_PM_AOI222_X1%B2_r6 x_PM_AOI222_X1%B2_14 x_PM_AOI222_X1%B2_12 25.0012
R_x_PM_AOI222_X1%B2_r7 x_PM_AOI222_X1%B2_12 B2 0.156071
R_x_PM_AOI222_X1%B2_r8 N_B2_M0_g x_PM_AOI222_X1%B2_18 51.48
R_x_PM_AOI222_X1%B2_r9 N_B2_M6_g x_PM_AOI222_X1%B2_17 51.48
C_x_PM_AOI222_X1%6_c0 VSS N_6_M2_d 1.59718e-16
R_x_PM_AOI222_X1%6_r1 N_6_M2_d N_6_M0_d 2.03571
C_x_PM_AOI222_X1%C2_c0 VSS x_PM_AOI222_X1%C2_14 9.41034e-18
C_x_PM_AOI222_X1%C2_c1 VSS x_PM_AOI222_X1%C2_12 7.56814e-17
C_x_PM_AOI222_X1%C2_c2 VSS N_C2_M1_g 5.74689e-17
C_x_PM_AOI222_X1%C2_c3 VSS N_C2_M7_g 4.80234e-17
R_x_PM_AOI222_X1%C2_r4 x_PM_AOI222_X1%C2_18 x_PM_AOI222_X1%C2_14 4.74714
R_x_PM_AOI222_X1%C2_r5 x_PM_AOI222_X1%C2_17 x_PM_AOI222_X1%C2_14 4.74714
R_x_PM_AOI222_X1%C2_r6 x_PM_AOI222_X1%C2_14 x_PM_AOI222_X1%C2_12 25.0012
R_x_PM_AOI222_X1%C2_r7 x_PM_AOI222_X1%C2_12 C2 0.156071
R_x_PM_AOI222_X1%C2_r8 N_C2_M1_g x_PM_AOI222_X1%C2_18 51.48
R_x_PM_AOI222_X1%C2_r9 N_C2_M7_g x_PM_AOI222_X1%C2_17 51.48
C_x_PM_AOI222_X1%C1_c0 VSS x_PM_AOI222_X1%C1_14 9.35685e-18
C_x_PM_AOI222_X1%C1_c1 VSS x_PM_AOI222_X1%C1_12 7.41191e-17
C_x_PM_AOI222_X1%C1_c2 VSS N_C1_M2_g 5.83171e-17
C_x_PM_AOI222_X1%C1_c3 VSS N_C1_M8_g 4.70195e-17
R_x_PM_AOI222_X1%C1_r4 x_PM_AOI222_X1%C1_18 x_PM_AOI222_X1%C1_14 4.74714
R_x_PM_AOI222_X1%C1_r5 x_PM_AOI222_X1%C1_17 x_PM_AOI222_X1%C1_14 4.74714
R_x_PM_AOI222_X1%C1_r6 x_PM_AOI222_X1%C1_14 x_PM_AOI222_X1%C1_12 25.0012
R_x_PM_AOI222_X1%C1_r7 x_PM_AOI222_X1%C1_12 C1 0.156071
R_x_PM_AOI222_X1%C1_r8 N_C1_M2_g x_PM_AOI222_X1%C1_18 51.48
R_x_PM_AOI222_X1%C1_r9 N_C1_M8_g x_PM_AOI222_X1%C1_17 51.48
C_x_PM_AOI222_X1%ZN_c0 VSS x_PM_AOI222_X1%ZN_23 2.26282e-18
C_x_PM_AOI222_X1%ZN_c1 VSS N_ZN_M8_d 8.25173e-17
C_x_PM_AOI222_X1%ZN_c2 VSS ZN 4.8037e-17
C_x_PM_AOI222_X1%ZN_c3 VSS N_ZN_M11_d 5.10358e-17
C_x_PM_AOI222_X1%ZN_c4 VSS x_PM_AOI222_X1%ZN_6 6.0087e-17
C_x_PM_AOI222_X1%ZN_c5 VSS x_PM_AOI222_X1%ZN_4 6.24031e-17
R_x_PM_AOI222_X1%ZN_r6 x_PM_AOI222_X1%ZN_21 N_ZN_M8_d 0.316667
R_x_PM_AOI222_X1%ZN_r7 ZN x_PM_AOI222_X1%ZN_15 1.67647
R_x_PM_AOI222_X1%ZN_r8 x_PM_AOI222_X1%ZN_23 x_PM_AOI222_X1%ZN_14 0.136506
R_x_PM_AOI222_X1%ZN_r9 ZN x_PM_AOI222_X1%ZN_14 0.245882
R_x_PM_AOI222_X1%ZN_r10 x_PM_AOI222_X1%ZN_23 x_PM_AOI222_X1%ZN_10 0.136506
R_x_PM_AOI222_X1%ZN_r11 N_ZN_M11_d x_PM_AOI222_X1%ZN_10 1.28529
R_x_PM_AOI222_X1%ZN_r12 x_PM_AOI222_X1%ZN_15 x_PM_AOI222_X1%ZN_6 0.214913
R_x_PM_AOI222_X1%ZN_r13 N_ZN_M4_d x_PM_AOI222_X1%ZN_6 0.936429
R_x_PM_AOI222_X1%ZN_r14 x_PM_AOI222_X1%ZN_21 x_PM_AOI222_X1%ZN_5 0.095
R_x_PM_AOI222_X1%ZN_r15 x_PM_AOI222_X1%ZN_23 x_PM_AOI222_X1%ZN_4 0.0638579
R_x_PM_AOI222_X1%ZN_r16 x_PM_AOI222_X1%ZN_5 x_PM_AOI222_X1%ZN_4 2.63286
C_x_PM_AOI222_X1%B1_c0 VSS x_PM_AOI222_X1%B1_14 9.44794e-18
C_x_PM_AOI222_X1%B1_c1 VSS x_PM_AOI222_X1%B1_12 7.82399e-17
C_x_PM_AOI222_X1%B1_c2 VSS N_B1_M3_g 5.41911e-17
C_x_PM_AOI222_X1%B1_c3 VSS N_B1_M9_g 4.85589e-17
R_x_PM_AOI222_X1%B1_r4 x_PM_AOI222_X1%B1_18 x_PM_AOI222_X1%B1_14 4.74714
R_x_PM_AOI222_X1%B1_r5 x_PM_AOI222_X1%B1_17 x_PM_AOI222_X1%B1_14 4.74714
R_x_PM_AOI222_X1%B1_r6 x_PM_AOI222_X1%B1_14 x_PM_AOI222_X1%B1_12 25.0012
R_x_PM_AOI222_X1%B1_r7 x_PM_AOI222_X1%B1_12 B1 0.156071
R_x_PM_AOI222_X1%B1_r8 N_B1_M3_g x_PM_AOI222_X1%B1_18 51.48
R_x_PM_AOI222_X1%B1_r9 N_B1_M9_g x_PM_AOI222_X1%B1_17 51.48
C_x_PM_AOI222_X1%A2_c0 VSS x_PM_AOI222_X1%A2_19 1.24849e-17
C_x_PM_AOI222_X1%A2_c1 VSS x_PM_AOI222_X1%A2_12 7.04828e-17
C_x_PM_AOI222_X1%A2_c2 VSS N_A2_M10_g 6.96821e-17
C_x_PM_AOI222_X1%A2_c3 VSS N_A2_M4_g 5.45474e-17
R_x_PM_AOI222_X1%A2_r4 x_PM_AOI222_X1%A2_19 x_PM_AOI222_X1%A2_18 2.6
R_x_PM_AOI222_X1%A2_r5 x_PM_AOI222_X1%A2_18 x_PM_AOI222_X1%A2_14 1.82
R_x_PM_AOI222_X1%A2_r6 x_PM_AOI222_X1%A2_14 x_PM_AOI222_X1%A2_12 25.0012
R_x_PM_AOI222_X1%A2_r7 x_PM_AOI222_X1%A2_12 A2 0.156071
R_x_PM_AOI222_X1%A2_r8 x_PM_AOI222_X1%A2_19 x_PM_AOI222_X1%A2_5 1.95
R_x_PM_AOI222_X1%A2_r9 N_A2_M10_g x_PM_AOI222_X1%A2_5 85.02
R_x_PM_AOI222_X1%A2_r10 x_PM_AOI222_X1%A2_18 x_PM_AOI222_X1%A2_VSS 1.95
R_x_PM_AOI222_X1%A2_r11 N_A2_M4_g x_PM_AOI222_X1%A2_VSS 50.7
C_x_PM_AOI222_X1%A1_c0 VSS x_PM_AOI222_X1%A1_19 1.43626e-17
C_x_PM_AOI222_X1%A1_c1 VSS x_PM_AOI222_X1%A1_12 6.93523e-17
C_x_PM_AOI222_X1%A1_c2 VSS N_A1_M11_g 7.61882e-17
C_x_PM_AOI222_X1%A1_c3 VSS N_A1_M5_g 5.6867e-17
R_x_PM_AOI222_X1%A1_r4 x_PM_AOI222_X1%A1_19 x_PM_AOI222_X1%A1_18 2.6
R_x_PM_AOI222_X1%A1_r5 x_PM_AOI222_X1%A1_18 x_PM_AOI222_X1%A1_14 1.82
R_x_PM_AOI222_X1%A1_r6 x_PM_AOI222_X1%A1_14 x_PM_AOI222_X1%A1_12 25.0012
R_x_PM_AOI222_X1%A1_r7 x_PM_AOI222_X1%A1_12 A1 0.156071
R_x_PM_AOI222_X1%A1_r8 x_PM_AOI222_X1%A1_19 x_PM_AOI222_X1%A1_5 1.95
R_x_PM_AOI222_X1%A1_r9 N_A1_M11_g x_PM_AOI222_X1%A1_5 85.02
R_x_PM_AOI222_X1%A1_r10 x_PM_AOI222_X1%A1_18 x_PM_AOI222_X1%A1_VSS 1.95
R_x_PM_AOI222_X1%A1_r11 N_A1_M5_g x_PM_AOI222_X1%A1_VSS 50.7
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X2 VSS VDD B2 C2 C1 ZN B1 A2 A1
*.PININFO VSS:B VDD:B B2:I C2:I C1:I ZN:O B1:I A1:I A2:I
M_M6 N_6_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M7 N_VDD_M1_d N_C2_M1_g N_6_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M8 N_6_M2_d N_C1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M9 N_4_M3_d N_B1_M3_g N_6_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M10 N_ZN_M4_d N_A1_M4_g N_4_M3_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M11 N_4_M5_d N_A2_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 N_VSS_M6_d N_B2_M6_g N_3_M6_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 noxref_13 N_C2_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_ZN_M8_d N_C1_M8_g noxref_13 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_3_M9_d N_B1_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 noxref_14 N_A1_M10_g N_ZN_M10_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_VSS_M11_d N_A2_M11_g noxref_14 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI222_X2%VSS_c0 VSS N_VSS_M6_d 3.12363e-17
C_x_PM_AOI222_X2%VSS_c1 VSS N_VSS_M11_d 1.86937e-17
C_x_PM_AOI222_X2%VSS_c2 VSS x_PM_AOI222_X2%VSS_6 2.85781e-17
C_x_PM_AOI222_X2%VSS_c3 VSS x_PM_AOI222_X2%VSS_5 2.08647e-16
R_x_PM_AOI222_X2%VSS_r4 N_VSS_M11_d x_PM_AOI222_X2%VSS_9 0.230714
R_x_PM_AOI222_X2%VSS_r5 x_PM_AOI222_X2%VSS_6 N_VSS_M6_d 0.141744
R_x_PM_AOI222_X2%VSS_r6 VSS x_PM_AOI222_X2%VSS_6 0.793529
R_x_PM_AOI222_X2%VSS_r7 x_PM_AOI222_X2%VSS_9 x_PM_AOI222_X2%VSS_5 0.264221
R_x_PM_AOI222_X2%VSS_r8 VSS x_PM_AOI222_X2%VSS_5 1.44176
C_x_PM_AOI222_X2%VDD_c0 VSS x_PM_AOI222_X2%VDD_12 1.13717e-16
C_x_PM_AOI222_X2%VDD_c1 VSS N_VDD_M1_d 5.91299e-17
C_x_PM_AOI222_X2%VDD_c2 VSS x_PM_AOI222_X2%VDD_2 4.57735e-17
R_x_PM_AOI222_X2%VDD_r3 x_PM_AOI222_X2%VDD_12 x_PM_AOI222_X2%VDD_6 0.0680382
R_x_PM_AOI222_X2%VDD_r4 N_VDD_M1_d x_PM_AOI222_X2%VDD_6 0.133704
R_x_PM_AOI222_X2%VDD_r5 x_PM_AOI222_X2%VDD_12 x_PM_AOI222_X2%VDD_2 0.132285
R_x_PM_AOI222_X2%VDD_r6 VDD x_PM_AOI222_X2%VDD_2 0.514118
C_x_PM_AOI222_X2%3_c0 VSS N_3_M9_d 1.63779e-16
R_x_PM_AOI222_X2%3_r1 N_3_M9_d N_3_M6_s 4.09857
C_x_PM_AOI222_X2%4_c0 VSS x_PM_AOI222_X2%4_17 7.706e-18
C_x_PM_AOI222_X2%4_c1 VSS N_4_M0_s 2.86535e-17
C_x_PM_AOI222_X2%4_c2 VSS x_PM_AOI222_X2%4_12 4.50179e-17
C_x_PM_AOI222_X2%4_c3 VSS N_4_M3_d 5.25186e-17
C_x_PM_AOI222_X2%4_c4 VSS x_PM_AOI222_X2%4_6 1.11738e-16
C_x_PM_AOI222_X2%4_c5 VSS N_4_M5_d 2.92885e-17
R_x_PM_AOI222_X2%4_r6 x_PM_AOI222_X2%4_17 x_PM_AOI222_X2%4_13 0.266978
R_x_PM_AOI222_X2%4_r7 x_PM_AOI222_X2%4_13 x_PM_AOI222_X2%4_12 1.92714
R_x_PM_AOI222_X2%4_r8 x_PM_AOI222_X2%4_17 x_PM_AOI222_X2%4_8 0.0272847
R_x_PM_AOI222_X2%4_r9 N_4_M3_d x_PM_AOI222_X2%4_8 0.513704
R_x_PM_AOI222_X2%4_r10 N_4_M0_s x_PM_AOI222_X2%4_7 0.198162
R_x_PM_AOI222_X2%4_r11 x_PM_AOI222_X2%4_17 x_PM_AOI222_X2%4_6 0.266978
R_x_PM_AOI222_X2%4_r12 x_PM_AOI222_X2%4_7 x_PM_AOI222_X2%4_6 3.96286
R_x_PM_AOI222_X2%4_r13 N_4_M5_d x_PM_AOI222_X2%4_12 0.198162
C_x_PM_AOI222_X2%B2_c0 VSS B2 2.76081e-17
C_x_PM_AOI222_X2%B2_c1 VSS x_PM_AOI222_X2%B2_11 7.808e-18
C_x_PM_AOI222_X2%B2_c2 VSS N_B2_M0_g 8.1667e-17
C_x_PM_AOI222_X2%B2_c3 VSS N_B2_M6_g 4.19652e-17
R_x_PM_AOI222_X2%B2_r4 x_PM_AOI222_X2%B2_18 x_PM_AOI222_X2%B2_11 4.7687
R_x_PM_AOI222_X2%B2_r5 x_PM_AOI222_X2%B2_17 x_PM_AOI222_X2%B2_11 4.7687
R_x_PM_AOI222_X2%B2_r6 x_PM_AOI222_X2%B2_11 x_PM_AOI222_X2%B2_9 25.0012
R_x_PM_AOI222_X2%B2_r7 B2 x_PM_AOI222_X2%B2_9 0.0882143
R_x_PM_AOI222_X2%B2_r8 N_B2_M0_g x_PM_AOI222_X2%B2_18 80.34
R_x_PM_AOI222_X2%B2_r9 N_B2_M6_g x_PM_AOI222_X2%B2_17 35.88
C_x_PM_AOI222_X2%6_c0 VSS N_6_M2_d 1.01116e-16
R_x_PM_AOI222_X2%6_r1 N_6_M2_d N_6_M0_d 2.03571
C_x_PM_AOI222_X2%C2_c0 VSS x_PM_AOI222_X2%C2_11 9.80645e-18
C_x_PM_AOI222_X2%C2_c1 VSS x_PM_AOI222_X2%C2_9 3.76316e-17
C_x_PM_AOI222_X2%C2_c2 VSS N_C2_M1_g 7.80612e-17
C_x_PM_AOI222_X2%C2_c3 VSS N_C2_M7_g 5.44172e-17
R_x_PM_AOI222_X2%C2_r4 x_PM_AOI222_X2%C2_11 x_PM_AOI222_X2%C2_16 2.34
R_x_PM_AOI222_X2%C2_r5 x_PM_AOI222_X2%C2_11 x_PM_AOI222_X2%C2_9 25.0012
R_x_PM_AOI222_X2%C2_r6 C2 x_PM_AOI222_X2%C2_9 0.105556
R_x_PM_AOI222_X2%C2_r7 x_PM_AOI222_X2%C2_16 x_PM_AOI222_X2%C2_5 1.95
R_x_PM_AOI222_X2%C2_r8 N_C2_M1_g x_PM_AOI222_X2%C2_5 64.74
R_x_PM_AOI222_X2%C2_r9 x_PM_AOI222_X2%C2_16 x_PM_AOI222_X2%C2_VSS 1.95
R_x_PM_AOI222_X2%C2_r10 N_C2_M7_g x_PM_AOI222_X2%C2_VSS 51.48
C_x_PM_AOI222_X2%C1_c0 VSS C1 3.13397e-17
C_x_PM_AOI222_X2%C1_c1 VSS x_PM_AOI222_X2%C1_11 8.69872e-18
C_x_PM_AOI222_X2%C1_c2 VSS N_C1_M2_g 8.73068e-17
C_x_PM_AOI222_X2%C1_c3 VSS N_C1_M8_g 4.48531e-17
R_x_PM_AOI222_X2%C1_r4 x_PM_AOI222_X2%C1_18 x_PM_AOI222_X2%C1_11 4.7687
R_x_PM_AOI222_X2%C1_r5 x_PM_AOI222_X2%C1_17 x_PM_AOI222_X2%C1_11 4.7687
R_x_PM_AOI222_X2%C1_r6 x_PM_AOI222_X2%C1_11 x_PM_AOI222_X2%C1_9 25.0012
R_x_PM_AOI222_X2%C1_r7 C1 x_PM_AOI222_X2%C1_9 0.0882143
R_x_PM_AOI222_X2%C1_r8 N_C1_M2_g x_PM_AOI222_X2%C1_18 81.12
R_x_PM_AOI222_X2%C1_r9 N_C1_M8_g x_PM_AOI222_X2%C1_17 35.1
C_x_PM_AOI222_X2%ZN_c0 VSS N_ZN_M4_d 3.83564e-17
C_x_PM_AOI222_X2%ZN_c1 VSS x_PM_AOI222_X2%ZN_14 1.17241e-17
C_x_PM_AOI222_X2%ZN_c2 VSS ZN 9.82852e-17
C_x_PM_AOI222_X2%ZN_c3 VSS x_PM_AOI222_X2%ZN_4 1.93644e-16
R_x_PM_AOI222_X2%ZN_r4 N_ZN_M4_d x_PM_AOI222_X2%ZN_14 0.111765
R_x_PM_AOI222_X2%ZN_r5 x_PM_AOI222_X2%ZN_11 x_PM_AOI222_X2%ZN_14 0.202958
R_x_PM_AOI222_X2%ZN_r6 ZN x_PM_AOI222_X2%ZN_11 1.43857
R_x_PM_AOI222_X2%ZN_r7 ZN x_PM_AOI222_X2%ZN_10 1.46571
R_x_PM_AOI222_X2%ZN_r8 N_ZN_M10_s N_ZN_M8_d 1.9
R_x_PM_AOI222_X2%ZN_r9 x_PM_AOI222_X2%ZN_10 x_PM_AOI222_X2%ZN_4 0.212317
R_x_PM_AOI222_X2%ZN_r10 N_ZN_M10_s x_PM_AOI222_X2%ZN_4 0.719286
C_x_PM_AOI222_X2%B1_c0 VSS x_PM_AOI222_X2%B1_11 8.4309e-18
C_x_PM_AOI222_X2%B1_c1 VSS x_PM_AOI222_X2%B1_9 2.78029e-17
C_x_PM_AOI222_X2%B1_c2 VSS N_B1_M3_g 7.60979e-17
C_x_PM_AOI222_X2%B1_c3 VSS N_B1_M9_g 5.79149e-17
R_x_PM_AOI222_X2%B1_r4 x_PM_AOI222_X2%B1_11 x_PM_AOI222_X2%B1_16 2.34
R_x_PM_AOI222_X2%B1_r5 x_PM_AOI222_X2%B1_11 x_PM_AOI222_X2%B1_9 25.0012
R_x_PM_AOI222_X2%B1_r6 B1 x_PM_AOI222_X2%B1_9 0.105556
R_x_PM_AOI222_X2%B1_r7 x_PM_AOI222_X2%B1_16 x_PM_AOI222_X2%B1_5 1.95
R_x_PM_AOI222_X2%B1_r8 N_B1_M3_g x_PM_AOI222_X2%B1_5 64.74
R_x_PM_AOI222_X2%B1_r9 x_PM_AOI222_X2%B1_16 x_PM_AOI222_X2%B1_VSS 1.95
R_x_PM_AOI222_X2%B1_r10 N_B1_M9_g x_PM_AOI222_X2%B1_VSS 51.48
C_x_PM_AOI222_X2%A1_c0 VSS x_PM_AOI222_X2%A1_18 1.07998e-17
C_x_PM_AOI222_X2%A1_c1 VSS x_PM_AOI222_X2%A1_9 6.82151e-17
C_x_PM_AOI222_X2%A1_c2 VSS N_A1_M4_g 6.51795e-17
C_x_PM_AOI222_X2%A1_c3 VSS N_A1_M10_g 6.5154e-17
R_x_PM_AOI222_X2%A1_r4 x_PM_AOI222_X2%A1_18 x_PM_AOI222_X2%A1_11 5.98
R_x_PM_AOI222_X2%A1_r5 x_PM_AOI222_X2%A1_11 x_PM_AOI222_X2%A1_9 25.0012
R_x_PM_AOI222_X2%A1_r6 A1 x_PM_AOI222_X2%A1_9 0.2204
R_x_PM_AOI222_X2%A1_r7 x_PM_AOI222_X2%A1_18 x_PM_AOI222_X2%A1_5 1.95
R_x_PM_AOI222_X2%A1_r8 N_A1_M4_g x_PM_AOI222_X2%A1_5 48.36
R_x_PM_AOI222_X2%A1_r9 x_PM_AOI222_X2%A1_18 x_PM_AOI222_X2%A1_VSS 1.95
R_x_PM_AOI222_X2%A1_r10 N_A1_M10_g x_PM_AOI222_X2%A1_VSS 68.64
C_x_PM_AOI222_X2%A2_c0 VSS x_PM_AOI222_X2%A2_14 7.2135e-18
C_x_PM_AOI222_X2%A2_c1 VSS A2 6.16966e-17
C_x_PM_AOI222_X2%A2_c2 VSS N_A2_M5_g 8.74077e-17
C_x_PM_AOI222_X2%A2_c3 VSS N_A2_M11_g 3.6377e-17
R_x_PM_AOI222_X2%A2_r4 x_PM_AOI222_X2%A2_18 x_PM_AOI222_X2%A2_14 4.74714
R_x_PM_AOI222_X2%A2_r5 x_PM_AOI222_X2%A2_17 x_PM_AOI222_X2%A2_14 4.74714
R_x_PM_AOI222_X2%A2_r6 x_PM_AOI222_X2%A2_14 x_PM_AOI222_X2%A2_12 25.0012
R_x_PM_AOI222_X2%A2_r7 x_PM_AOI222_X2%A2_12 A2 0.266
R_x_PM_AOI222_X2%A2_r8 N_A2_M5_g x_PM_AOI222_X2%A2_18 88.92
R_x_PM_AOI222_X2%A2_r9 N_A2_M11_g x_PM_AOI222_X2%A2_17 28.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI222_X4 VSS VDD B2 C2 C1 ZN B1 A2 A1
*.PININFO VSS:B VDD:B C2:I C1:I ZN:O B2:I B1:I A1:I A2:I
M_M12 N_VDD_M0_d N_C2_M0_g N_3_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M13 N_3_M1_d N_C1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M14 N_VDD_M2_d N_C1_M2_g N_3_M1_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M15 N_3_M3_d N_C2_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M16 N_8_M4_d N_B2_M4_g N_3_M3_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M17 N_3_M5_d N_B1_M5_g N_8_M4_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M18 N_8_M6_d N_B1_M6_g N_3_M5_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M19 N_3_M7_d N_B2_M7_g N_8_M6_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M20 N_8_M8_d N_A1_M8_g N_ZN_M8_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M21 N_ZN_M9_d N_A2_M9_g N_8_M8_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M22 N_8_M10_d N_A2_M10_g N_ZN_M9_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M23 N_ZN_M11_d N_A1_M11_g N_8_M10_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 12 N_C2_M12_g N_VSS_M12_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M13_d N_C1_M13_g 12 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 13 N_C1_M14_g N_ZN_M13_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M15_d N_C2_M15_g 13 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 14 N_B2_M16_g N_VSS_M15_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_ZN_M17_d N_B1_M17_g 14 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 15 N_B1_M18_g N_ZN_M17_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 N_VSS_M19_d N_B2_M19_g 15 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M8 16 N_A1_M20_g N_ZN_M20_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M9 N_VSS_M21_d N_A2_M21_g 16 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M10 17 N_A2_M22_g N_VSS_M21_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M11 N_ZN_M23_d N_A1_M23_g 17 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI222_X4%VSS_c0 VSS N_VSS_M21_d 7.57949e-17
C_x_PM_AOI222_X4%VSS_c1 VSS x_PM_AOI222_X4%VSS_24 2.43444e-17
C_x_PM_AOI222_X4%VSS_c2 VSS x_PM_AOI222_X4%VSS_19 6.18045e-17
C_x_PM_AOI222_X4%VSS_c3 VSS x_PM_AOI222_X4%VSS_11 4.49751e-17
C_x_PM_AOI222_X4%VSS_c4 VSS x_PM_AOI222_X4%VSS_8 2.50704e-17
C_x_PM_AOI222_X4%VSS_c5 VSS x_PM_AOI222_X4%VSS_7 6.83816e-17
C_x_PM_AOI222_X4%VSS_c6 VSS x_PM_AOI222_X4%VSS_6 2.29602e-17
R_x_PM_AOI222_X4%VSS_r7 x_PM_AOI222_X4%VSS_24 N_VSS_M19_d 0.140674
R_x_PM_AOI222_X4%VSS_r8 x_PM_AOI222_X4%VSS_19 N_VSS_M15_d 0.140674
R_x_PM_AOI222_X4%VSS_r9 x_PM_AOI222_X4%VSS_11 N_VSS_M21_d 0.140674
R_x_PM_AOI222_X4%VSS_r10 x_PM_AOI222_X4%VSS_24 x_PM_AOI222_X4%VSS_11 0.95
R_x_PM_AOI222_X4%VSS_r11 x_PM_AOI222_X4%VSS_8 N_VSS_M15_d 0.140674
R_x_PM_AOI222_X4%VSS_r12 VSS x_PM_AOI222_X4%VSS_8 0.905294
R_x_PM_AOI222_X4%VSS_r13 x_PM_AOI222_X4%VSS_7 N_VSS_M19_d 0.140674
R_x_PM_AOI222_X4%VSS_r14 VSS x_PM_AOI222_X4%VSS_7 0.491765
R_x_PM_AOI222_X4%VSS_r15 N_VSS_M12_s x_PM_AOI222_X4%VSS_6 0.111765
R_x_PM_AOI222_X4%VSS_r16 x_PM_AOI222_X4%VSS_6 x_PM_AOI222_X4%VSS_19 1.38588
C_x_PM_AOI222_X4%VDD_c0 VSS x_PM_AOI222_X4%VDD_20 2.19043e-16
C_x_PM_AOI222_X4%VDD_c1 VSS x_PM_AOI222_X4%VDD_19 5.79763e-18
C_x_PM_AOI222_X4%VDD_c2 VSS N_VDD_M2_d 2.7467e-17
C_x_PM_AOI222_X4%VDD_c3 VSS x_PM_AOI222_X4%VDD_11 1.9007e-17
C_x_PM_AOI222_X4%VDD_c4 VSS N_VDD_M0_d 2.59284e-17
C_x_PM_AOI222_X4%VDD_c5 VSS x_PM_AOI222_X4%VDD_3 2.34305e-17
R_x_PM_AOI222_X4%VDD_r6 x_PM_AOI222_X4%VDD_20 x_PM_AOI222_X4%VDD_13 0.0680382
R_x_PM_AOI222_X4%VDD_r7 N_VDD_M2_d x_PM_AOI222_X4%VDD_13 0.11963
R_x_PM_AOI222_X4%VDD_r8 x_PM_AOI222_X4%VDD_19 x_PM_AOI222_X4%VDD_12 0.132285
R_x_PM_AOI222_X4%VDD_r9 x_PM_AOI222_X4%VDD_20 x_PM_AOI222_X4%VDD_11 0.132285
R_x_PM_AOI222_X4%VDD_r10 x_PM_AOI222_X4%VDD_12 x_PM_AOI222_X4%VDD_11 0.558824
R_x_PM_AOI222_X4%VDD_r11 x_PM_AOI222_X4%VDD_19 x_PM_AOI222_X4%VDD_7 0.0680382
R_x_PM_AOI222_X4%VDD_r12 N_VDD_M0_d x_PM_AOI222_X4%VDD_7 0.11963
R_x_PM_AOI222_X4%VDD_r13 x_PM_AOI222_X4%VDD_19 x_PM_AOI222_X4%VDD_3 0.132285
R_x_PM_AOI222_X4%VDD_r14 VDD x_PM_AOI222_X4%VDD_3 0.245882
C_x_PM_AOI222_X4%3_c0 VSS N_3_M0_s 1.38309e-17
C_x_PM_AOI222_X4%3_c1 VSS x_PM_AOI222_X4%3_6 1.68986e-16
C_x_PM_AOI222_X4%3_c2 VSS N_3_M7_d 2.42636e-17
R_x_PM_AOI222_X4%3_r3 x_PM_AOI222_X4%3_21 N_3_M0_s 0.257857
R_x_PM_AOI222_X4%3_r4 N_3_M5_d N_3_M3_d 2.09
R_x_PM_AOI222_X4%3_r5 N_3_M3_d N_3_M1_d 2.06286
R_x_PM_AOI222_X4%3_r6 x_PM_AOI222_X4%3_21 x_PM_AOI222_X4%3_7 0.095
R_x_PM_AOI222_X4%3_r7 N_3_M1_d x_PM_AOI222_X4%3_7 1.83214
R_x_PM_AOI222_X4%3_r8 x_PM_AOI222_X4%3_14 x_PM_AOI222_X4%3_6 0.212317
R_x_PM_AOI222_X4%3_r9 N_3_M5_d x_PM_AOI222_X4%3_6 1.83214
R_x_PM_AOI222_X4%3_r10 N_3_M7_d x_PM_AOI222_X4%3_14 0.149286
C_x_PM_AOI222_X4%C2_c0 VSS x_PM_AOI222_X4%C2_26 6.85835e-18
C_x_PM_AOI222_X4%C2_c1 VSS x_PM_AOI222_X4%C2_22 8.22468e-18
C_x_PM_AOI222_X4%C2_c2 VSS x_PM_AOI222_X4%C2_20 8.65336e-17
C_x_PM_AOI222_X4%C2_c3 VSS x_PM_AOI222_X4%C2_17 2.10099e-17
C_x_PM_AOI222_X4%C2_c4 VSS N_C2_M3_g 7.05152e-17
C_x_PM_AOI222_X4%C2_c5 VSS N_C2_M15_g 5.76481e-17
C_x_PM_AOI222_X4%C2_c6 VSS N_C2_M0_g 6.85609e-17
C_x_PM_AOI222_X4%C2_c7 VSS N_C2_M12_g 4.81393e-17
R_x_PM_AOI222_X4%C2_r8 x_PM_AOI222_X4%C2_31 x_PM_AOI222_X4%C2_26 4.7687
R_x_PM_AOI222_X4%C2_r9 x_PM_AOI222_X4%C2_30 x_PM_AOI222_X4%C2_26 4.7687
R_x_PM_AOI222_X4%C2_r10 x_PM_AOI222_X4%C2_26 x_PM_AOI222_X4%C2_24 25.0012
R_x_PM_AOI222_X4%C2_r11 x_PM_AOI222_X4%C2_34 x_PM_AOI222_X4%C2_22 4.7687
R_x_PM_AOI222_X4%C2_r12 x_PM_AOI222_X4%C2_33 x_PM_AOI222_X4%C2_22 4.7687
R_x_PM_AOI222_X4%C2_r13 x_PM_AOI222_X4%C2_22 x_PM_AOI222_X4%C2_20 25.0012
R_x_PM_AOI222_X4%C2_r14 x_PM_AOI222_X4%C2_20 C2 0.958636
R_x_PM_AOI222_X4%C2_r15 x_PM_AOI222_X4%C2_17 x_PM_AOI222_X4%C2_24 0.323854
R_x_PM_AOI222_X4%C2_r16 C2 x_PM_AOI222_X4%C2_17 0.535455
R_x_PM_AOI222_X4%C2_r17 N_C2_M3_g x_PM_AOI222_X4%C2_34 60.84
R_x_PM_AOI222_X4%C2_r18 N_C2_M15_g x_PM_AOI222_X4%C2_33 56.94
R_x_PM_AOI222_X4%C2_r19 N_C2_M0_g x_PM_AOI222_X4%C2_31 65.52
R_x_PM_AOI222_X4%C2_r20 N_C2_M12_g x_PM_AOI222_X4%C2_30 52.26
C_x_PM_AOI222_X4%C1_c0 VSS C1 3.29817e-17
C_x_PM_AOI222_X4%C1_c1 VSS x_PM_AOI222_X4%C1_20 4.36553e-18
C_x_PM_AOI222_X4%C1_c2 VSS x_PM_AOI222_X4%C1_19 7.14297e-18
C_x_PM_AOI222_X4%C1_c3 VSS x_PM_AOI222_X4%C1_18 4.23234e-18
C_x_PM_AOI222_X4%C1_c4 VSS N_C1_M2_g 6.74994e-17
C_x_PM_AOI222_X4%C1_c5 VSS N_C1_M14_g 3.47853e-17
C_x_PM_AOI222_X4%C1_c6 VSS N_C1_M1_g 6.77797e-17
C_x_PM_AOI222_X4%C1_c7 VSS N_C1_M13_g 3.07331e-17
R_x_PM_AOI222_X4%C1_r8 x_PM_AOI222_X4%C1_23 x_PM_AOI222_X4%C1_21 25.0012
R_x_PM_AOI222_X4%C1_r9 C1 x_PM_AOI222_X4%C1_21 0.0135714
R_x_PM_AOI222_X4%C1_r10 x_PM_AOI222_X4%C1_23 x_PM_AOI222_X4%C1_19 8.06
R_x_PM_AOI222_X4%C1_r11 x_PM_AOI222_X4%C1_20 x_PM_AOI222_X4%C1_19 0.043368
R_x_PM_AOI222_X4%C1_r12 x_PM_AOI222_X4%C1_23 x_PM_AOI222_X4%C1_17 6.5
R_x_PM_AOI222_X4%C1_r13 x_PM_AOI222_X4%C1_18 x_PM_AOI222_X4%C1_17 0.043368
R_x_PM_AOI222_X4%C1_r14 x_PM_AOI222_X4%C1_20 x_PM_AOI222_X4%C1_13 4.56151
R_x_PM_AOI222_X4%C1_r15 N_C1_M2_g x_PM_AOI222_X4%C1_13 81.9
R_x_PM_AOI222_X4%C1_r16 x_PM_AOI222_X4%C1_20 x_PM_AOI222_X4%C1_9 4.56151
R_x_PM_AOI222_X4%C1_r17 N_C1_M14_g x_PM_AOI222_X4%C1_9 35.88
R_x_PM_AOI222_X4%C1_r18 x_PM_AOI222_X4%C1_18 x_PM_AOI222_X4%C1_5 4.56151
R_x_PM_AOI222_X4%C1_r19 N_C1_M1_g x_PM_AOI222_X4%C1_5 81.9
R_x_PM_AOI222_X4%C1_r20 x_PM_AOI222_X4%C1_18 x_PM_AOI222_X4%C1_VSS 4.56151
R_x_PM_AOI222_X4%C1_r21 N_C1_M13_g x_PM_AOI222_X4%C1_VSS 35.88
C_x_PM_AOI222_X4%ZN_c0 VSS N_ZN_M20_s 1.7285e-17
C_x_PM_AOI222_X4%ZN_c1 VSS N_ZN_M23_d 1.01751e-16
C_x_PM_AOI222_X4%ZN_c2 VSS N_ZN_M11_d 1.22228e-16
C_x_PM_AOI222_X4%ZN_c3 VSS x_PM_AOI222_X4%ZN_15 6.68282e-17
C_x_PM_AOI222_X4%ZN_c4 VSS x_PM_AOI222_X4%ZN_8 2.3476e-16
R_x_PM_AOI222_X4%ZN_r5 x_PM_AOI222_X4%ZN_32 ZN 0.254502
R_x_PM_AOI222_X4%ZN_r6 ZN x_PM_AOI222_X4%ZN_29 0.110833
R_x_PM_AOI222_X4%ZN_r7 x_PM_AOI222_X4%ZN_29 N_ZN_M20_s 0.00791667
R_x_PM_AOI222_X4%ZN_r8 x_PM_AOI222_X4%ZN_29 x_PM_AOI222_X4%ZN_22 0.095
R_x_PM_AOI222_X4%ZN_r9 N_ZN_M23_d x_PM_AOI222_X4%ZN_22 3.895
R_x_PM_AOI222_X4%ZN_r10 N_ZN_M11_d N_ZN_M9_d 2.06286
R_x_PM_AOI222_X4%ZN_r11 N_ZN_M8_s x_PM_AOI222_X4%ZN_16 0.0130251
R_x_PM_AOI222_X4%ZN_r12 N_ZN_M9_d x_PM_AOI222_X4%ZN_16 2.02214
R_x_PM_AOI222_X4%ZN_r13 N_ZN_M8_s x_PM_AOI222_X4%ZN_15 0.201888
R_x_PM_AOI222_X4%ZN_r14 x_PM_AOI222_X4%ZN_15 x_PM_AOI222_X4%ZN_32 1.65412
R_x_PM_AOI222_X4%ZN_r15 N_ZN_M17_d N_ZN_M13_d 4.09857
R_x_PM_AOI222_X4%ZN_r16 x_PM_AOI222_X4%ZN_29 x_PM_AOI222_X4%ZN_8 0.095
R_x_PM_AOI222_X4%ZN_r17 N_ZN_M17_d x_PM_AOI222_X4%ZN_8 2.61929
C_x_PM_AOI222_X4%B2_c0 VSS x_PM_AOI222_X4%B2_26 7.89594e-18
C_x_PM_AOI222_X4%B2_c1 VSS B2 1.38576e-16
C_x_PM_AOI222_X4%B2_c2 VSS x_PM_AOI222_X4%B2_20 8.4426e-18
C_x_PM_AOI222_X4%B2_c3 VSS x_PM_AOI222_X4%B2_17 2.68258e-17
C_x_PM_AOI222_X4%B2_c4 VSS N_B2_M7_g 9.38687e-17
C_x_PM_AOI222_X4%B2_c5 VSS N_B2_M19_g 4.20784e-17
C_x_PM_AOI222_X4%B2_c6 VSS N_B2_M4_g 8.7894e-17
C_x_PM_AOI222_X4%B2_c7 VSS N_B2_M16_g 4.22423e-17
R_x_PM_AOI222_X4%B2_r8 x_PM_AOI222_X4%B2_32 x_PM_AOI222_X4%B2_26 4.7687
R_x_PM_AOI222_X4%B2_r9 x_PM_AOI222_X4%B2_31 x_PM_AOI222_X4%B2_26 4.7687
R_x_PM_AOI222_X4%B2_r10 x_PM_AOI222_X4%B2_26 x_PM_AOI222_X4%B2_24 25.0012
R_x_PM_AOI222_X4%B2_r11 x_PM_AOI222_X4%B2_24 B2 2.39322
R_x_PM_AOI222_X4%B2_r12 x_PM_AOI222_X4%B2_29 x_PM_AOI222_X4%B2_20 4.7687
R_x_PM_AOI222_X4%B2_r13 x_PM_AOI222_X4%B2_28 x_PM_AOI222_X4%B2_20 4.7687
R_x_PM_AOI222_X4%B2_r14 x_PM_AOI222_X4%B2_20 x_PM_AOI222_X4%B2_18 25.0012
R_x_PM_AOI222_X4%B2_r15 B2 x_PM_AOI222_X4%B2_17 0.175119
R_x_PM_AOI222_X4%B2_r16 x_PM_AOI222_X4%B2_18 x_PM_AOI222_X4%B2_17 0.366429
R_x_PM_AOI222_X4%B2_r17 N_B2_M7_g x_PM_AOI222_X4%B2_32 87.36
R_x_PM_AOI222_X4%B2_r18 N_B2_M19_g x_PM_AOI222_X4%B2_31 30.42
R_x_PM_AOI222_X4%B2_r19 N_B2_M4_g x_PM_AOI222_X4%B2_29 87.36
R_x_PM_AOI222_X4%B2_r20 N_B2_M16_g x_PM_AOI222_X4%B2_28 30.42
C_x_PM_AOI222_X4%8_c0 VSS N_8_M10_d 1.91332e-16
R_x_PM_AOI222_X4%8_r1 N_8_M8_d N_8_M6_d 3.04
R_x_PM_AOI222_X4%8_r2 N_8_M6_d N_8_M4_d 2.03571
R_x_PM_AOI222_X4%8_r3 N_8_M10_d N_8_M8_d 2.06286
C_x_PM_AOI222_X4%B1_c0 VSS x_PM_AOI222_X4%B1_21 2.29195e-17
C_x_PM_AOI222_X4%B1_c1 VSS x_PM_AOI222_X4%B1_20 4.3503e-18
C_x_PM_AOI222_X4%B1_c2 VSS x_PM_AOI222_X4%B1_19 5.27147e-18
C_x_PM_AOI222_X4%B1_c3 VSS x_PM_AOI222_X4%B1_18 4.38057e-18
C_x_PM_AOI222_X4%B1_c4 VSS N_B1_M6_g 5.72703e-17
C_x_PM_AOI222_X4%B1_c5 VSS N_B1_M18_g 4.81161e-17
C_x_PM_AOI222_X4%B1_c6 VSS N_B1_M5_g 5.74193e-17
C_x_PM_AOI222_X4%B1_c7 VSS N_B1_M17_g 4.82887e-17
R_x_PM_AOI222_X4%B1_r8 x_PM_AOI222_X4%B1_23 x_PM_AOI222_X4%B1_21 25.0012
R_x_PM_AOI222_X4%B1_r9 B1 x_PM_AOI222_X4%B1_21 0.0135714
R_x_PM_AOI222_X4%B1_r10 x_PM_AOI222_X4%B1_23 x_PM_AOI222_X4%B1_19 8.06
R_x_PM_AOI222_X4%B1_r11 x_PM_AOI222_X4%B1_20 x_PM_AOI222_X4%B1_19 0.043368
R_x_PM_AOI222_X4%B1_r12 x_PM_AOI222_X4%B1_23 x_PM_AOI222_X4%B1_17 6.5
R_x_PM_AOI222_X4%B1_r13 x_PM_AOI222_X4%B1_18 x_PM_AOI222_X4%B1_17 0.043368
R_x_PM_AOI222_X4%B1_r14 x_PM_AOI222_X4%B1_20 x_PM_AOI222_X4%B1_13 4.56151
R_x_PM_AOI222_X4%B1_r15 N_B1_M6_g x_PM_AOI222_X4%B1_13 60.06
R_x_PM_AOI222_X4%B1_r16 x_PM_AOI222_X4%B1_20 x_PM_AOI222_X4%B1_9 4.56151
R_x_PM_AOI222_X4%B1_r17 N_B1_M18_g x_PM_AOI222_X4%B1_9 57.72
R_x_PM_AOI222_X4%B1_r18 x_PM_AOI222_X4%B1_18 x_PM_AOI222_X4%B1_5 4.56151
R_x_PM_AOI222_X4%B1_r19 N_B1_M5_g x_PM_AOI222_X4%B1_5 60.06
R_x_PM_AOI222_X4%B1_r20 x_PM_AOI222_X4%B1_18 x_PM_AOI222_X4%B1_VSS 4.56151
R_x_PM_AOI222_X4%B1_r21 N_B1_M17_g x_PM_AOI222_X4%B1_VSS 57.72
C_x_PM_AOI222_X4%A1_c0 VSS x_PM_AOI222_X4%A1_29 6.41872e-18
C_x_PM_AOI222_X4%A1_c1 VSS x_PM_AOI222_X4%A1_27 3.57807e-17
C_x_PM_AOI222_X4%A1_c2 VSS x_PM_AOI222_X4%A1_26 8.27147e-17
C_x_PM_AOI222_X4%A1_c3 VSS x_PM_AOI222_X4%A1_23 2.55567e-17
C_x_PM_AOI222_X4%A1_c4 VSS x_PM_AOI222_X4%A1_20 1.04981e-17
C_x_PM_AOI222_X4%A1_c5 VSS x_PM_AOI222_X4%A1_18 1.93316e-17
C_x_PM_AOI222_X4%A1_c6 VSS N_A1_M11_g 6.32443e-17
C_x_PM_AOI222_X4%A1_c7 VSS N_A1_M23_g 5.4881e-17
C_x_PM_AOI222_X4%A1_c8 VSS N_A1_M8_g 7.84338e-17
C_x_PM_AOI222_X4%A1_c9 VSS N_A1_M20_g 5.78118e-17
R_x_PM_AOI222_X4%A1_r10 x_PM_AOI222_X4%A1_36 x_PM_AOI222_X4%A1_29 4.7687
R_x_PM_AOI222_X4%A1_r11 x_PM_AOI222_X4%A1_35 x_PM_AOI222_X4%A1_29 4.7687
R_x_PM_AOI222_X4%A1_r12 x_PM_AOI222_X4%A1_29 x_PM_AOI222_X4%A1_27 25.0012
R_x_PM_AOI222_X4%A1_r13 x_PM_AOI222_X4%A1_27 A1 0.210357
R_x_PM_AOI222_X4%A1_r14 x_PM_AOI222_X4%A1_26 A1 0.176411
R_x_PM_AOI222_X4%A1_r15 x_PM_AOI222_X4%A1_23 x_PM_AOI222_X4%A1_26 1.976
R_x_PM_AOI222_X4%A1_r16 x_PM_AOI222_X4%A1_33 x_PM_AOI222_X4%A1_20 4.74714
R_x_PM_AOI222_X4%A1_r17 x_PM_AOI222_X4%A1_32 x_PM_AOI222_X4%A1_20 4.74714
R_x_PM_AOI222_X4%A1_r18 x_PM_AOI222_X4%A1_20 x_PM_AOI222_X4%A1_18 25.0012
R_x_PM_AOI222_X4%A1_r19 x_PM_AOI222_X4%A1_23 x_PM_AOI222_X4%A1_17 0.212645
R_x_PM_AOI222_X4%A1_r20 x_PM_AOI222_X4%A1_18 x_PM_AOI222_X4%A1_17 0.176429
R_x_PM_AOI222_X4%A1_r21 N_A1_M11_g x_PM_AOI222_X4%A1_36 55.38
R_x_PM_AOI222_X4%A1_r22 N_A1_M23_g x_PM_AOI222_X4%A1_35 62.4
R_x_PM_AOI222_X4%A1_r23 N_A1_M8_g x_PM_AOI222_X4%A1_33 65.52
R_x_PM_AOI222_X4%A1_r24 N_A1_M20_g x_PM_AOI222_X4%A1_32 52.26
C_x_PM_AOI222_X4%A2_c0 VSS x_PM_AOI222_X4%A2_21 5.60424e-17
C_x_PM_AOI222_X4%A2_c1 VSS x_PM_AOI222_X4%A2_20 4.23234e-18
C_x_PM_AOI222_X4%A2_c2 VSS x_PM_AOI222_X4%A2_19 5.57399e-18
C_x_PM_AOI222_X4%A2_c3 VSS x_PM_AOI222_X4%A2_18 4.40968e-18
C_x_PM_AOI222_X4%A2_c4 VSS N_A2_M10_g 7.29479e-17
C_x_PM_AOI222_X4%A2_c5 VSS N_A2_M22_g 3.32406e-17
C_x_PM_AOI222_X4%A2_c6 VSS N_A2_M9_g 7.24433e-17
C_x_PM_AOI222_X4%A2_c7 VSS N_A2_M21_g 3.30708e-17
R_x_PM_AOI222_X4%A2_r8 x_PM_AOI222_X4%A2_23 x_PM_AOI222_X4%A2_21 25.0012
R_x_PM_AOI222_X4%A2_r9 A2 x_PM_AOI222_X4%A2_21 0.0914815
R_x_PM_AOI222_X4%A2_r10 x_PM_AOI222_X4%A2_23 x_PM_AOI222_X4%A2_19 10.14
R_x_PM_AOI222_X4%A2_r11 x_PM_AOI222_X4%A2_20 x_PM_AOI222_X4%A2_19 0.043368
R_x_PM_AOI222_X4%A2_r12 x_PM_AOI222_X4%A2_23 x_PM_AOI222_X4%A2_17 4.42
R_x_PM_AOI222_X4%A2_r13 x_PM_AOI222_X4%A2_18 x_PM_AOI222_X4%A2_17 0.043368
R_x_PM_AOI222_X4%A2_r14 x_PM_AOI222_X4%A2_20 x_PM_AOI222_X4%A2_13 4.56151
R_x_PM_AOI222_X4%A2_r15 N_A2_M10_g x_PM_AOI222_X4%A2_13 86.58
R_x_PM_AOI222_X4%A2_r16 x_PM_AOI222_X4%A2_20 x_PM_AOI222_X4%A2_9 4.56151
R_x_PM_AOI222_X4%A2_r17 N_A2_M22_g x_PM_AOI222_X4%A2_9 31.2
R_x_PM_AOI222_X4%A2_r18 x_PM_AOI222_X4%A2_18 x_PM_AOI222_X4%A2_5 4.56151
R_x_PM_AOI222_X4%A2_r19 N_A2_M9_g x_PM_AOI222_X4%A2_5 86.58
R_x_PM_AOI222_X4%A2_r20 x_PM_AOI222_X4%A2_18 x_PM_AOI222_X4%A2_VSS 4.56151
R_x_PM_AOI222_X4%A2_r21 N_A2_M21_g x_PM_AOI222_X4%A2_VSS 31.2
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X1 VSS VDD B2 B1 ZN A1 A2
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A1:I A2:I
M_M4 N_VDD_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_4_M1_d N_B1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_ZN_M2_d N_A1_M2_g N_4_M1_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_4_M3_d N_A2_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 noxref_9 N_B2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_ZN_M5_d N_B1_M5_g noxref_9 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 noxref_10 N_A1_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_VSS_M7_d N_A2_M7_g noxref_10 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_AOI22_X1%VSS_c0 VSS N_VSS_M7_d 1.32179e-17
C_x_PM_AOI22_X1%VSS_c1 VSS x_PM_AOI22_X1%VSS_8 1.17956e-17
C_x_PM_AOI22_X1%VSS_c2 VSS x_PM_AOI22_X1%VSS_7 8.13874e-17
C_x_PM_AOI22_X1%VSS_c3 VSS N_VSS_M4_s 1.45675e-17
R_x_PM_AOI22_X1%VSS_r4 N_VSS_M7_d x_PM_AOI22_X1%VSS_11 0.420714
R_x_PM_AOI22_X1%VSS_r5 VSS x_PM_AOI22_X1%VSS_8 0.782353
R_x_PM_AOI22_X1%VSS_r6 x_PM_AOI22_X1%VSS_11 x_PM_AOI22_X1%VSS_7 0.264221
R_x_PM_AOI22_X1%VSS_r7 VSS x_PM_AOI22_X1%VSS_7 0.748824
R_x_PM_AOI22_X1%VSS_r8 x_PM_AOI22_X1%VSS_8 x_PM_AOI22_X1%VSS_3 0.264221
R_x_PM_AOI22_X1%VSS_r9 N_VSS_M4_s x_PM_AOI22_X1%VSS_3 0.420714
C_x_PM_AOI22_X1%VDD_c0 VSS x_PM_AOI22_X1%VDD_12 1.31798e-16
C_x_PM_AOI22_X1%VDD_c1 VSS N_VDD_M0_d 4.27765e-17
C_x_PM_AOI22_X1%VDD_c2 VSS x_PM_AOI22_X1%VDD_2 2.53264e-17
R_x_PM_AOI22_X1%VDD_r3 x_PM_AOI22_X1%VDD_12 x_PM_AOI22_X1%VDD_6 0.145286
R_x_PM_AOI22_X1%VDD_r4 N_VDD_M0_d x_PM_AOI22_X1%VDD_6 0.800714
R_x_PM_AOI22_X1%VDD_r5 x_PM_AOI22_X1%VDD_12 x_PM_AOI22_X1%VDD_2 0.0731438
R_x_PM_AOI22_X1%VDD_r6 VDD x_PM_AOI22_X1%VDD_2 0.268235
C_x_PM_AOI22_X1%B2_c0 VSS x_PM_AOI22_X1%B2_13 7.06285e-18
C_x_PM_AOI22_X1%B2_c1 VSS B2 4.16708e-17
C_x_PM_AOI22_X1%B2_c2 VSS N_B2_M0_g 6.55997e-17
C_x_PM_AOI22_X1%B2_c3 VSS N_B2_M4_g 4.31021e-17
R_x_PM_AOI22_X1%B2_r4 x_PM_AOI22_X1%B2_16 x_PM_AOI22_X1%B2_13 4.7687
R_x_PM_AOI22_X1%B2_r5 x_PM_AOI22_X1%B2_15 x_PM_AOI22_X1%B2_13 4.7687
R_x_PM_AOI22_X1%B2_r6 x_PM_AOI22_X1%B2_13 x_PM_AOI22_X1%B2_11 25.0012
R_x_PM_AOI22_X1%B2_r7 x_PM_AOI22_X1%B2_11 B2 0.240878
R_x_PM_AOI22_X1%B2_r8 N_B2_M0_g x_PM_AOI22_X1%B2_16 80.73
R_x_PM_AOI22_X1%B2_r9 N_B2_M4_g x_PM_AOI22_X1%B2_15 50.7
C_x_PM_AOI22_X1%4_c0 VSS x_PM_AOI22_X1%4_16 1.36205e-17
C_x_PM_AOI22_X1%4_c1 VSS x_PM_AOI22_X1%4_11 2.38371e-17
C_x_PM_AOI22_X1%4_c2 VSS x_PM_AOI22_X1%4_10 1.11456e-16
C_x_PM_AOI22_X1%4_c3 VSS N_4_M1_d 1.68968e-17
C_x_PM_AOI22_X1%4_c4 VSS x_PM_AOI22_X1%4_4 5.32308e-17
C_x_PM_AOI22_X1%4_c5 VSS N_4_M3_d 2.00486e-17
R_x_PM_AOI22_X1%4_r6 N_4_M0_s x_PM_AOI22_X1%4_16 0.257857
R_x_PM_AOI22_X1%4_r7 x_PM_AOI22_X1%4_12 x_PM_AOI22_X1%4_10 0.212317
R_x_PM_AOI22_X1%4_r8 x_PM_AOI22_X1%4_11 x_PM_AOI22_X1%4_10 1.65571
R_x_PM_AOI22_X1%4_r9 x_PM_AOI22_X1%4_11 x_PM_AOI22_X1%4_7 0.212317
R_x_PM_AOI22_X1%4_r10 N_4_M1_d x_PM_AOI22_X1%4_7 0.719286
R_x_PM_AOI22_X1%4_r11 N_4_M1_d x_PM_AOI22_X1%4_6 0.0678571
R_x_PM_AOI22_X1%4_r12 x_PM_AOI22_X1%4_16 x_PM_AOI22_X1%4_5 0.095
R_x_PM_AOI22_X1%4_r13 x_PM_AOI22_X1%4_6 x_PM_AOI22_X1%4_4 0.212317
R_x_PM_AOI22_X1%4_r14 x_PM_AOI22_X1%4_5 x_PM_AOI22_X1%4_4 1.65571
R_x_PM_AOI22_X1%4_r15 N_4_M3_d x_PM_AOI22_X1%4_12 0.637857
C_x_PM_AOI22_X1%B1_c0 VSS x_PM_AOI22_X1%B1_20 1.03216e-17
C_x_PM_AOI22_X1%B1_c1 VSS B1 4.30088e-17
C_x_PM_AOI22_X1%B1_c2 VSS x_PM_AOI22_X1%B1_10 7.73102e-17
C_x_PM_AOI22_X1%B1_c3 VSS N_B1_M1_g 6.09307e-17
C_x_PM_AOI22_X1%B1_c4 VSS N_B1_M5_g 5.29585e-17
R_x_PM_AOI22_X1%B1_r5 x_PM_AOI22_X1%B1_17 B1 0.28578
R_x_PM_AOI22_X1%B1_r6 x_PM_AOI22_X1%B1_20 x_PM_AOI22_X1%B1_12 3.38
R_x_PM_AOI22_X1%B1_r7 x_PM_AOI22_X1%B1_12 x_PM_AOI22_X1%B1_10 25.0012
R_x_PM_AOI22_X1%B1_r8 x_PM_AOI22_X1%B1_10 x_PM_AOI22_X1%B1_17 1.28929
R_x_PM_AOI22_X1%B1_r9 x_PM_AOI22_X1%B1_20 x_PM_AOI22_X1%B1_5 1.95
R_x_PM_AOI22_X1%B1_r10 N_B1_M1_g x_PM_AOI22_X1%B1_5 64.35
R_x_PM_AOI22_X1%B1_r11 x_PM_AOI22_X1%B1_20 x_PM_AOI22_X1%B1_VSS 1.95
R_x_PM_AOI22_X1%B1_r12 N_B1_M5_g x_PM_AOI22_X1%B1_VSS 67.08
C_x_PM_AOI22_X1%ZN_c0 VSS N_ZN_M2_d 5.64081e-17
C_x_PM_AOI22_X1%ZN_c1 VSS x_PM_AOI22_X1%ZN_10 1.32622e-17
C_x_PM_AOI22_X1%ZN_c2 VSS x_PM_AOI22_X1%ZN_9 1.77106e-17
C_x_PM_AOI22_X1%ZN_c3 VSS N_ZN_M5_d 1.52917e-16
R_x_PM_AOI22_X1%ZN_r4 N_ZN_M2_d x_PM_AOI22_X1%ZN_11 1.09929
R_x_PM_AOI22_X1%ZN_r5 x_PM_AOI22_X1%ZN_11 x_PM_AOI22_X1%ZN_9 0.212317
R_x_PM_AOI22_X1%ZN_r6 x_PM_AOI22_X1%ZN_10 x_PM_AOI22_X1%ZN_9 0.597143
R_x_PM_AOI22_X1%ZN_r7 ZN N_ZN_M5_d 2.99929
R_x_PM_AOI22_X1%ZN_r8 x_PM_AOI22_X1%ZN_10 x_PM_AOI22_X1%ZN_3 0.212317
R_x_PM_AOI22_X1%ZN_r9 ZN x_PM_AOI22_X1%ZN_3 0.0271429
C_x_PM_AOI22_X1%A1_c0 VSS A1 4.47449e-17
C_x_PM_AOI22_X1%A1_c1 VSS x_PM_AOI22_X1%A1_11 1.14504e-17
C_x_PM_AOI22_X1%A1_c2 VSS N_A1_M2_g 9.30065e-17
C_x_PM_AOI22_X1%A1_c3 VSS N_A1_M6_g 2.57078e-17
R_x_PM_AOI22_X1%A1_r4 x_PM_AOI22_X1%A1_11 x_PM_AOI22_X1%A1_16 4.42
R_x_PM_AOI22_X1%A1_r5 x_PM_AOI22_X1%A1_11 x_PM_AOI22_X1%A1_9 25.0012
R_x_PM_AOI22_X1%A1_r6 A1 x_PM_AOI22_X1%A1_9 0.156071
R_x_PM_AOI22_X1%A1_r7 x_PM_AOI22_X1%A1_16 x_PM_AOI22_X1%A1_5 1.95
R_x_PM_AOI22_X1%A1_r8 N_A1_M2_g x_PM_AOI22_X1%A1_5 112.71
R_x_PM_AOI22_X1%A1_r9 x_PM_AOI22_X1%A1_16 x_PM_AOI22_X1%A1_VSS 1.95
R_x_PM_AOI22_X1%A1_r10 N_A1_M6_g x_PM_AOI22_X1%A1_VSS 18.72
C_x_PM_AOI22_X1%A2_c0 VSS A2 1.63874e-17
C_x_PM_AOI22_X1%A2_c1 VSS x_PM_AOI22_X1%A2_11 6.57295e-18
C_x_PM_AOI22_X1%A2_c2 VSS N_A2_M3_g 6.11502e-17
C_x_PM_AOI22_X1%A2_c3 VSS N_A2_M7_g 5.02768e-17
R_x_PM_AOI22_X1%A2_r4 x_PM_AOI22_X1%A2_18 x_PM_AOI22_X1%A2_11 4.7687
R_x_PM_AOI22_X1%A2_r5 x_PM_AOI22_X1%A2_17 x_PM_AOI22_X1%A2_11 4.7687
R_x_PM_AOI22_X1%A2_r6 x_PM_AOI22_X1%A2_11 x_PM_AOI22_X1%A2_9 25.0012
R_x_PM_AOI22_X1%A2_r7 A2 x_PM_AOI22_X1%A2_9 0.2375
R_x_PM_AOI22_X1%A2_r8 N_A2_M3_g x_PM_AOI22_X1%A2_18 69.03
R_x_PM_AOI22_X1%A2_r9 N_A2_M7_g x_PM_AOI22_X1%A2_17 62.4
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X2 VSS VDD B2 B1 ZN A1 A2
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A1:I A2:I
M_M4 N_VDD_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_4_M1_d N_B1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_ZN_M2_d N_A1_M2_g N_4_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_4_M3_d N_A2_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 noxref_9 N_B2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M5_d N_B1_M5_g noxref_9 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 noxref_10 N_A1_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M7_d N_A2_M7_g noxref_10 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI22_X2%VSS_c0 VSS N_VSS_M7_d 1.85133e-17
C_x_PM_AOI22_X2%VSS_c1 VSS x_PM_AOI22_X2%VSS_8 1.16443e-17
C_x_PM_AOI22_X2%VSS_c2 VSS x_PM_AOI22_X2%VSS_7 8.17107e-17
C_x_PM_AOI22_X2%VSS_c3 VSS N_VSS_M4_s 1.77772e-17
R_x_PM_AOI22_X2%VSS_r4 N_VSS_M7_d x_PM_AOI22_X2%VSS_11 0.230714
R_x_PM_AOI22_X2%VSS_r5 VSS x_PM_AOI22_X2%VSS_8 0.782353
R_x_PM_AOI22_X2%VSS_r6 x_PM_AOI22_X2%VSS_11 x_PM_AOI22_X2%VSS_7 0.264221
R_x_PM_AOI22_X2%VSS_r7 VSS x_PM_AOI22_X2%VSS_7 0.748824
R_x_PM_AOI22_X2%VSS_r8 x_PM_AOI22_X2%VSS_8 x_PM_AOI22_X2%VSS_3 0.264221
R_x_PM_AOI22_X2%VSS_r9 N_VSS_M4_s x_PM_AOI22_X2%VSS_3 0.230714
C_x_PM_AOI22_X2%VDD_c0 VSS x_PM_AOI22_X2%VDD_12 3.42403e-17
C_x_PM_AOI22_X2%VDD_c1 VSS VDD 7.44755e-17
C_x_PM_AOI22_X2%VDD_c2 VSS N_VDD_M0_d 2.54185e-17
R_x_PM_AOI22_X2%VDD_r3 x_PM_AOI22_X2%VDD_12 x_PM_AOI22_X2%VDD_8 0.0731438
R_x_PM_AOI22_X2%VDD_r4 VDD x_PM_AOI22_X2%VDD_8 0.368824
R_x_PM_AOI22_X2%VDD_r5 x_PM_AOI22_X2%VDD_12 x_PM_AOI22_X2%VDD_4 0.145286
R_x_PM_AOI22_X2%VDD_r6 N_VDD_M0_d x_PM_AOI22_X2%VDD_4 0.230714
C_x_PM_AOI22_X2%B2_c0 VSS x_PM_AOI22_X2%B2_16 6.72544e-18
C_x_PM_AOI22_X2%B2_c1 VSS x_PM_AOI22_X2%B2_14 1.53181e-17
C_x_PM_AOI22_X2%B2_c2 VSS B2 3.00266e-17
C_x_PM_AOI22_X2%B2_c3 VSS N_B2_M0_g 7.54674e-17
C_x_PM_AOI22_X2%B2_c4 VSS N_B2_M4_g 4.59519e-17
R_x_PM_AOI22_X2%B2_r5 x_PM_AOI22_X2%B2_20 x_PM_AOI22_X2%B2_16 4.7687
R_x_PM_AOI22_X2%B2_r6 x_PM_AOI22_X2%B2_19 x_PM_AOI22_X2%B2_16 4.7687
R_x_PM_AOI22_X2%B2_r7 x_PM_AOI22_X2%B2_16 x_PM_AOI22_X2%B2_14 25.0012
R_x_PM_AOI22_X2%B2_r8 x_PM_AOI22_X2%B2_14 B2 0.218148
R_x_PM_AOI22_X2%B2_r9 N_B2_M0_g x_PM_AOI22_X2%B2_20 84.24
R_x_PM_AOI22_X2%B2_r10 N_B2_M4_g x_PM_AOI22_X2%B2_19 43.68
C_x_PM_AOI22_X2%4_c0 VSS x_PM_AOI22_X2%4_13 1.45949e-17
C_x_PM_AOI22_X2%4_c1 VSS x_PM_AOI22_X2%4_8 1.46933e-17
C_x_PM_AOI22_X2%4_c2 VSS x_PM_AOI22_X2%4_4 1.12002e-16
R_x_PM_AOI22_X2%4_r3 N_4_M0_s x_PM_AOI22_X2%4_8 0.176429
R_x_PM_AOI22_X2%4_r4 x_PM_AOI22_X2%4_8 x_PM_AOI22_X2%4_5 0.095
R_x_PM_AOI22_X2%4_r5 N_4_M1_d x_PM_AOI22_X2%4_5 1.83214
R_x_PM_AOI22_X2%4_r6 x_PM_AOI22_X2%4_13 x_PM_AOI22_X2%4_4 0.095
R_x_PM_AOI22_X2%4_r7 N_4_M1_d x_PM_AOI22_X2%4_4 1.85929
R_x_PM_AOI22_X2%4_r8 N_4_M3_d x_PM_AOI22_X2%4_13 0.176429
C_x_PM_AOI22_X2%B1_c0 VSS x_PM_AOI22_X2%B1_16 1.03288e-17
C_x_PM_AOI22_X2%B1_c1 VSS B1 6.66996e-17
C_x_PM_AOI22_X2%B1_c2 VSS N_B1_M1_g 9.09212e-17
C_x_PM_AOI22_X2%B1_c3 VSS N_B1_M5_g 3.70189e-17
R_x_PM_AOI22_X2%B1_r4 x_PM_AOI22_X2%B1_16 x_PM_AOI22_X2%B1_13 3.38
R_x_PM_AOI22_X2%B1_r5 x_PM_AOI22_X2%B1_13 x_PM_AOI22_X2%B1_11 25.0012
R_x_PM_AOI22_X2%B1_r6 x_PM_AOI22_X2%B1_11 B1 0.319098
R_x_PM_AOI22_X2%B1_r7 x_PM_AOI22_X2%B1_16 x_PM_AOI22_X2%B1_5 1.95
R_x_PM_AOI22_X2%B1_r8 N_B1_M1_g x_PM_AOI22_X2%B1_5 99.84
R_x_PM_AOI22_X2%B1_r9 x_PM_AOI22_X2%B1_16 x_PM_AOI22_X2%B1_VSS 1.95
R_x_PM_AOI22_X2%B1_r10 N_B1_M5_g x_PM_AOI22_X2%B1_VSS 28.08
C_x_PM_AOI22_X2%ZN_c0 VSS N_ZN_M2_d 5.1322e-17
C_x_PM_AOI22_X2%ZN_c1 VSS x_PM_AOI22_X2%ZN_9 2.4478e-17
C_x_PM_AOI22_X2%ZN_c2 VSS N_ZN_M5_d 1.3494e-16
R_x_PM_AOI22_X2%ZN_r3 N_ZN_M2_d x_PM_AOI22_X2%ZN_9 0.800714
R_x_PM_AOI22_X2%ZN_r4 ZN N_ZN_M5_d 2.48357
R_x_PM_AOI22_X2%ZN_r5 x_PM_AOI22_X2%ZN_9 x_PM_AOI22_X2%ZN_3 0.212317
R_x_PM_AOI22_X2%ZN_r6 ZN x_PM_AOI22_X2%ZN_3 0.814286
C_x_PM_AOI22_X2%A1_c0 VSS x_PM_AOI22_X2%A1_14 1.12932e-17
C_x_PM_AOI22_X2%A1_c1 VSS A1 9.47391e-17
C_x_PM_AOI22_X2%A1_c2 VSS N_A1_M2_g 9.43407e-17
C_x_PM_AOI22_X2%A1_c3 VSS N_A1_M6_g 3.70199e-17
R_x_PM_AOI22_X2%A1_r4 x_PM_AOI22_X2%A1_14 x_PM_AOI22_X2%A1_16 4.42
R_x_PM_AOI22_X2%A1_r5 x_PM_AOI22_X2%A1_14 x_PM_AOI22_X2%A1_12 25.0012
R_x_PM_AOI22_X2%A1_r6 x_PM_AOI22_X2%A1_12 A1 0.266
R_x_PM_AOI22_X2%A1_r7 x_PM_AOI22_X2%A1_16 x_PM_AOI22_X2%A1_5 1.95
R_x_PM_AOI22_X2%A1_r8 N_A1_M2_g x_PM_AOI22_X2%A1_5 99.84
R_x_PM_AOI22_X2%A1_r9 x_PM_AOI22_X2%A1_16 x_PM_AOI22_X2%A1_VSS 1.95
R_x_PM_AOI22_X2%A1_r10 N_A1_M6_g x_PM_AOI22_X2%A1_VSS 28.08
C_x_PM_AOI22_X2%A2_c0 VSS x_PM_AOI22_X2%A2_14 9.42774e-18
C_x_PM_AOI22_X2%A2_c1 VSS A2 6.37255e-17
C_x_PM_AOI22_X2%A2_c2 VSS N_A2_M3_g 8.38282e-17
C_x_PM_AOI22_X2%A2_c3 VSS N_A2_M7_g 3.62352e-17
R_x_PM_AOI22_X2%A2_r4 x_PM_AOI22_X2%A2_14 x_PM_AOI22_X2%A2_16 4.42
R_x_PM_AOI22_X2%A2_r5 x_PM_AOI22_X2%A2_14 x_PM_AOI22_X2%A2_12 25.0012
R_x_PM_AOI22_X2%A2_r6 x_PM_AOI22_X2%A2_12 A2 0.266
R_x_PM_AOI22_X2%A2_r7 x_PM_AOI22_X2%A2_16 x_PM_AOI22_X2%A2_5 1.95
R_x_PM_AOI22_X2%A2_r8 N_A2_M3_g x_PM_AOI22_X2%A2_5 99.84
R_x_PM_AOI22_X2%A2_r9 x_PM_AOI22_X2%A2_16 x_PM_AOI22_X2%A2_VSS 1.95
R_x_PM_AOI22_X2%A2_r10 N_A2_M7_g x_PM_AOI22_X2%A2_VSS 28.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   AOI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT AOI22_X4 VSS VDD B2 B1 ZN A1 A2
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A2:I A1:I
M_M8 N_VDD_M0_d N_B2_M0_g N_3_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_3_M1_d N_B1_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 N_VDD_M2_d N_B1_M2_g N_3_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_3_M3_d N_B2_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M12 N_ZN_M4_d N_A2_M4_g N_3_M3_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M13 N_3_M5_d N_A1_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M14 N_ZN_M6_d N_A1_M6_g N_3_M5_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M15 N_3_M7_d N_A2_M7_g N_ZN_M6_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 9 N_B2_M8_g N_VSS_M8_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M9_d N_B1_M9_g 9 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 10 N_B1_M10_g N_ZN_M9_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M11_d N_B2_M11_g 10 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 11 N_A2_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_ZN_M13_d N_A1_M13_g 11 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 12 N_A1_M14_g N_ZN_M13_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 N_VSS_M15_d N_A2_M15_g 12 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_AOI22_X4%VSS_c0 VSS x_PM_AOI22_X4%VSS_21 2.51333e-17
C_x_PM_AOI22_X4%VSS_c1 VSS x_PM_AOI22_X4%VSS_18 6.47941e-17
C_x_PM_AOI22_X4%VSS_c2 VSS N_VSS_M15_d 1.03697e-17
C_x_PM_AOI22_X4%VSS_c3 VSS x_PM_AOI22_X4%VSS_10 8.0484e-17
C_x_PM_AOI22_X4%VSS_c4 VSS x_PM_AOI22_X4%VSS_9 1.07808e-17
C_x_PM_AOI22_X4%VSS_c5 VSS N_VSS_M8_s 1.01877e-17
R_x_PM_AOI22_X4%VSS_r6 x_PM_AOI22_X4%VSS_21 VSS 0.105776
R_x_PM_AOI22_X4%VSS_r7 VSS N_VSS_M11_d 0.034898
R_x_PM_AOI22_X4%VSS_r8 x_PM_AOI22_X4%VSS_18 N_VSS_M11_d 0.140674
R_x_PM_AOI22_X4%VSS_r9 N_VSS_M15_d x_PM_AOI22_X4%VSS_12 0.230714
R_x_PM_AOI22_X4%VSS_r10 x_PM_AOI22_X4%VSS_12 x_PM_AOI22_X4%VSS_10 0.264221
R_x_PM_AOI22_X4%VSS_r11 x_PM_AOI22_X4%VSS_21 x_PM_AOI22_X4%VSS_10 1.55353
R_x_PM_AOI22_X4%VSS_r12 x_PM_AOI22_X4%VSS_9 x_PM_AOI22_X4%VSS_18 1.46412
R_x_PM_AOI22_X4%VSS_r13 x_PM_AOI22_X4%VSS_9 x_PM_AOI22_X4%VSS_4 0.264221
R_x_PM_AOI22_X4%VSS_r14 N_VSS_M8_s x_PM_AOI22_X4%VSS_4 0.230714
C_x_PM_AOI22_X4%VDD_c0 VSS x_PM_AOI22_X4%VDD_16 2.91289e-17
C_x_PM_AOI22_X4%VDD_c1 VSS N_VDD_M0_d 2.57884e-17
C_x_PM_AOI22_X4%VDD_c2 VSS x_PM_AOI22_X4%VDD_7 1.46721e-16
C_x_PM_AOI22_X4%VDD_c3 VSS x_PM_AOI22_X4%VDD_6 2.82636e-17
R_x_PM_AOI22_X4%VDD_r4 x_PM_AOI22_X4%VDD_16 N_VDD_M2_d 0.140674
R_x_PM_AOI22_X4%VDD_r5 x_PM_AOI22_X4%VDD_7 N_VDD_M2_d 0.140674
R_x_PM_AOI22_X4%VDD_r6 VDD x_PM_AOI22_X4%VDD_7 0.324118
R_x_PM_AOI22_X4%VDD_r7 x_PM_AOI22_X4%VDD_6 N_VDD_M0_d 0.140674
R_x_PM_AOI22_X4%VDD_r8 x_PM_AOI22_X4%VDD_6 x_PM_AOI22_X4%VDD_16 0.547647
C_x_PM_AOI22_X4%3_c0 VSS N_3_M0_s 1.50849e-17
C_x_PM_AOI22_X4%3_c1 VSS x_PM_AOI22_X4%3_6 2.36549e-16
C_x_PM_AOI22_X4%3_c2 VSS N_3_M7_d 1.50849e-17
R_x_PM_AOI22_X4%3_r3 x_PM_AOI22_X4%3_17 N_3_M0_s 0.176429
R_x_PM_AOI22_X4%3_r4 N_3_M5_d N_3_M3_d 2.28
R_x_PM_AOI22_X4%3_r5 N_3_M3_d N_3_M1_d 2.06286
R_x_PM_AOI22_X4%3_r6 x_PM_AOI22_X4%3_17 x_PM_AOI22_X4%3_7 0.095
R_x_PM_AOI22_X4%3_r7 N_3_M1_d x_PM_AOI22_X4%3_7 1.83214
R_x_PM_AOI22_X4%3_r8 x_PM_AOI22_X4%3_22 x_PM_AOI22_X4%3_6 0.095
R_x_PM_AOI22_X4%3_r9 N_3_M5_d x_PM_AOI22_X4%3_6 1.85929
R_x_PM_AOI22_X4%3_r10 x_PM_AOI22_X4%3_22 N_3_M7_d 0.176429
C_x_PM_AOI22_X4%B2_c0 VSS x_PM_AOI22_X4%B2_35 1.18654e-17
C_x_PM_AOI22_X4%B2_c1 VSS B2 4.48651e-17
C_x_PM_AOI22_X4%B2_c2 VSS x_PM_AOI22_X4%B2_20 6.34785e-18
C_x_PM_AOI22_X4%B2_c3 VSS x_PM_AOI22_X4%B2_17 5.78155e-17
C_x_PM_AOI22_X4%B2_c4 VSS N_B2_M3_g 5.46025e-17
C_x_PM_AOI22_X4%B2_c5 VSS N_B2_M11_g 7.29963e-17
C_x_PM_AOI22_X4%B2_c6 VSS N_B2_M0_g 5.28439e-17
C_x_PM_AOI22_X4%B2_c7 VSS N_B2_M8_g 6.74502e-17
R_x_PM_AOI22_X4%B2_r8 x_PM_AOI22_X4%B2_35 x_PM_AOI22_X4%B2_27 5.46
R_x_PM_AOI22_X4%B2_r9 x_PM_AOI22_X4%B2_27 x_PM_AOI22_X4%B2_25 25.0012
R_x_PM_AOI22_X4%B2_r10 x_PM_AOI22_X4%B2_28 x_PM_AOI22_X4%B2_25 0.0076
R_x_PM_AOI22_X4%B2_r11 x_PM_AOI22_X4%B2_25 B2 0.0988
R_x_PM_AOI22_X4%B2_r12 x_PM_AOI22_X4%B2_32 x_PM_AOI22_X4%B2_20 4.7687
R_x_PM_AOI22_X4%B2_r13 x_PM_AOI22_X4%B2_31 x_PM_AOI22_X4%B2_20 4.7687
R_x_PM_AOI22_X4%B2_r14 x_PM_AOI22_X4%B2_20 x_PM_AOI22_X4%B2_18 25.0012
R_x_PM_AOI22_X4%B2_r15 x_PM_AOI22_X4%B2_28 x_PM_AOI22_X4%B2_17 0.095
R_x_PM_AOI22_X4%B2_r16 x_PM_AOI22_X4%B2_18 x_PM_AOI22_X4%B2_17 2.565
R_x_PM_AOI22_X4%B2_r17 x_PM_AOI22_X4%B2_35 x_PM_AOI22_X4%B2_13 1.95
R_x_PM_AOI22_X4%B2_r18 N_B2_M3_g x_PM_AOI22_X4%B2_13 42.9
R_x_PM_AOI22_X4%B2_r19 x_PM_AOI22_X4%B2_35 x_PM_AOI22_X4%B2_9 1.95
R_x_PM_AOI22_X4%B2_r20 N_B2_M11_g x_PM_AOI22_X4%B2_9 85.02
R_x_PM_AOI22_X4%B2_r21 N_B2_M0_g x_PM_AOI22_X4%B2_32 42.9
R_x_PM_AOI22_X4%B2_r22 N_B2_M8_g x_PM_AOI22_X4%B2_31 85.02
C_x_PM_AOI22_X4%B1_c0 VSS x_PM_AOI22_X4%B1_25 3.51727e-18
C_x_PM_AOI22_X4%B1_c1 VSS x_PM_AOI22_X4%B1_23 2.93999e-17
C_x_PM_AOI22_X4%B1_c2 VSS x_PM_AOI22_X4%B1_19 4.41706e-18
C_x_PM_AOI22_X4%B1_c3 VSS N_B1_M2_g 5.85039e-17
C_x_PM_AOI22_X4%B1_c4 VSS N_B1_M10_g 4.40294e-17
C_x_PM_AOI22_X4%B1_c5 VSS x_PM_AOI22_X4%B1_9 7.47863e-18
C_x_PM_AOI22_X4%B1_c6 VSS N_B1_M1_g 5.77036e-17
C_x_PM_AOI22_X4%B1_c7 VSS N_B1_M9_g 3.97252e-17
R_x_PM_AOI22_X4%B1_r8 x_PM_AOI22_X4%B1_25 x_PM_AOI22_X4%B1_23 25.0012
R_x_PM_AOI22_X4%B1_r9 x_PM_AOI22_X4%B1_23 B1 0.475
R_x_PM_AOI22_X4%B1_r10 x_PM_AOI22_X4%B1_19 x_PM_AOI22_X4%B1_15 4.56151
R_x_PM_AOI22_X4%B1_r11 N_B1_M2_g x_PM_AOI22_X4%B1_15 70.2
R_x_PM_AOI22_X4%B1_r12 x_PM_AOI22_X4%B1_19 x_PM_AOI22_X4%B1_11 4.56151
R_x_PM_AOI22_X4%B1_r13 N_B1_M10_g x_PM_AOI22_X4%B1_11 57.72
R_x_PM_AOI22_X4%B1_r14 x_PM_AOI22_X4%B1_25 x_PM_AOI22_X4%B1_10 0.043368
R_x_PM_AOI22_X4%B1_r15 x_PM_AOI22_X4%B1_19 x_PM_AOI22_X4%B1_9 0.043368
R_x_PM_AOI22_X4%B1_r16 x_PM_AOI22_X4%B1_10 x_PM_AOI22_X4%B1_9 14.56
R_x_PM_AOI22_X4%B1_r17 x_PM_AOI22_X4%B1_25 x_PM_AOI22_X4%B1_5 4.56151
R_x_PM_AOI22_X4%B1_r18 N_B1_M1_g x_PM_AOI22_X4%B1_5 70.2
R_x_PM_AOI22_X4%B1_r19 x_PM_AOI22_X4%B1_25 x_PM_AOI22_X4%B1_VSS 4.56151
R_x_PM_AOI22_X4%B1_r20 N_B1_M9_g x_PM_AOI22_X4%B1_VSS 57.72
C_x_PM_AOI22_X4%ZN_c0 VSS x_PM_AOI22_X4%ZN_23 8.71943e-18
C_x_PM_AOI22_X4%ZN_c1 VSS N_ZN_M6_d 1.67605e-16
C_x_PM_AOI22_X4%ZN_c2 VSS x_PM_AOI22_X4%ZN_17 2.04001e-17
C_x_PM_AOI22_X4%ZN_c3 VSS N_ZN_M13_d 4.83278e-17
C_x_PM_AOI22_X4%ZN_c4 VSS ZN 8.03504e-17
C_x_PM_AOI22_X4%ZN_c5 VSS x_PM_AOI22_X4%ZN_5 4.95482e-17
R_x_PM_AOI22_X4%ZN_r6 N_ZN_M6_d N_ZN_M4_d 2.06286
R_x_PM_AOI22_X4%ZN_r7 N_ZN_M4_d x_PM_AOI22_X4%ZN_17 0.936429
R_x_PM_AOI22_X4%ZN_r8 x_PM_AOI22_X4%ZN_23 x_PM_AOI22_X4%ZN_13 0.160909
R_x_PM_AOI22_X4%ZN_r9 N_ZN_M13_d x_PM_AOI22_X4%ZN_13 1.96786
R_x_PM_AOI22_X4%ZN_r10 x_PM_AOI22_X4%ZN_17 x_PM_AOI22_X4%ZN_10 0.212317
R_x_PM_AOI22_X4%ZN_r11 ZN x_PM_AOI22_X4%ZN_10 1.57429
R_x_PM_AOI22_X4%ZN_r12 x_PM_AOI22_X4%ZN_23 x_PM_AOI22_X4%ZN_9 0.0418175
R_x_PM_AOI22_X4%ZN_r13 ZN x_PM_AOI22_X4%ZN_9 1.52
R_x_PM_AOI22_X4%ZN_r14 x_PM_AOI22_X4%ZN_23 x_PM_AOI22_X4%ZN_5 0.160909
R_x_PM_AOI22_X4%ZN_r15 N_ZN_M9_d x_PM_AOI22_X4%ZN_5 1.96786
C_x_PM_AOI22_X4%A2_c0 VSS x_PM_AOI22_X4%A2_29 1.08668e-16
C_x_PM_AOI22_X4%A2_c1 VSS x_PM_AOI22_X4%A2_25 6.59548e-18
C_x_PM_AOI22_X4%A2_c2 VSS x_PM_AOI22_X4%A2_23 1.8682e-17
C_x_PM_AOI22_X4%A2_c3 VSS x_PM_AOI22_X4%A2_22 2.17935e-17
C_x_PM_AOI22_X4%A2_c4 VSS x_PM_AOI22_X4%A2_20 1.36854e-17
C_x_PM_AOI22_X4%A2_c5 VSS N_A2_M7_g 5.72438e-17
C_x_PM_AOI22_X4%A2_c6 VSS N_A2_M15_g 6.17584e-17
C_x_PM_AOI22_X4%A2_c7 VSS N_A2_M4_g 5.79028e-17
C_x_PM_AOI22_X4%A2_c8 VSS N_A2_M12_g 7.32284e-17
R_x_PM_AOI22_X4%A2_r9 x_PM_AOI22_X4%A2_29 A2 0.176411
R_x_PM_AOI22_X4%A2_r10 x_PM_AOI22_X4%A2_36 x_PM_AOI22_X4%A2_25 4.7687
R_x_PM_AOI22_X4%A2_r11 x_PM_AOI22_X4%A2_35 x_PM_AOI22_X4%A2_25 4.7687
R_x_PM_AOI22_X4%A2_r12 x_PM_AOI22_X4%A2_25 x_PM_AOI22_X4%A2_23 25.0012
R_x_PM_AOI22_X4%A2_r13 A2 x_PM_AOI22_X4%A2_22 0.095
R_x_PM_AOI22_X4%A2_r14 x_PM_AOI22_X4%A2_23 x_PM_AOI22_X4%A2_22 0.251071
R_x_PM_AOI22_X4%A2_r15 x_PM_AOI22_X4%A2_20 x_PM_AOI22_X4%A2_30 5.46
R_x_PM_AOI22_X4%A2_r16 x_PM_AOI22_X4%A2_20 x_PM_AOI22_X4%A2_18 25.0012
R_x_PM_AOI22_X4%A2_r17 x_PM_AOI22_X4%A2_18 x_PM_AOI22_X4%A2_29 1.862
R_x_PM_AOI22_X4%A2_r18 N_A2_M7_g x_PM_AOI22_X4%A2_36 53.82
R_x_PM_AOI22_X4%A2_r19 N_A2_M15_g x_PM_AOI22_X4%A2_35 74.1
R_x_PM_AOI22_X4%A2_r20 x_PM_AOI22_X4%A2_30 x_PM_AOI22_X4%A2_5 1.95
R_x_PM_AOI22_X4%A2_r21 N_A2_M4_g x_PM_AOI22_X4%A2_5 43.68
R_x_PM_AOI22_X4%A2_r22 x_PM_AOI22_X4%A2_30 x_PM_AOI22_X4%A2_VSS 1.95
R_x_PM_AOI22_X4%A2_r23 N_A2_M12_g x_PM_AOI22_X4%A2_VSS 84.24
C_x_PM_AOI22_X4%A1_c0 VSS x_PM_AOI22_X4%A1_25 2.15598e-17
C_x_PM_AOI22_X4%A1_c1 VSS x_PM_AOI22_X4%A1_23 6.06726e-18
C_x_PM_AOI22_X4%A1_c2 VSS x_PM_AOI22_X4%A1_21 1.88743e-17
C_x_PM_AOI22_X4%A1_c3 VSS x_PM_AOI22_X4%A1_19 4.43365e-18
C_x_PM_AOI22_X4%A1_c4 VSS N_A1_M6_g 6.39871e-17
C_x_PM_AOI22_X4%A1_c5 VSS N_A1_M14_g 3.74767e-17
C_x_PM_AOI22_X4%A1_c6 VSS x_PM_AOI22_X4%A1_9 6.38321e-18
C_x_PM_AOI22_X4%A1_c7 VSS N_A1_M5_g 6.47406e-17
C_x_PM_AOI22_X4%A1_c8 VSS N_A1_M13_g 4.17243e-17
R_x_PM_AOI22_X4%A1_r9 A1 x_PM_AOI22_X4%A1_25 0.19
R_x_PM_AOI22_X4%A1_r10 x_PM_AOI22_X4%A1_23 x_PM_AOI22_X4%A1_21 25.0012
R_x_PM_AOI22_X4%A1_r11 x_PM_AOI22_X4%A1_25 x_PM_AOI22_X4%A1_20 0.095
R_x_PM_AOI22_X4%A1_r12 x_PM_AOI22_X4%A1_21 x_PM_AOI22_X4%A1_20 0.502143
R_x_PM_AOI22_X4%A1_r13 x_PM_AOI22_X4%A1_23 x_PM_AOI22_X4%A1_15 4.56151
R_x_PM_AOI22_X4%A1_r14 N_A1_M6_g x_PM_AOI22_X4%A1_15 75.66
R_x_PM_AOI22_X4%A1_r15 x_PM_AOI22_X4%A1_23 x_PM_AOI22_X4%A1_11 4.56151
R_x_PM_AOI22_X4%A1_r16 N_A1_M14_g x_PM_AOI22_X4%A1_11 52.26
R_x_PM_AOI22_X4%A1_r17 x_PM_AOI22_X4%A1_19 x_PM_AOI22_X4%A1_10 0.043368
R_x_PM_AOI22_X4%A1_r18 x_PM_AOI22_X4%A1_23 x_PM_AOI22_X4%A1_9 0.043368
R_x_PM_AOI22_X4%A1_r19 x_PM_AOI22_X4%A1_10 x_PM_AOI22_X4%A1_9 14.56
R_x_PM_AOI22_X4%A1_r20 x_PM_AOI22_X4%A1_19 x_PM_AOI22_X4%A1_5 4.56151
R_x_PM_AOI22_X4%A1_r21 N_A1_M5_g x_PM_AOI22_X4%A1_5 75.66
R_x_PM_AOI22_X4%A1_r22 x_PM_AOI22_X4%A1_19 x_PM_AOI22_X4%A1_VSS 4.56151
R_x_PM_AOI22_X4%A1_r23 N_A1_M13_g x_PM_AOI22_X4%A1_VSS 52.26
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X1 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_BUF_X1%VSS_c0 VSS VSS 7.70537e-17
C_x_PM_BUF_X1%VSS_c1 VSS N_VSS_M2_d 6.11e-17
R_x_PM_BUF_X1%VSS_r2 VSS x_PM_BUF_X1%VSS_4 0.0680382
R_x_PM_BUF_X1%VSS_r3 N_VSS_M2_d x_PM_BUF_X1%VSS_4 0.330741
C_x_PM_BUF_X1%VDD_c0 VSS VDD 7.40906e-17
C_x_PM_BUF_X1%VDD_c1 VSS N_VDD_M0_d 5.49632e-17
R_x_PM_BUF_X1%VDD_r2 VDD N_VDD_M0_d 0.295556
C_x_PM_BUF_X1%3_c0 VSS x_PM_BUF_X1%3_29 1.22462e-17
C_x_PM_BUF_X1%3_c1 VSS x_PM_BUF_X1%3_24 1.80436e-16
C_x_PM_BUF_X1%3_c2 VSS x_PM_BUF_X1%3_23 3.01727e-17
C_x_PM_BUF_X1%3_c3 VSS x_PM_BUF_X1%3_22 4.25454e-18
C_x_PM_BUF_X1%3_c4 VSS x_PM_BUF_X1%3_21 5.84638e-17
C_x_PM_BUF_X1%3_c5 VSS x_PM_BUF_X1%3_20 5.62677e-18
C_x_PM_BUF_X1%3_c6 VSS x_PM_BUF_X1%3_19 2.86344e-17
C_x_PM_BUF_X1%3_c7 VSS N_3_M0_s 2.52906e-17
C_x_PM_BUF_X1%3_c8 VSS N_3_M2_s 3.29867e-17
C_x_PM_BUF_X1%3_c9 VSS N_3_M1_g 9.91336e-17
C_x_PM_BUF_X1%3_c10 VSS N_3_M3_g 2.72422e-17
R_x_PM_BUF_X1%3_r11 x_PM_BUF_X1%3_29 x_PM_BUF_X1%3_27 3.9
R_x_PM_BUF_X1%3_r12 x_PM_BUF_X1%3_27 x_PM_BUF_X1%3_25 25.0012
R_x_PM_BUF_X1%3_r13 x_PM_BUF_X1%3_25 x_PM_BUF_X1%3_23 0.0141545
R_x_PM_BUF_X1%3_r14 x_PM_BUF_X1%3_24 x_PM_BUF_X1%3_23 3.82714
R_x_PM_BUF_X1%3_r15 x_PM_BUF_X1%3_24 x_PM_BUF_X1%3_21 0.212317
R_x_PM_BUF_X1%3_r16 x_PM_BUF_X1%3_22 x_PM_BUF_X1%3_21 0.922857
R_x_PM_BUF_X1%3_r17 x_PM_BUF_X1%3_25 x_PM_BUF_X1%3_19 0.198162
R_x_PM_BUF_X1%3_r18 x_PM_BUF_X1%3_20 x_PM_BUF_X1%3_19 0.922857
R_x_PM_BUF_X1%3_r19 x_PM_BUF_X1%3_22 x_PM_BUF_X1%3_15 0.212317
R_x_PM_BUF_X1%3_r20 N_3_M0_s x_PM_BUF_X1%3_15 0.203571
R_x_PM_BUF_X1%3_r21 x_PM_BUF_X1%3_20 x_PM_BUF_X1%3_11 0.212317
R_x_PM_BUF_X1%3_r22 N_3_M2_s x_PM_BUF_X1%3_11 0.447857
R_x_PM_BUF_X1%3_r23 x_PM_BUF_X1%3_29 x_PM_BUF_X1%3_5 1.95
R_x_PM_BUF_X1%3_r24 N_3_M1_g x_PM_BUF_X1%3_5 125.97
R_x_PM_BUF_X1%3_r25 x_PM_BUF_X1%3_29 x_PM_BUF_X1%3_VSS 1.95
R_x_PM_BUF_X1%3_r26 N_3_M3_g x_PM_BUF_X1%3_VSS 18.72
C_x_PM_BUF_X1%A_c0 VSS x_PM_BUF_X1%A_14 7.18477e-18
C_x_PM_BUF_X1%A_c1 VSS x_PM_BUF_X1%A_12 4.322e-17
C_x_PM_BUF_X1%A_c2 VSS N_A_M0_g 6.66406e-17
C_x_PM_BUF_X1%A_c3 VSS N_A_M2_g 4.93286e-17
R_x_PM_BUF_X1%A_r4 x_PM_BUF_X1%A_18 x_PM_BUF_X1%A_14 4.74714
R_x_PM_BUF_X1%A_r5 x_PM_BUF_X1%A_17 x_PM_BUF_X1%A_14 4.74714
R_x_PM_BUF_X1%A_r6 x_PM_BUF_X1%A_14 x_PM_BUF_X1%A_12 25.0012
R_x_PM_BUF_X1%A_r7 x_PM_BUF_X1%A_12 A 0.156071
R_x_PM_BUF_X1%A_r8 N_A_M0_g x_PM_BUF_X1%A_18 90.87
R_x_PM_BUF_X1%A_r9 N_A_M2_g x_PM_BUF_X1%A_17 53.82
C_x_PM_BUF_X1%Z_c0 VSS N_Z_M3_d 2.5795e-16
R_x_PM_BUF_X1%Z_r1 N_Z_M1_d Z 2.33278
R_x_PM_BUF_X1%Z_r2 Z N_Z_M3_d 1.74167
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X16 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M5 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M7 N_VDD_M2_d N_3_M2_g N_Z_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M8 N_Z_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M9 N_VDD_M4_d N_3_M4_g N_Z_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_VSS_M5_d N_A_M5_g N_3_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M6_d N_3_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M2 N_VSS_M7_d N_3_M7_g N_Z_M6_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M3 N_Z_M8_d N_3_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M4 N_VSS_M9_d N_3_M9_g N_Z_M8_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_BUF_X16%VSS_c0 VSS x_PM_BUF_X16%VSS_25 2.70113e-18
C_x_PM_BUF_X16%VSS_c1 VSS x_PM_BUF_X16%VSS_24 3.97457e-17
C_x_PM_BUF_X16%VSS_c2 VSS N_VSS_M9_d 2.33807e-17
C_x_PM_BUF_X16%VSS_c3 VSS x_PM_BUF_X16%VSS_18 4.02684e-17
C_x_PM_BUF_X16%VSS_c4 VSS VSS 3.33754e-17
C_x_PM_BUF_X16%VSS_c5 VSS x_PM_BUF_X16%VSS_10 2.67621e-17
C_x_PM_BUF_X16%VSS_c6 VSS N_VSS_M5_d 3.82509e-17
R_x_PM_BUF_X16%VSS_r7 N_VSS_M9_d x_PM_BUF_X16%VSS_20 0.990714
R_x_PM_BUF_X16%VSS_r8 x_PM_BUF_X16%VSS_25 x_PM_BUF_X16%VSS_19 0.0731438
R_x_PM_BUF_X16%VSS_r9 x_PM_BUF_X16%VSS_20 x_PM_BUF_X16%VSS_18 0.264221
R_x_PM_BUF_X16%VSS_r10 x_PM_BUF_X16%VSS_19 x_PM_BUF_X16%VSS_18 0.692941
R_x_PM_BUF_X16%VSS_r11 N_VSS_M7_d VSS 0.746429
R_x_PM_BUF_X16%VSS_r12 x_PM_BUF_X16%VSS_25 x_PM_BUF_X16%VSS_12 0.145286
R_x_PM_BUF_X16%VSS_r13 VSS x_PM_BUF_X16%VSS_12 0.244286
R_x_PM_BUF_X16%VSS_r14 x_PM_BUF_X16%VSS_24 x_PM_BUF_X16%VSS_11 0.0731438
R_x_PM_BUF_X16%VSS_r15 x_PM_BUF_X16%VSS_25 x_PM_BUF_X16%VSS_10 0.0731438
R_x_PM_BUF_X16%VSS_r16 x_PM_BUF_X16%VSS_11 x_PM_BUF_X16%VSS_10 0.670588
R_x_PM_BUF_X16%VSS_r17 x_PM_BUF_X16%VSS_24 x_PM_BUF_X16%VSS_6 0.145286
R_x_PM_BUF_X16%VSS_r18 N_VSS_M5_d x_PM_BUF_X16%VSS_6 0.637857
C_x_PM_BUF_X16%VDD_c0 VSS x_PM_BUF_X16%VDD_25 2.87298e-18
C_x_PM_BUF_X16%VDD_c1 VSS x_PM_BUF_X16%VDD_24 2.82055e-18
C_x_PM_BUF_X16%VDD_c2 VSS N_VDD_M4_d 1.73054e-17
C_x_PM_BUF_X16%VDD_c3 VSS x_PM_BUF_X16%VDD_18 3.45164e-17
C_x_PM_BUF_X16%VDD_c4 VSS N_VDD_M2_d 1.9971e-17
C_x_PM_BUF_X16%VDD_c5 VSS x_PM_BUF_X16%VDD_12 2.14911e-17
C_x_PM_BUF_X16%VDD_c6 VSS N_VDD_M0_d 3.05908e-17
C_x_PM_BUF_X16%VDD_c7 VSS x_PM_BUF_X16%VDD_4 3.80993e-17
R_x_PM_BUF_X16%VDD_r8 N_VDD_M4_d x_PM_BUF_X16%VDD_20 0.393571
R_x_PM_BUF_X16%VDD_r9 x_PM_BUF_X16%VDD_25 x_PM_BUF_X16%VDD_19 0.0731438
R_x_PM_BUF_X16%VDD_r10 x_PM_BUF_X16%VDD_20 x_PM_BUF_X16%VDD_18 0.264221
R_x_PM_BUF_X16%VDD_r11 x_PM_BUF_X16%VDD_19 x_PM_BUF_X16%VDD_18 0.692941
R_x_PM_BUF_X16%VDD_r12 x_PM_BUF_X16%VDD_25 x_PM_BUF_X16%VDD_14 0.145286
R_x_PM_BUF_X16%VDD_r13 N_VDD_M2_d x_PM_BUF_X16%VDD_14 0.393571
R_x_PM_BUF_X16%VDD_r14 x_PM_BUF_X16%VDD_24 x_PM_BUF_X16%VDD_13 0.0731438
R_x_PM_BUF_X16%VDD_r15 x_PM_BUF_X16%VDD_25 x_PM_BUF_X16%VDD_12 0.0731438
R_x_PM_BUF_X16%VDD_r16 x_PM_BUF_X16%VDD_13 x_PM_BUF_X16%VDD_12 0.692941
R_x_PM_BUF_X16%VDD_r17 x_PM_BUF_X16%VDD_24 x_PM_BUF_X16%VDD_8 0.145286
R_x_PM_BUF_X16%VDD_r18 N_VDD_M0_d x_PM_BUF_X16%VDD_8 0.393571
R_x_PM_BUF_X16%VDD_r19 x_PM_BUF_X16%VDD_24 x_PM_BUF_X16%VDD_4 0.0731438
R_x_PM_BUF_X16%VDD_r20 VDD x_PM_BUF_X16%VDD_4 0.268235
C_x_PM_BUF_X16%3_c0 VSS x_PM_BUF_X16%3_59 1.35049e-16
C_x_PM_BUF_X16%3_c1 VSS x_PM_BUF_X16%3_55 4.69206e-18
C_x_PM_BUF_X16%3_c2 VSS x_PM_BUF_X16%3_54 2.89924e-17
C_x_PM_BUF_X16%3_c3 VSS x_PM_BUF_X16%3_53 7.34789e-18
C_x_PM_BUF_X16%3_c4 VSS x_PM_BUF_X16%3_52 4.53985e-17
C_x_PM_BUF_X16%3_c5 VSS N_3_M0_s 2.8613e-17
C_x_PM_BUF_X16%3_c6 VSS N_3_M5_s 3.38281e-17
C_x_PM_BUF_X16%3_c7 VSS x_PM_BUF_X16%3_41 3.30952e-18
C_x_PM_BUF_X16%3_c8 VSS x_PM_BUF_X16%3_40 1.49221e-18
C_x_PM_BUF_X16%3_c9 VSS x_PM_BUF_X16%3_39 1.49221e-18
C_x_PM_BUF_X16%3_c10 VSS N_3_M4_g 5.41722e-17
C_x_PM_BUF_X16%3_c11 VSS N_3_M9_g 3.77106e-17
C_x_PM_BUF_X16%3_c12 VSS x_PM_BUF_X16%3_29 1.21928e-17
C_x_PM_BUF_X16%3_c13 VSS N_3_M3_g 3.65562e-17
C_x_PM_BUF_X16%3_c14 VSS N_3_M8_g 2.31229e-17
C_x_PM_BUF_X16%3_c15 VSS x_PM_BUF_X16%3_19 1.23428e-17
C_x_PM_BUF_X16%3_c16 VSS N_3_M2_g 3.5976e-17
C_x_PM_BUF_X16%3_c17 VSS N_3_M7_g 2.28163e-17
C_x_PM_BUF_X16%3_c18 VSS x_PM_BUF_X16%3_10 6.58676e-18
C_x_PM_BUF_X16%3_c19 VSS x_PM_BUF_X16%3_9 1.15641e-17
C_x_PM_BUF_X16%3_c20 VSS N_3_M1_g 4.88274e-17
C_x_PM_BUF_X16%3_c21 VSS N_3_M6_g 3.32945e-17
R_x_PM_BUF_X16%3_r22 x_PM_BUF_X16%3_63 x_PM_BUF_X16%3_61 3.38
R_x_PM_BUF_X16%3_r23 x_PM_BUF_X16%3_61 x_PM_BUF_X16%3_59 25.0012
R_x_PM_BUF_X16%3_r24 x_PM_BUF_X16%3_59 x_PM_BUF_X16%3_57 2.72786
R_x_PM_BUF_X16%3_r25 x_PM_BUF_X16%3_59 x_PM_BUF_X16%3_56 0.719286
R_x_PM_BUF_X16%3_r26 x_PM_BUF_X16%3_57 x_PM_BUF_X16%3_54 0.212317
R_x_PM_BUF_X16%3_r27 x_PM_BUF_X16%3_55 x_PM_BUF_X16%3_54 0.95
R_x_PM_BUF_X16%3_r28 x_PM_BUF_X16%3_56 x_PM_BUF_X16%3_52 0.212317
R_x_PM_BUF_X16%3_r29 x_PM_BUF_X16%3_53 x_PM_BUF_X16%3_52 0.95
R_x_PM_BUF_X16%3_r30 x_PM_BUF_X16%3_55 x_PM_BUF_X16%3_48 0.212317
R_x_PM_BUF_X16%3_r31 N_3_M0_s x_PM_BUF_X16%3_48 0.393571
R_x_PM_BUF_X16%3_r32 x_PM_BUF_X16%3_53 x_PM_BUF_X16%3_44 0.212317
R_x_PM_BUF_X16%3_r33 N_3_M5_s x_PM_BUF_X16%3_44 0.637857
R_x_PM_BUF_X16%3_r34 x_PM_BUF_X16%3_41 x_PM_BUF_X16%3_35 4.56151
R_x_PM_BUF_X16%3_r35 N_3_M4_g x_PM_BUF_X16%3_35 67.86
R_x_PM_BUF_X16%3_r36 x_PM_BUF_X16%3_41 x_PM_BUF_X16%3_31 4.56151
R_x_PM_BUF_X16%3_r37 N_3_M9_g x_PM_BUF_X16%3_31 35.88
R_x_PM_BUF_X16%3_r38 x_PM_BUF_X16%3_40 x_PM_BUF_X16%3_30 1.95
R_x_PM_BUF_X16%3_r39 x_PM_BUF_X16%3_41 x_PM_BUF_X16%3_29 0.043368
R_x_PM_BUF_X16%3_r40 x_PM_BUF_X16%3_30 x_PM_BUF_X16%3_29 14.56
R_x_PM_BUF_X16%3_r41 x_PM_BUF_X16%3_40 x_PM_BUF_X16%3_25 1.95
R_x_PM_BUF_X16%3_r42 N_3_M3_g x_PM_BUF_X16%3_25 67.86
R_x_PM_BUF_X16%3_r43 x_PM_BUF_X16%3_40 x_PM_BUF_X16%3_21 1.95
R_x_PM_BUF_X16%3_r44 N_3_M8_g x_PM_BUF_X16%3_21 35.88
R_x_PM_BUF_X16%3_r45 x_PM_BUF_X16%3_39 x_PM_BUF_X16%3_20 1.95
R_x_PM_BUF_X16%3_r46 x_PM_BUF_X16%3_40 x_PM_BUF_X16%3_19 1.95
R_x_PM_BUF_X16%3_r47 x_PM_BUF_X16%3_20 x_PM_BUF_X16%3_19 14.56
R_x_PM_BUF_X16%3_r48 x_PM_BUF_X16%3_39 x_PM_BUF_X16%3_15 1.95
R_x_PM_BUF_X16%3_r49 N_3_M2_g x_PM_BUF_X16%3_15 67.86
R_x_PM_BUF_X16%3_r50 x_PM_BUF_X16%3_39 x_PM_BUF_X16%3_11 1.95
R_x_PM_BUF_X16%3_r51 N_3_M7_g x_PM_BUF_X16%3_11 35.88
R_x_PM_BUF_X16%3_r52 x_PM_BUF_X16%3_63 x_PM_BUF_X16%3_10 2.6
R_x_PM_BUF_X16%3_r53 x_PM_BUF_X16%3_39 x_PM_BUF_X16%3_9 1.95
R_x_PM_BUF_X16%3_r54 x_PM_BUF_X16%3_10 x_PM_BUF_X16%3_9 14.56
R_x_PM_BUF_X16%3_r55 x_PM_BUF_X16%3_63 x_PM_BUF_X16%3_5 1.95
R_x_PM_BUF_X16%3_r56 N_3_M1_g x_PM_BUF_X16%3_5 67.86
R_x_PM_BUF_X16%3_r57 x_PM_BUF_X16%3_63 x_PM_BUF_X16%3_VSS 1.95
R_x_PM_BUF_X16%3_r58 N_3_M6_g x_PM_BUF_X16%3_VSS 35.88
C_x_PM_BUF_X16%A_c0 VSS x_PM_BUF_X16%A_14 6.7341e-18
C_x_PM_BUF_X16%A_c1 VSS x_PM_BUF_X16%A_12 3.0235e-17
C_x_PM_BUF_X16%A_c2 VSS N_A_M0_g 6.6618e-17
C_x_PM_BUF_X16%A_c3 VSS N_A_M5_g 5.35862e-17
R_x_PM_BUF_X16%A_r4 x_PM_BUF_X16%A_18 x_PM_BUF_X16%A_14 4.7687
R_x_PM_BUF_X16%A_r5 x_PM_BUF_X16%A_17 x_PM_BUF_X16%A_14 4.7687
R_x_PM_BUF_X16%A_r6 x_PM_BUF_X16%A_14 x_PM_BUF_X16%A_12 25.0012
R_x_PM_BUF_X16%A_r7 x_PM_BUF_X16%A_12 A 0.210357
R_x_PM_BUF_X16%A_r8 N_A_M0_g x_PM_BUF_X16%A_18 85.41
R_x_PM_BUF_X16%A_r9 N_A_M5_g x_PM_BUF_X16%A_17 59.28
C_x_PM_BUF_X16%Z_c0 VSS x_PM_BUF_X16%Z_26 9.34233e-18
C_x_PM_BUF_X16%Z_c1 VSS x_PM_BUF_X16%Z_25 3.1474e-17
C_x_PM_BUF_X16%Z_c2 VSS N_Z_M3_d 3.07954e-17
C_x_PM_BUF_X16%Z_c3 VSS N_Z_M8_d 5.0206e-17
C_x_PM_BUF_X16%Z_c4 VSS x_PM_BUF_X16%Z_13 2.23412e-17
C_x_PM_BUF_X16%Z_c5 VSS N_Z_M1_d 6.46259e-17
C_x_PM_BUF_X16%Z_c6 VSS N_Z_M6_d 7.40393e-17
R_x_PM_BUF_X16%Z_r7 x_PM_BUF_X16%Z_26 x_PM_BUF_X16%Z_21 0.230141
R_x_PM_BUF_X16%Z_r8 N_Z_M3_d x_PM_BUF_X16%Z_21 1.37071
R_x_PM_BUF_X16%Z_r9 x_PM_BUF_X16%Z_26 x_PM_BUF_X16%Z_17 0.230141
R_x_PM_BUF_X16%Z_r10 N_Z_M8_d x_PM_BUF_X16%Z_17 0.773571
R_x_PM_BUF_X16%Z_r11 x_PM_BUF_X16%Z_25 x_PM_BUF_X16%Z_14 0.00691171
R_x_PM_BUF_X16%Z_r12 Z x_PM_BUF_X16%Z_14 0.535455
R_x_PM_BUF_X16%Z_r13 x_PM_BUF_X16%Z_26 x_PM_BUF_X16%Z_13 0.00691171
R_x_PM_BUF_X16%Z_r14 Z x_PM_BUF_X16%Z_13 0.500909
R_x_PM_BUF_X16%Z_r15 x_PM_BUF_X16%Z_25 x_PM_BUF_X16%Z_9 0.230141
R_x_PM_BUF_X16%Z_r16 N_Z_M1_d x_PM_BUF_X16%Z_9 1.37071
R_x_PM_BUF_X16%Z_r17 x_PM_BUF_X16%Z_25 x_PM_BUF_X16%Z_5 0.230141
R_x_PM_BUF_X16%Z_r18 N_Z_M6_d x_PM_BUF_X16%Z_5 0.773571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X2 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_BUF_X2%VSS_c0 VSS VSS 1.0786e-16
R_x_PM_BUF_X2%VSS_r1 N_VSS_M2_d VSS 0.637857
C_x_PM_BUF_X2%VDD_c0 VSS VDD 8.03115e-17
C_x_PM_BUF_X2%VDD_c1 VSS N_VDD_M0_d 3.78724e-17
R_x_PM_BUF_X2%VDD_r2 VDD x_PM_BUF_X2%VDD_4 0.145286
R_x_PM_BUF_X2%VDD_r3 N_VDD_M0_d x_PM_BUF_X2%VDD_4 0.420714
C_x_PM_BUF_X2%3_c0 VSS x_PM_BUF_X2%3_31 9.87551e-18
C_x_PM_BUF_X2%3_c1 VSS x_PM_BUF_X2%3_25 4.34052e-17
C_x_PM_BUF_X2%3_c2 VSS x_PM_BUF_X2%3_24 9.58887e-17
C_x_PM_BUF_X2%3_c3 VSS x_PM_BUF_X2%3_22 4.39826e-18
C_x_PM_BUF_X2%3_c4 VSS x_PM_BUF_X2%3_21 4.41595e-17
C_x_PM_BUF_X2%3_c5 VSS x_PM_BUF_X2%3_20 1.51022e-17
C_x_PM_BUF_X2%3_c6 VSS x_PM_BUF_X2%3_19 2.89567e-17
C_x_PM_BUF_X2%3_c7 VSS N_3_M0_s 2.73356e-17
C_x_PM_BUF_X2%3_c8 VSS N_3_M2_s 3.67549e-17
C_x_PM_BUF_X2%3_c9 VSS N_3_M1_g 8.56064e-17
C_x_PM_BUF_X2%3_c10 VSS N_3_M3_g 4.79448e-17
R_x_PM_BUF_X2%3_r11 x_PM_BUF_X2%3_33 x_PM_BUF_X2%3_31 4.74714
R_x_PM_BUF_X2%3_r12 x_PM_BUF_X2%3_30 x_PM_BUF_X2%3_28 0.297071
R_x_PM_BUF_X2%3_r13 x_PM_BUF_X2%3_31 x_PM_BUF_X2%3_28 25.0012
R_x_PM_BUF_X2%3_r14 x_PM_BUF_X2%3_28 x_PM_BUF_X2%3_25 0.13
R_x_PM_BUF_X2%3_r15 x_PM_BUF_X2%3_24 x_PM_BUF_X2%3_30 2.57857
R_x_PM_BUF_X2%3_r16 x_PM_BUF_X2%3_24 x_PM_BUF_X2%3_21 0.212317
R_x_PM_BUF_X2%3_r17 x_PM_BUF_X2%3_22 x_PM_BUF_X2%3_21 0.895714
R_x_PM_BUF_X2%3_r18 x_PM_BUF_X2%3_25 x_PM_BUF_X2%3_19 0.095
R_x_PM_BUF_X2%3_r19 x_PM_BUF_X2%3_20 x_PM_BUF_X2%3_19 0.895714
R_x_PM_BUF_X2%3_r20 x_PM_BUF_X2%3_22 x_PM_BUF_X2%3_15 0.212317
R_x_PM_BUF_X2%3_r21 N_3_M0_s x_PM_BUF_X2%3_15 0.393571
R_x_PM_BUF_X2%3_r22 x_PM_BUF_X2%3_20 x_PM_BUF_X2%3_11 0.212317
R_x_PM_BUF_X2%3_r23 N_3_M2_s x_PM_BUF_X2%3_11 1.045
R_x_PM_BUF_X2%3_r24 N_3_M1_g x_PM_BUF_X2%3_33 95.16
R_x_PM_BUF_X2%3_r25 x_PM_BUF_X2%3_VSS x_PM_BUF_X2%3_31 4.74714
R_x_PM_BUF_X2%3_r26 N_3_M3_g x_PM_BUF_X2%3_VSS 42.9
C_x_PM_BUF_X2%A_c0 VSS x_PM_BUF_X2%A_14 7.38755e-18
C_x_PM_BUF_X2%A_c1 VSS x_PM_BUF_X2%A_12 6.51234e-17
C_x_PM_BUF_X2%A_c2 VSS N_A_M0_g 6.60639e-17
C_x_PM_BUF_X2%A_c3 VSS N_A_M2_g 5.42189e-17
R_x_PM_BUF_X2%A_r4 x_PM_BUF_X2%A_18 x_PM_BUF_X2%A_14 4.7687
R_x_PM_BUF_X2%A_r5 x_PM_BUF_X2%A_17 x_PM_BUF_X2%A_14 4.7687
R_x_PM_BUF_X2%A_r6 x_PM_BUF_X2%A_14 x_PM_BUF_X2%A_12 25.0012
R_x_PM_BUF_X2%A_r7 x_PM_BUF_X2%A_12 A 0.2375
R_x_PM_BUF_X2%A_r8 N_A_M0_g x_PM_BUF_X2%A_18 84.63
R_x_PM_BUF_X2%A_r9 N_A_M2_g x_PM_BUF_X2%A_17 56.94
C_x_PM_BUF_X2%Z_c0 VSS N_Z_M3_d 3.4635e-17
C_x_PM_BUF_X2%Z_c1 VSS Z 9.23569e-17
C_x_PM_BUF_X2%Z_c2 VSS N_Z_M1_d 5.59233e-17
C_x_PM_BUF_X2%Z_c3 VSS x_PM_BUF_X2%Z_3 8.95839e-18
R_x_PM_BUF_X2%Z_r4 Z x_PM_BUF_X2%Z_8 1.87286
R_x_PM_BUF_X2%Z_r5 x_PM_BUF_X2%Z_7 N_Z_M3_d 0.30478
R_x_PM_BUF_X2%Z_r6 Z x_PM_BUF_X2%Z_7 1.79143
R_x_PM_BUF_X2%Z_r7 x_PM_BUF_X2%Z_8 x_PM_BUF_X2%Z_3 0.20978
R_x_PM_BUF_X2%Z_r8 N_Z_M1_d x_PM_BUF_X2%Z_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X32 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M8 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M9 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M10 N_VDD_M2_d N_3_M2_g N_Z_M1_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M11 N_Z_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M12 N_VDD_M4_d N_3_M4_g N_Z_M3_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M13 N_Z_M5_d N_3_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M14 N_VDD_M6_d N_3_M6_g N_Z_M5_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M15 N_Z_M7_d N_3_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M0 N_VSS_M8_d N_A_M8_g N_3_M8_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M2 N_VSS_M10_d N_3_M10_g N_Z_M9_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M3 N_Z_M11_d N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M4 N_VSS_M12_d N_3_M12_g N_Z_M11_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M5 N_Z_M13_d N_3_M13_g N_VSS_M12_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M6 N_VSS_M14_d N_3_M14_g N_Z_M13_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M7 N_Z_M15_d N_3_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.410000U L=0.050000U
C_x_PM_BUF_X32%VSS_c0 VSS x_PM_BUF_X32%VSS_36 3.22161e-17
C_x_PM_BUF_X32%VSS_c1 VSS x_PM_BUF_X32%VSS_35 2.70113e-18
C_x_PM_BUF_X32%VSS_c2 VSS x_PM_BUF_X32%VSS_34 2.70113e-18
C_x_PM_BUF_X32%VSS_c3 VSS x_PM_BUF_X32%VSS_33 3.88153e-17
C_x_PM_BUF_X32%VSS_c4 VSS N_VSS_M14_d 3.21482e-17
C_x_PM_BUF_X32%VSS_c5 VSS x_PM_BUF_X32%VSS_25 2.47021e-17
C_x_PM_BUF_X32%VSS_c6 VSS N_VSS_M12_d 2.64696e-17
C_x_PM_BUF_X32%VSS_c7 VSS x_PM_BUF_X32%VSS_17 2.54462e-17
C_x_PM_BUF_X32%VSS_c8 VSS N_VSS_M10_d 2.64969e-17
C_x_PM_BUF_X32%VSS_c9 VSS x_PM_BUF_X32%VSS_11 2.47013e-17
C_x_PM_BUF_X32%VSS_c10 VSS N_VSS_M8_d 3.52583e-17
R_x_PM_BUF_X32%VSS_r11 x_PM_BUF_X32%VSS_36 x_PM_BUF_X32%VSS_27 0.145286
R_x_PM_BUF_X32%VSS_r12 N_VSS_M14_d x_PM_BUF_X32%VSS_27 0.990714
R_x_PM_BUF_X32%VSS_r13 x_PM_BUF_X32%VSS_35 x_PM_BUF_X32%VSS_26 0.0731438
R_x_PM_BUF_X32%VSS_r14 x_PM_BUF_X32%VSS_36 x_PM_BUF_X32%VSS_25 0.0731438
R_x_PM_BUF_X32%VSS_r15 x_PM_BUF_X32%VSS_26 x_PM_BUF_X32%VSS_25 0.681765
R_x_PM_BUF_X32%VSS_r16 x_PM_BUF_X32%VSS_35 x_PM_BUF_X32%VSS_21 0.145286
R_x_PM_BUF_X32%VSS_r17 N_VSS_M12_d x_PM_BUF_X32%VSS_21 0.990714
R_x_PM_BUF_X32%VSS_r18 x_PM_BUF_X32%VSS_34 x_PM_BUF_X32%VSS_18 0.0731438
R_x_PM_BUF_X32%VSS_r19 VSS x_PM_BUF_X32%VSS_18 0.402353
R_x_PM_BUF_X32%VSS_r20 x_PM_BUF_X32%VSS_35 x_PM_BUF_X32%VSS_17 0.0731438
R_x_PM_BUF_X32%VSS_r21 VSS x_PM_BUF_X32%VSS_17 0.301765
R_x_PM_BUF_X32%VSS_r22 x_PM_BUF_X32%VSS_34 x_PM_BUF_X32%VSS_13 0.145286
R_x_PM_BUF_X32%VSS_r23 N_VSS_M10_d x_PM_BUF_X32%VSS_13 0.990714
R_x_PM_BUF_X32%VSS_r24 x_PM_BUF_X32%VSS_33 x_PM_BUF_X32%VSS_12 0.0731438
R_x_PM_BUF_X32%VSS_r25 x_PM_BUF_X32%VSS_34 x_PM_BUF_X32%VSS_11 0.0731438
R_x_PM_BUF_X32%VSS_r26 x_PM_BUF_X32%VSS_12 x_PM_BUF_X32%VSS_11 0.670588
R_x_PM_BUF_X32%VSS_r27 x_PM_BUF_X32%VSS_33 x_PM_BUF_X32%VSS_7 0.145286
R_x_PM_BUF_X32%VSS_r28 N_VSS_M8_d x_PM_BUF_X32%VSS_7 0.637857
C_x_PM_BUF_X32%VDD_c0 VSS x_PM_BUF_X32%VDD_36 3.00879e-17
C_x_PM_BUF_X32%VDD_c1 VSS x_PM_BUF_X32%VDD_35 2.70113e-18
C_x_PM_BUF_X32%VDD_c2 VSS x_PM_BUF_X32%VDD_34 2.70113e-18
C_x_PM_BUF_X32%VDD_c3 VSS x_PM_BUF_X32%VDD_33 2.71639e-18
C_x_PM_BUF_X32%VDD_c4 VSS N_VDD_M6_d 2.43243e-17
C_x_PM_BUF_X32%VDD_c5 VSS x_PM_BUF_X32%VDD_25 2.23069e-17
C_x_PM_BUF_X32%VDD_c6 VSS N_VDD_M4_d 1.55834e-17
C_x_PM_BUF_X32%VDD_c7 VSS x_PM_BUF_X32%VDD_19 2.37944e-17
C_x_PM_BUF_X32%VDD_c8 VSS N_VDD_M2_d 1.78143e-17
C_x_PM_BUF_X32%VDD_c9 VSS x_PM_BUF_X32%VDD_13 2.32977e-17
C_x_PM_BUF_X32%VDD_c10 VSS N_VDD_M0_d 3.05911e-17
C_x_PM_BUF_X32%VDD_c11 VSS x_PM_BUF_X32%VDD_5 3.71689e-17
R_x_PM_BUF_X32%VDD_r12 x_PM_BUF_X32%VDD_36 x_PM_BUF_X32%VDD_27 0.145286
R_x_PM_BUF_X32%VDD_r13 N_VDD_M6_d x_PM_BUF_X32%VDD_27 0.230714
R_x_PM_BUF_X32%VDD_r14 x_PM_BUF_X32%VDD_35 x_PM_BUF_X32%VDD_26 0.0731438
R_x_PM_BUF_X32%VDD_r15 x_PM_BUF_X32%VDD_36 x_PM_BUF_X32%VDD_25 0.0731438
R_x_PM_BUF_X32%VDD_r16 x_PM_BUF_X32%VDD_26 x_PM_BUF_X32%VDD_25 0.670588
R_x_PM_BUF_X32%VDD_r17 x_PM_BUF_X32%VDD_35 x_PM_BUF_X32%VDD_21 0.145286
R_x_PM_BUF_X32%VDD_r18 N_VDD_M4_d x_PM_BUF_X32%VDD_21 0.230714
R_x_PM_BUF_X32%VDD_r19 x_PM_BUF_X32%VDD_34 x_PM_BUF_X32%VDD_20 0.0731438
R_x_PM_BUF_X32%VDD_r20 x_PM_BUF_X32%VDD_35 x_PM_BUF_X32%VDD_19 0.0731438
R_x_PM_BUF_X32%VDD_r21 x_PM_BUF_X32%VDD_20 x_PM_BUF_X32%VDD_19 0.715294
R_x_PM_BUF_X32%VDD_r22 x_PM_BUF_X32%VDD_34 x_PM_BUF_X32%VDD_15 0.145286
R_x_PM_BUF_X32%VDD_r23 N_VDD_M2_d x_PM_BUF_X32%VDD_15 0.230714
R_x_PM_BUF_X32%VDD_r24 x_PM_BUF_X32%VDD_33 x_PM_BUF_X32%VDD_14 0.0731438
R_x_PM_BUF_X32%VDD_r25 x_PM_BUF_X32%VDD_34 x_PM_BUF_X32%VDD_13 0.0731438
R_x_PM_BUF_X32%VDD_r26 x_PM_BUF_X32%VDD_14 x_PM_BUF_X32%VDD_13 0.692941
R_x_PM_BUF_X32%VDD_r27 x_PM_BUF_X32%VDD_33 x_PM_BUF_X32%VDD_9 0.145286
R_x_PM_BUF_X32%VDD_r28 N_VDD_M0_d x_PM_BUF_X32%VDD_9 0.393571
R_x_PM_BUF_X32%VDD_r29 x_PM_BUF_X32%VDD_33 x_PM_BUF_X32%VDD_5 0.0731438
R_x_PM_BUF_X32%VDD_r30 VDD x_PM_BUF_X32%VDD_5 0.251471
C_x_PM_BUF_X32%3_c0 VSS x_PM_BUF_X32%3_92 1.26061e-16
C_x_PM_BUF_X32%3_c1 VSS x_PM_BUF_X32%3_88 4.40263e-18
C_x_PM_BUF_X32%3_c2 VSS x_PM_BUF_X32%3_87 2.81894e-17
C_x_PM_BUF_X32%3_c3 VSS x_PM_BUF_X32%3_86 6.48936e-18
C_x_PM_BUF_X32%3_c4 VSS x_PM_BUF_X32%3_85 4.53985e-17
C_x_PM_BUF_X32%3_c5 VSS N_3_M0_s 2.8613e-17
C_x_PM_BUF_X32%3_c6 VSS N_3_M8_s 3.38281e-17
C_x_PM_BUF_X32%3_c7 VSS x_PM_BUF_X32%3_74 5.63556e-18
C_x_PM_BUF_X32%3_c8 VSS x_PM_BUF_X32%3_73 2.33209e-18
C_x_PM_BUF_X32%3_c9 VSS x_PM_BUF_X32%3_72 1.9637e-18
C_x_PM_BUF_X32%3_c10 VSS x_PM_BUF_X32%3_71 2.14789e-18
C_x_PM_BUF_X32%3_c11 VSS x_PM_BUF_X32%3_70 2.14789e-18
C_x_PM_BUF_X32%3_c12 VSS x_PM_BUF_X32%3_69 1.9637e-18
C_x_PM_BUF_X32%3_c13 VSS N_3_M7_g 5.61721e-17
C_x_PM_BUF_X32%3_c14 VSS N_3_M15_g 4.29491e-17
C_x_PM_BUF_X32%3_c15 VSS x_PM_BUF_X32%3_59 1.33177e-17
C_x_PM_BUF_X32%3_c16 VSS N_3_M6_g 3.54626e-17
C_x_PM_BUF_X32%3_c17 VSS N_3_M14_g 2.46487e-17
C_x_PM_BUF_X32%3_c18 VSS x_PM_BUF_X32%3_49 1.01284e-17
C_x_PM_BUF_X32%3_c19 VSS N_3_M5_g 3.51373e-17
C_x_PM_BUF_X32%3_c20 VSS N_3_M13_g 2.48697e-17
C_x_PM_BUF_X32%3_c21 VSS x_PM_BUF_X32%3_39 1.35422e-17
C_x_PM_BUF_X32%3_c22 VSS N_3_M4_g 3.56e-17
C_x_PM_BUF_X32%3_c23 VSS N_3_M12_g 2.48255e-17
C_x_PM_BUF_X32%3_c24 VSS x_PM_BUF_X32%3_29 1.01609e-17
C_x_PM_BUF_X32%3_c25 VSS N_3_M3_g 3.55917e-17
C_x_PM_BUF_X32%3_c26 VSS N_3_M11_g 2.49857e-17
C_x_PM_BUF_X32%3_c27 VSS x_PM_BUF_X32%3_19 1.35422e-17
C_x_PM_BUF_X32%3_c28 VSS N_3_M2_g 3.47929e-17
C_x_PM_BUF_X32%3_c29 VSS N_3_M10_g 2.47085e-17
C_x_PM_BUF_X32%3_c30 VSS x_PM_BUF_X32%3_10 6.58434e-18
C_x_PM_BUF_X32%3_c31 VSS x_PM_BUF_X32%3_9 1.09256e-17
C_x_PM_BUF_X32%3_c32 VSS N_3_M1_g 4.81466e-17
C_x_PM_BUF_X32%3_c33 VSS N_3_M9_g 3.61412e-17
R_x_PM_BUF_X32%3_r34 x_PM_BUF_X32%3_96 x_PM_BUF_X32%3_94 3.38
R_x_PM_BUF_X32%3_r35 x_PM_BUF_X32%3_94 x_PM_BUF_X32%3_92 25.0012
R_x_PM_BUF_X32%3_r36 x_PM_BUF_X32%3_92 x_PM_BUF_X32%3_90 2.45643
R_x_PM_BUF_X32%3_r37 x_PM_BUF_X32%3_92 x_PM_BUF_X32%3_89 0.990714
R_x_PM_BUF_X32%3_r38 x_PM_BUF_X32%3_90 x_PM_BUF_X32%3_87 0.212317
R_x_PM_BUF_X32%3_r39 x_PM_BUF_X32%3_88 x_PM_BUF_X32%3_87 0.95
R_x_PM_BUF_X32%3_r40 x_PM_BUF_X32%3_89 x_PM_BUF_X32%3_85 0.212317
R_x_PM_BUF_X32%3_r41 x_PM_BUF_X32%3_86 x_PM_BUF_X32%3_85 0.95
R_x_PM_BUF_X32%3_r42 x_PM_BUF_X32%3_88 x_PM_BUF_X32%3_81 0.212317
R_x_PM_BUF_X32%3_r43 N_3_M0_s x_PM_BUF_X32%3_81 0.393571
R_x_PM_BUF_X32%3_r44 x_PM_BUF_X32%3_86 x_PM_BUF_X32%3_77 0.212317
R_x_PM_BUF_X32%3_r45 N_3_M8_s x_PM_BUF_X32%3_77 0.637857
R_x_PM_BUF_X32%3_r46 x_PM_BUF_X32%3_74 x_PM_BUF_X32%3_65 4.56151
R_x_PM_BUF_X32%3_r47 N_3_M7_g x_PM_BUF_X32%3_65 58.89
R_x_PM_BUF_X32%3_r48 x_PM_BUF_X32%3_74 x_PM_BUF_X32%3_61 4.56151
R_x_PM_BUF_X32%3_r49 N_3_M15_g x_PM_BUF_X32%3_61 39.78
R_x_PM_BUF_X32%3_r50 x_PM_BUF_X32%3_73 x_PM_BUF_X32%3_60 1.95
R_x_PM_BUF_X32%3_r51 x_PM_BUF_X32%3_74 x_PM_BUF_X32%3_59 0.043368
R_x_PM_BUF_X32%3_r52 x_PM_BUF_X32%3_60 x_PM_BUF_X32%3_59 14.56
R_x_PM_BUF_X32%3_r53 x_PM_BUF_X32%3_73 x_PM_BUF_X32%3_55 1.95
R_x_PM_BUF_X32%3_r54 N_3_M6_g x_PM_BUF_X32%3_55 58.89
R_x_PM_BUF_X32%3_r55 x_PM_BUF_X32%3_73 x_PM_BUF_X32%3_51 1.95
R_x_PM_BUF_X32%3_r56 N_3_M14_g x_PM_BUF_X32%3_51 39.78
R_x_PM_BUF_X32%3_r57 x_PM_BUF_X32%3_72 x_PM_BUF_X32%3_50 1.95
R_x_PM_BUF_X32%3_r58 x_PM_BUF_X32%3_73 x_PM_BUF_X32%3_49 1.95
R_x_PM_BUF_X32%3_r59 x_PM_BUF_X32%3_50 x_PM_BUF_X32%3_49 14.56
R_x_PM_BUF_X32%3_r60 x_PM_BUF_X32%3_72 x_PM_BUF_X32%3_45 1.95
R_x_PM_BUF_X32%3_r61 N_3_M5_g x_PM_BUF_X32%3_45 58.89
R_x_PM_BUF_X32%3_r62 x_PM_BUF_X32%3_72 x_PM_BUF_X32%3_41 1.95
R_x_PM_BUF_X32%3_r63 N_3_M13_g x_PM_BUF_X32%3_41 39.78
R_x_PM_BUF_X32%3_r64 x_PM_BUF_X32%3_71 x_PM_BUF_X32%3_40 1.95
R_x_PM_BUF_X32%3_r65 x_PM_BUF_X32%3_72 x_PM_BUF_X32%3_39 1.95
R_x_PM_BUF_X32%3_r66 x_PM_BUF_X32%3_40 x_PM_BUF_X32%3_39 14.56
R_x_PM_BUF_X32%3_r67 x_PM_BUF_X32%3_71 x_PM_BUF_X32%3_35 1.95
R_x_PM_BUF_X32%3_r68 N_3_M4_g x_PM_BUF_X32%3_35 58.89
R_x_PM_BUF_X32%3_r69 x_PM_BUF_X32%3_71 x_PM_BUF_X32%3_31 1.95
R_x_PM_BUF_X32%3_r70 N_3_M12_g x_PM_BUF_X32%3_31 39.78
R_x_PM_BUF_X32%3_r71 x_PM_BUF_X32%3_70 x_PM_BUF_X32%3_30 1.95
R_x_PM_BUF_X32%3_r72 x_PM_BUF_X32%3_71 x_PM_BUF_X32%3_29 1.95
R_x_PM_BUF_X32%3_r73 x_PM_BUF_X32%3_30 x_PM_BUF_X32%3_29 14.56
R_x_PM_BUF_X32%3_r74 x_PM_BUF_X32%3_70 x_PM_BUF_X32%3_25 1.95
R_x_PM_BUF_X32%3_r75 N_3_M3_g x_PM_BUF_X32%3_25 58.89
R_x_PM_BUF_X32%3_r76 x_PM_BUF_X32%3_70 x_PM_BUF_X32%3_21 1.95
R_x_PM_BUF_X32%3_r77 N_3_M11_g x_PM_BUF_X32%3_21 39.78
R_x_PM_BUF_X32%3_r78 x_PM_BUF_X32%3_69 x_PM_BUF_X32%3_20 1.95
R_x_PM_BUF_X32%3_r79 x_PM_BUF_X32%3_70 x_PM_BUF_X32%3_19 1.95
R_x_PM_BUF_X32%3_r80 x_PM_BUF_X32%3_20 x_PM_BUF_X32%3_19 14.56
R_x_PM_BUF_X32%3_r81 x_PM_BUF_X32%3_69 x_PM_BUF_X32%3_15 1.95
R_x_PM_BUF_X32%3_r82 N_3_M2_g x_PM_BUF_X32%3_15 58.89
R_x_PM_BUF_X32%3_r83 x_PM_BUF_X32%3_69 x_PM_BUF_X32%3_11 1.95
R_x_PM_BUF_X32%3_r84 N_3_M10_g x_PM_BUF_X32%3_11 39.78
R_x_PM_BUF_X32%3_r85 x_PM_BUF_X32%3_96 x_PM_BUF_X32%3_10 2.6
R_x_PM_BUF_X32%3_r86 x_PM_BUF_X32%3_69 x_PM_BUF_X32%3_9 1.95
R_x_PM_BUF_X32%3_r87 x_PM_BUF_X32%3_10 x_PM_BUF_X32%3_9 14.56
R_x_PM_BUF_X32%3_r88 x_PM_BUF_X32%3_96 x_PM_BUF_X32%3_5 1.95
R_x_PM_BUF_X32%3_r89 N_3_M1_g x_PM_BUF_X32%3_5 58.89
R_x_PM_BUF_X32%3_r90 x_PM_BUF_X32%3_96 x_PM_BUF_X32%3_VSS 1.95
R_x_PM_BUF_X32%3_r91 N_3_M9_g x_PM_BUF_X32%3_VSS 39.78
C_x_PM_BUF_X32%A_c0 VSS x_PM_BUF_X32%A_14 6.97073e-18
C_x_PM_BUF_X32%A_c1 VSS x_PM_BUF_X32%A_12 2.79469e-17
C_x_PM_BUF_X32%A_c2 VSS N_A_M0_g 6.65821e-17
C_x_PM_BUF_X32%A_c3 VSS N_A_M8_g 5.3353e-17
R_x_PM_BUF_X32%A_r4 x_PM_BUF_X32%A_18 x_PM_BUF_X32%A_14 4.7687
R_x_PM_BUF_X32%A_r5 x_PM_BUF_X32%A_17 x_PM_BUF_X32%A_14 4.7687
R_x_PM_BUF_X32%A_r6 x_PM_BUF_X32%A_14 x_PM_BUF_X32%A_12 25.0012
R_x_PM_BUF_X32%A_r7 x_PM_BUF_X32%A_12 A 0.169643
R_x_PM_BUF_X32%A_r8 N_A_M0_g x_PM_BUF_X32%A_18 85.41
R_x_PM_BUF_X32%A_r9 N_A_M8_g x_PM_BUF_X32%A_17 59.28
C_x_PM_BUF_X32%Z_c0 VSS x_PM_BUF_X32%Z_52 3.71575e-18
C_x_PM_BUF_X32%Z_c1 VSS x_PM_BUF_X32%Z_51 2.23522e-18
C_x_PM_BUF_X32%Z_c2 VSS x_PM_BUF_X32%Z_50 2.23522e-18
C_x_PM_BUF_X32%Z_c3 VSS x_PM_BUF_X32%Z_49 4.50784e-17
C_x_PM_BUF_X32%Z_c4 VSS N_Z_M7_d 1.67143e-17
C_x_PM_BUF_X32%Z_c5 VSS N_Z_M15_d 2.75236e-17
C_x_PM_BUF_X32%Z_c6 VSS x_PM_BUF_X32%Z_39 2.52347e-17
C_x_PM_BUF_X32%Z_c7 VSS N_Z_M5_d 1.57794e-17
C_x_PM_BUF_X32%Z_c8 VSS N_Z_M13_d 3.28143e-17
C_x_PM_BUF_X32%Z_c9 VSS x_PM_BUF_X32%Z_27 2.34215e-17
C_x_PM_BUF_X32%Z_c10 VSS N_Z_M3_d 1.57207e-17
C_x_PM_BUF_X32%Z_c11 VSS N_Z_M11_d 3.22366e-17
C_x_PM_BUF_X32%Z_c12 VSS x_PM_BUF_X32%Z_17 2.32993e-17
C_x_PM_BUF_X32%Z_c13 VSS N_Z_M1_d 5.18034e-17
C_x_PM_BUF_X32%Z_c14 VSS N_Z_M9_d 6.40188e-17
R_x_PM_BUF_X32%Z_r15 x_PM_BUF_X32%Z_52 x_PM_BUF_X32%Z_45 0.237865
R_x_PM_BUF_X32%Z_r16 N_Z_M7_d x_PM_BUF_X32%Z_45 1.01786
R_x_PM_BUF_X32%Z_r17 x_PM_BUF_X32%Z_52 x_PM_BUF_X32%Z_41 0.237865
R_x_PM_BUF_X32%Z_r18 N_Z_M15_d x_PM_BUF_X32%Z_41 0.583571
R_x_PM_BUF_X32%Z_r19 x_PM_BUF_X32%Z_51 x_PM_BUF_X32%Z_40 0.0950001
R_x_PM_BUF_X32%Z_r20 x_PM_BUF_X32%Z_52 x_PM_BUF_X32%Z_39 0.0114412
R_x_PM_BUF_X32%Z_r21 x_PM_BUF_X32%Z_40 x_PM_BUF_X32%Z_39 1.02435
R_x_PM_BUF_X32%Z_r22 x_PM_BUF_X32%Z_51 x_PM_BUF_X32%Z_35 0.0950001
R_x_PM_BUF_X32%Z_r23 N_Z_M5_d x_PM_BUF_X32%Z_35 1.01786
R_x_PM_BUF_X32%Z_r24 x_PM_BUF_X32%Z_51 x_PM_BUF_X32%Z_31 0.0950001
R_x_PM_BUF_X32%Z_r25 N_Z_M13_d x_PM_BUF_X32%Z_31 0.583571
R_x_PM_BUF_X32%Z_r26 x_PM_BUF_X32%Z_50 x_PM_BUF_X32%Z_28 0.0950001
R_x_PM_BUF_X32%Z_r27 Z x_PM_BUF_X32%Z_28 0.578261
R_x_PM_BUF_X32%Z_r28 x_PM_BUF_X32%Z_51 x_PM_BUF_X32%Z_27 0.0950001
R_x_PM_BUF_X32%Z_r29 Z x_PM_BUF_X32%Z_27 0.429565
R_x_PM_BUF_X32%Z_r30 x_PM_BUF_X32%Z_50 x_PM_BUF_X32%Z_23 0.0950001
R_x_PM_BUF_X32%Z_r31 N_Z_M3_d x_PM_BUF_X32%Z_23 1.01786
R_x_PM_BUF_X32%Z_r32 x_PM_BUF_X32%Z_50 x_PM_BUF_X32%Z_19 0.0950001
R_x_PM_BUF_X32%Z_r33 N_Z_M11_d x_PM_BUF_X32%Z_19 0.583571
R_x_PM_BUF_X32%Z_r34 x_PM_BUF_X32%Z_49 x_PM_BUF_X32%Z_18 0.0114412
R_x_PM_BUF_X32%Z_r35 x_PM_BUF_X32%Z_50 x_PM_BUF_X32%Z_17 0.0950001
R_x_PM_BUF_X32%Z_r36 x_PM_BUF_X32%Z_18 x_PM_BUF_X32%Z_17 1.00783
R_x_PM_BUF_X32%Z_r37 x_PM_BUF_X32%Z_49 x_PM_BUF_X32%Z_13 0.237865
R_x_PM_BUF_X32%Z_r38 N_Z_M1_d x_PM_BUF_X32%Z_13 1.01786
R_x_PM_BUF_X32%Z_r39 x_PM_BUF_X32%Z_49 x_PM_BUF_X32%Z_9 0.237865
R_x_PM_BUF_X32%Z_r40 N_Z_M9_d x_PM_BUF_X32%Z_9 0.583571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X4 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_BUF_X4%VSS_c0 VSS VSS 1.06406e-16
R_x_PM_BUF_X4%VSS_r1 N_VSS_M2_d VSS 0.597143
C_x_PM_BUF_X4%VDD_c0 VSS VDD 6.66616e-17
C_x_PM_BUF_X4%VDD_c1 VSS N_VDD_M0_d 3.55471e-17
R_x_PM_BUF_X4%VDD_r2 VDD x_PM_BUF_X4%VDD_4 0.145286
R_x_PM_BUF_X4%VDD_r3 N_VDD_M0_d x_PM_BUF_X4%VDD_4 0.393571
C_x_PM_BUF_X4%3_c0 VSS x_PM_BUF_X4%3_34 1.16224e-17
C_x_PM_BUF_X4%3_c1 VSS x_PM_BUF_X4%3_30 3.26815e-17
C_x_PM_BUF_X4%3_c2 VSS x_PM_BUF_X4%3_28 4.69677e-17
C_x_PM_BUF_X4%3_c3 VSS x_PM_BUF_X4%3_26 5.12109e-17
C_x_PM_BUF_X4%3_c4 VSS x_PM_BUF_X4%3_22 4.67575e-18
C_x_PM_BUF_X4%3_c5 VSS x_PM_BUF_X4%3_21 3.30188e-17
C_x_PM_BUF_X4%3_c6 VSS x_PM_BUF_X4%3_20 7.33159e-18
C_x_PM_BUF_X4%3_c7 VSS x_PM_BUF_X4%3_19 4.15601e-17
C_x_PM_BUF_X4%3_c8 VSS N_3_M0_s 2.97344e-17
C_x_PM_BUF_X4%3_c9 VSS N_3_M2_s 3.4955e-17
C_x_PM_BUF_X4%3_c10 VSS N_3_M1_g 6.66471e-17
C_x_PM_BUF_X4%3_c11 VSS N_3_M3_g 5.47013e-17
R_x_PM_BUF_X4%3_r12 x_PM_BUF_X4%3_34 x_PM_BUF_X4%3_32 3.38
R_x_PM_BUF_X4%3_r13 x_PM_BUF_X4%3_31 x_PM_BUF_X4%3_28 0.286607
R_x_PM_BUF_X4%3_r14 x_PM_BUF_X4%3_30 x_PM_BUF_X4%3_28 0.286607
R_x_PM_BUF_X4%3_r15 x_PM_BUF_X4%3_32 x_PM_BUF_X4%3_28 25.0012
R_x_PM_BUF_X4%3_r16 x_PM_BUF_X4%3_26 x_PM_BUF_X4%3_31 1.76429
R_x_PM_BUF_X4%3_r17 x_PM_BUF_X4%3_30 x_PM_BUF_X4%3_23 0.95
R_x_PM_BUF_X4%3_r18 x_PM_BUF_X4%3_26 x_PM_BUF_X4%3_21 0.212317
R_x_PM_BUF_X4%3_r19 x_PM_BUF_X4%3_22 x_PM_BUF_X4%3_21 0.76
R_x_PM_BUF_X4%3_r20 x_PM_BUF_X4%3_23 x_PM_BUF_X4%3_19 0.212317
R_x_PM_BUF_X4%3_r21 x_PM_BUF_X4%3_20 x_PM_BUF_X4%3_19 0.76
R_x_PM_BUF_X4%3_r22 x_PM_BUF_X4%3_22 x_PM_BUF_X4%3_15 0.212317
R_x_PM_BUF_X4%3_r23 N_3_M0_s x_PM_BUF_X4%3_15 0.393571
R_x_PM_BUF_X4%3_r24 x_PM_BUF_X4%3_20 x_PM_BUF_X4%3_11 0.212317
R_x_PM_BUF_X4%3_r25 N_3_M2_s x_PM_BUF_X4%3_11 0.637857
R_x_PM_BUF_X4%3_r26 x_PM_BUF_X4%3_34 x_PM_BUF_X4%3_5 1.95
R_x_PM_BUF_X4%3_r27 N_3_M1_g x_PM_BUF_X4%3_5 50.7
R_x_PM_BUF_X4%3_r28 x_PM_BUF_X4%3_34 x_PM_BUF_X4%3_VSS 1.95
R_x_PM_BUF_X4%3_r29 N_3_M3_g x_PM_BUF_X4%3_VSS 41.34
C_x_PM_BUF_X4%A_c0 VSS x_PM_BUF_X4%A_14 7.29519e-18
C_x_PM_BUF_X4%A_c1 VSS x_PM_BUF_X4%A_12 4.29404e-17
C_x_PM_BUF_X4%A_c2 VSS N_A_M0_g 6.77862e-17
C_x_PM_BUF_X4%A_c3 VSS N_A_M2_g 5.41743e-17
R_x_PM_BUF_X4%A_r4 x_PM_BUF_X4%A_18 x_PM_BUF_X4%A_14 4.7687
R_x_PM_BUF_X4%A_r5 x_PM_BUF_X4%A_17 x_PM_BUF_X4%A_14 4.7687
R_x_PM_BUF_X4%A_r6 x_PM_BUF_X4%A_14 x_PM_BUF_X4%A_12 25.0012
R_x_PM_BUF_X4%A_r7 x_PM_BUF_X4%A_12 A 0.210357
R_x_PM_BUF_X4%A_r8 N_A_M0_g x_PM_BUF_X4%A_18 84.63
R_x_PM_BUF_X4%A_r9 N_A_M2_g x_PM_BUF_X4%A_17 60.06
C_x_PM_BUF_X4%Z_c0 VSS Z 3.24815e-17
C_x_PM_BUF_X4%Z_c1 VSS x_PM_BUF_X4%Z_11 5.03178e-18
C_x_PM_BUF_X4%Z_c2 VSS N_Z_M1_d 3.5199e-17
C_x_PM_BUF_X4%Z_c3 VSS x_PM_BUF_X4%Z_7 5.03178e-18
C_x_PM_BUF_X4%Z_c4 VSS N_Z_M3_d 3.37415e-17
R_x_PM_BUF_X4%Z_r5 Z x_PM_BUF_X4%Z_12 0.597143
R_x_PM_BUF_X4%Z_r6 Z x_PM_BUF_X4%Z_11 0.407143
R_x_PM_BUF_X4%Z_r7 x_PM_BUF_X4%Z_12 x_PM_BUF_X4%Z_7 0.192227
R_x_PM_BUF_X4%Z_r8 N_Z_M1_d x_PM_BUF_X4%Z_7 0.861333
R_x_PM_BUF_X4%Z_r9 x_PM_BUF_X4%Z_11 x_PM_BUF_X4%Z_3 0.192227
R_x_PM_BUF_X4%Z_r10 N_Z_M3_d x_PM_BUF_X4%Z_3 0.152
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   BUF_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT BUF_X8 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M3 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M5 N_VDD_M2_d N_3_M2_g N_Z_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_VSS_M3_d N_A_M3_g N_3_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M4_d N_3_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M2 N_VSS_M5_d N_3_M5_g N_Z_M4_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_BUF_X8%VSS_c0 VSS x_PM_BUF_X8%VSS_17 3.89382e-17
C_x_PM_BUF_X8%VSS_c1 VSS N_VSS_M5_d 2.84639e-17
C_x_PM_BUF_X8%VSS_c2 VSS x_PM_BUF_X8%VSS_9 3.40688e-17
C_x_PM_BUF_X8%VSS_c3 VSS N_VSS_M3_d 3.50982e-17
R_x_PM_BUF_X8%VSS_r4 N_VSS_M5_d x_PM_BUF_X8%VSS_13 1.39786
R_x_PM_BUF_X8%VSS_r5 x_PM_BUF_X8%VSS_17 x_PM_BUF_X8%VSS_10 0.0731438
R_x_PM_BUF_X8%VSS_r6 VSS x_PM_BUF_X8%VSS_10 0.156471
R_x_PM_BUF_X8%VSS_r7 x_PM_BUF_X8%VSS_13 x_PM_BUF_X8%VSS_9 0.264221
R_x_PM_BUF_X8%VSS_r8 VSS x_PM_BUF_X8%VSS_9 0.536471
R_x_PM_BUF_X8%VSS_r9 x_PM_BUF_X8%VSS_17 x_PM_BUF_X8%VSS_5 0.145286
R_x_PM_BUF_X8%VSS_r10 N_VSS_M3_d x_PM_BUF_X8%VSS_5 0.637857
C_x_PM_BUF_X8%VDD_c0 VSS x_PM_BUF_X8%VDD_17 2.82055e-18
C_x_PM_BUF_X8%VDD_c1 VSS N_VDD_M2_d 2.00709e-17
C_x_PM_BUF_X8%VDD_c2 VSS x_PM_BUF_X8%VDD_11 3.41394e-17
C_x_PM_BUF_X8%VDD_c3 VSS N_VDD_M0_d 3.05913e-17
C_x_PM_BUF_X8%VDD_c4 VSS x_PM_BUF_X8%VDD_3 3.79516e-17
R_x_PM_BUF_X8%VDD_r5 N_VDD_M2_d x_PM_BUF_X8%VDD_13 0.393571
R_x_PM_BUF_X8%VDD_r6 x_PM_BUF_X8%VDD_17 x_PM_BUF_X8%VDD_12 0.0731438
R_x_PM_BUF_X8%VDD_r7 x_PM_BUF_X8%VDD_13 x_PM_BUF_X8%VDD_11 0.264221
R_x_PM_BUF_X8%VDD_r8 x_PM_BUF_X8%VDD_12 x_PM_BUF_X8%VDD_11 0.692941
R_x_PM_BUF_X8%VDD_r9 x_PM_BUF_X8%VDD_17 x_PM_BUF_X8%VDD_7 0.145286
R_x_PM_BUF_X8%VDD_r10 N_VDD_M0_d x_PM_BUF_X8%VDD_7 0.393571
R_x_PM_BUF_X8%VDD_r11 x_PM_BUF_X8%VDD_17 x_PM_BUF_X8%VDD_3 0.0731438
R_x_PM_BUF_X8%VDD_r12 VDD x_PM_BUF_X8%VDD_3 0.268235
C_x_PM_BUF_X8%3_c0 VSS x_PM_BUF_X8%3_37 1.35208e-16
C_x_PM_BUF_X8%3_c1 VSS x_PM_BUF_X8%3_33 4.69206e-18
C_x_PM_BUF_X8%3_c2 VSS x_PM_BUF_X8%3_32 2.89924e-17
C_x_PM_BUF_X8%3_c3 VSS x_PM_BUF_X8%3_31 7.34789e-18
C_x_PM_BUF_X8%3_c4 VSS x_PM_BUF_X8%3_30 4.42096e-17
C_x_PM_BUF_X8%3_c5 VSS N_3_M0_s 2.8613e-17
C_x_PM_BUF_X8%3_c6 VSS N_3_M3_s 3.47719e-17
C_x_PM_BUF_X8%3_c7 VSS x_PM_BUF_X8%3_19 3.30952e-18
C_x_PM_BUF_X8%3_c8 VSS N_3_M2_g 4.95662e-17
C_x_PM_BUF_X8%3_c9 VSS N_3_M5_g 3.77377e-17
C_x_PM_BUF_X8%3_c10 VSS x_PM_BUF_X8%3_10 6.50544e-18
C_x_PM_BUF_X8%3_c11 VSS x_PM_BUF_X8%3_9 1.21513e-17
C_x_PM_BUF_X8%3_c12 VSS N_3_M1_g 4.41519e-17
C_x_PM_BUF_X8%3_c13 VSS N_3_M4_g 3.14926e-17
R_x_PM_BUF_X8%3_r14 x_PM_BUF_X8%3_41 x_PM_BUF_X8%3_39 3.38
R_x_PM_BUF_X8%3_r15 x_PM_BUF_X8%3_39 x_PM_BUF_X8%3_37 25.0012
R_x_PM_BUF_X8%3_r16 x_PM_BUF_X8%3_37 x_PM_BUF_X8%3_35 2.32071
R_x_PM_BUF_X8%3_r17 x_PM_BUF_X8%3_37 x_PM_BUF_X8%3_34 1.12643
R_x_PM_BUF_X8%3_r18 x_PM_BUF_X8%3_35 x_PM_BUF_X8%3_32 0.212317
R_x_PM_BUF_X8%3_r19 x_PM_BUF_X8%3_33 x_PM_BUF_X8%3_32 0.95
R_x_PM_BUF_X8%3_r20 x_PM_BUF_X8%3_34 x_PM_BUF_X8%3_30 0.212317
R_x_PM_BUF_X8%3_r21 x_PM_BUF_X8%3_31 x_PM_BUF_X8%3_30 0.95
R_x_PM_BUF_X8%3_r22 x_PM_BUF_X8%3_33 x_PM_BUF_X8%3_26 0.212317
R_x_PM_BUF_X8%3_r23 N_3_M0_s x_PM_BUF_X8%3_26 0.393571
R_x_PM_BUF_X8%3_r24 x_PM_BUF_X8%3_31 x_PM_BUF_X8%3_22 0.212317
R_x_PM_BUF_X8%3_r25 N_3_M3_s x_PM_BUF_X8%3_22 0.637857
R_x_PM_BUF_X8%3_r26 x_PM_BUF_X8%3_19 x_PM_BUF_X8%3_15 4.56151
R_x_PM_BUF_X8%3_r27 N_3_M2_g x_PM_BUF_X8%3_15 56.16
R_x_PM_BUF_X8%3_r28 x_PM_BUF_X8%3_19 x_PM_BUF_X8%3_11 4.56151
R_x_PM_BUF_X8%3_r29 N_3_M5_g x_PM_BUF_X8%3_11 35.88
R_x_PM_BUF_X8%3_r30 x_PM_BUF_X8%3_41 x_PM_BUF_X8%3_10 2.6
R_x_PM_BUF_X8%3_r31 x_PM_BUF_X8%3_19 x_PM_BUF_X8%3_9 0.043368
R_x_PM_BUF_X8%3_r32 x_PM_BUF_X8%3_10 x_PM_BUF_X8%3_9 14.56
R_x_PM_BUF_X8%3_r33 x_PM_BUF_X8%3_41 x_PM_BUF_X8%3_5 1.95
R_x_PM_BUF_X8%3_r34 N_3_M1_g x_PM_BUF_X8%3_5 56.16
R_x_PM_BUF_X8%3_r35 x_PM_BUF_X8%3_41 x_PM_BUF_X8%3_VSS 1.95
R_x_PM_BUF_X8%3_r36 N_3_M4_g x_PM_BUF_X8%3_VSS 35.88
C_x_PM_BUF_X8%A_c0 VSS x_PM_BUF_X8%A_14 7.13975e-18
C_x_PM_BUF_X8%A_c1 VSS x_PM_BUF_X8%A_12 2.99617e-17
C_x_PM_BUF_X8%A_c2 VSS N_A_M0_g 6.6618e-17
C_x_PM_BUF_X8%A_c3 VSS N_A_M3_g 5.321e-17
R_x_PM_BUF_X8%A_r4 x_PM_BUF_X8%A_18 x_PM_BUF_X8%A_14 4.7687
R_x_PM_BUF_X8%A_r5 x_PM_BUF_X8%A_17 x_PM_BUF_X8%A_14 4.7687
R_x_PM_BUF_X8%A_r6 x_PM_BUF_X8%A_14 x_PM_BUF_X8%A_12 25.0012
R_x_PM_BUF_X8%A_r7 x_PM_BUF_X8%A_12 A 0.210357
R_x_PM_BUF_X8%A_r8 N_A_M0_g x_PM_BUF_X8%A_18 85.41
R_x_PM_BUF_X8%A_r9 N_A_M3_g x_PM_BUF_X8%A_17 59.28
C_x_PM_BUF_X8%Z_c0 VSS N_Z_M4_d 1.68117e-16
R_x_PM_BUF_X8%Z_r1 N_Z_M1_d Z 1.56071
R_x_PM_BUF_X8%Z_r2 Z N_Z_M4_d 0.773571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X1 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_CLKBUF_X1%VSS_c0 VSS VSS 7.45285e-17
C_x_PM_CLKBUF_X1%VSS_c1 VSS N_VSS_M2_d 6.47461e-17
R_x_PM_CLKBUF_X1%VSS_r2 VSS x_PM_CLKBUF_X1%VSS_4 0.0680382
R_x_PM_CLKBUF_X1%VSS_r3 N_VSS_M2_d x_PM_CLKBUF_X1%VSS_4 0.330741
C_x_PM_CLKBUF_X1%VDD_c0 VSS VDD 7.08053e-17
C_x_PM_CLKBUF_X1%VDD_c1 VSS N_VDD_M0_d 5.43247e-17
R_x_PM_CLKBUF_X1%VDD_r2 VDD N_VDD_M0_d 0.295556
C_x_PM_CLKBUF_X1%3_c0 VSS x_PM_CLKBUF_X1%3_31 1.40412e-17
C_x_PM_CLKBUF_X1%3_c1 VSS x_PM_CLKBUF_X1%3_22 2.82481e-17
C_x_PM_CLKBUF_X1%3_c2 VSS N_3_M2_s 4.21887e-17
C_x_PM_CLKBUF_X1%3_c3 VSS x_PM_CLKBUF_X1%3_16 1.81103e-16
C_x_PM_CLKBUF_X1%3_c4 VSS x_PM_CLKBUF_X1%3_15 3.51562e-17
C_x_PM_CLKBUF_X1%3_c5 VSS x_PM_CLKBUF_X1%3_13 5.78229e-17
C_x_PM_CLKBUF_X1%3_c6 VSS x_PM_CLKBUF_X1%3_11 2.29116e-17
C_x_PM_CLKBUF_X1%3_c7 VSS N_3_M1_g 9.98814e-17
C_x_PM_CLKBUF_X1%3_c8 VSS N_3_M3_g 2.6725e-17
R_x_PM_CLKBUF_X1%3_r9 x_PM_CLKBUF_X1%3_31 x_PM_CLKBUF_X1%3_29 5.46
R_x_PM_CLKBUF_X1%3_r10 x_PM_CLKBUF_X1%3_29 x_PM_CLKBUF_X1%3_27 25.0012
R_x_PM_CLKBUF_X1%3_r11 N_3_M0_s x_PM_CLKBUF_X1%3_22 0.204074
R_x_PM_CLKBUF_X1%3_r12 x_PM_CLKBUF_X1%3_20 N_3_M2_s 0.330741
R_x_PM_CLKBUF_X1%3_r13 x_PM_CLKBUF_X1%3_27 x_PM_CLKBUF_X1%3_15 0.0141545
R_x_PM_CLKBUF_X1%3_r14 x_PM_CLKBUF_X1%3_16 x_PM_CLKBUF_X1%3_15 3.82714
R_x_PM_CLKBUF_X1%3_r15 x_PM_CLKBUF_X1%3_22 x_PM_CLKBUF_X1%3_14 0.095
R_x_PM_CLKBUF_X1%3_r16 x_PM_CLKBUF_X1%3_16 x_PM_CLKBUF_X1%3_13 0.212317
R_x_PM_CLKBUF_X1%3_r17 x_PM_CLKBUF_X1%3_14 x_PM_CLKBUF_X1%3_13 0.732857
R_x_PM_CLKBUF_X1%3_r18 x_PM_CLKBUF_X1%3_20 x_PM_CLKBUF_X1%3_12 0.095
R_x_PM_CLKBUF_X1%3_r19 x_PM_CLKBUF_X1%3_27 x_PM_CLKBUF_X1%3_11 0.198162
R_x_PM_CLKBUF_X1%3_r20 x_PM_CLKBUF_X1%3_12 x_PM_CLKBUF_X1%3_11 0.732857
R_x_PM_CLKBUF_X1%3_r21 x_PM_CLKBUF_X1%3_31 x_PM_CLKBUF_X1%3_5 1.95
R_x_PM_CLKBUF_X1%3_r22 N_3_M1_g x_PM_CLKBUF_X1%3_5 125.97
R_x_PM_CLKBUF_X1%3_r23 x_PM_CLKBUF_X1%3_31 x_PM_CLKBUF_X1%3_VSS 1.95
R_x_PM_CLKBUF_X1%3_r24 N_3_M3_g x_PM_CLKBUF_X1%3_VSS 18.72
C_x_PM_CLKBUF_X1%A_c0 VSS x_PM_CLKBUF_X1%A_18 8.54707e-18
C_x_PM_CLKBUF_X1%A_c1 VSS x_PM_CLKBUF_X1%A_12 4.56375e-17
C_x_PM_CLKBUF_X1%A_c2 VSS N_A_M0_g 6.63456e-17
C_x_PM_CLKBUF_X1%A_c3 VSS N_A_M2_g 4.95317e-17
R_x_PM_CLKBUF_X1%A_r4 x_PM_CLKBUF_X1%A_18 x_PM_CLKBUF_X1%A_14 3.38
R_x_PM_CLKBUF_X1%A_r5 x_PM_CLKBUF_X1%A_14 x_PM_CLKBUF_X1%A_12 25.0012
R_x_PM_CLKBUF_X1%A_r6 x_PM_CLKBUF_X1%A_12 A 0.210357
R_x_PM_CLKBUF_X1%A_r7 x_PM_CLKBUF_X1%A_18 x_PM_CLKBUF_X1%A_5 1.95
R_x_PM_CLKBUF_X1%A_r8 N_A_M0_g x_PM_CLKBUF_X1%A_5 90.87
R_x_PM_CLKBUF_X1%A_r9 x_PM_CLKBUF_X1%A_18 x_PM_CLKBUF_X1%A_VSS 1.95
R_x_PM_CLKBUF_X1%A_r10 N_A_M2_g x_PM_CLKBUF_X1%A_VSS 53.82
C_x_PM_CLKBUF_X1%Z_c0 VSS N_Z_M3_d 2.5137e-16
R_x_PM_CLKBUF_X1%Z_r1 N_Z_M1_d Z 2.62438
R_x_PM_CLKBUF_X1%Z_r2 Z N_Z_M3_d 1.95938
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X2 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_CLKBUF_X2%VSS_c0 VSS VSS 1.07851e-16
R_x_PM_CLKBUF_X2%VSS_r1 N_VSS_M2_d VSS 0.637857
C_x_PM_CLKBUF_X2%VDD_c0 VSS VDD 7.97966e-17
C_x_PM_CLKBUF_X2%VDD_c1 VSS N_VDD_M0_d 3.78235e-17
R_x_PM_CLKBUF_X2%VDD_r2 VDD x_PM_CLKBUF_X2%VDD_4 0.145286
R_x_PM_CLKBUF_X2%VDD_r3 N_VDD_M0_d x_PM_CLKBUF_X2%VDD_4 0.420714
C_x_PM_CLKBUF_X2%3_c0 VSS x_PM_CLKBUF_X2%3_31 9.86438e-18
C_x_PM_CLKBUF_X2%3_c1 VSS x_PM_CLKBUF_X2%3_25 5.71796e-17
C_x_PM_CLKBUF_X2%3_c2 VSS x_PM_CLKBUF_X2%3_24 7.87657e-17
C_x_PM_CLKBUF_X2%3_c3 VSS x_PM_CLKBUF_X2%3_22 4.38643e-18
C_x_PM_CLKBUF_X2%3_c4 VSS x_PM_CLKBUF_X2%3_21 4.04714e-17
C_x_PM_CLKBUF_X2%3_c5 VSS x_PM_CLKBUF_X2%3_20 1.51022e-17
C_x_PM_CLKBUF_X2%3_c6 VSS x_PM_CLKBUF_X2%3_19 2.31709e-17
C_x_PM_CLKBUF_X2%3_c7 VSS N_3_M0_s 2.70189e-17
C_x_PM_CLKBUF_X2%3_c8 VSS N_3_M2_s 3.67549e-17
C_x_PM_CLKBUF_X2%3_c9 VSS N_3_M1_g 8.66583e-17
C_x_PM_CLKBUF_X2%3_c10 VSS N_3_M3_g 5.09141e-17
R_x_PM_CLKBUF_X2%3_r11 x_PM_CLKBUF_X2%3_33 x_PM_CLKBUF_X2%3_31 4.74714
R_x_PM_CLKBUF_X2%3_r12 x_PM_CLKBUF_X2%3_30 x_PM_CLKBUF_X2%3_28 0.279171
R_x_PM_CLKBUF_X2%3_r13 x_PM_CLKBUF_X2%3_31 x_PM_CLKBUF_X2%3_28 25.0012
R_x_PM_CLKBUF_X2%3_r14 x_PM_CLKBUF_X2%3_28 x_PM_CLKBUF_X2%3_25 0.197917
R_x_PM_CLKBUF_X2%3_r15 x_PM_CLKBUF_X2%3_24 x_PM_CLKBUF_X2%3_30 2.41571
R_x_PM_CLKBUF_X2%3_r16 x_PM_CLKBUF_X2%3_24 x_PM_CLKBUF_X2%3_21 0.212317
R_x_PM_CLKBUF_X2%3_r17 x_PM_CLKBUF_X2%3_22 x_PM_CLKBUF_X2%3_21 0.76
R_x_PM_CLKBUF_X2%3_r18 x_PM_CLKBUF_X2%3_25 x_PM_CLKBUF_X2%3_19 0.095
R_x_PM_CLKBUF_X2%3_r19 x_PM_CLKBUF_X2%3_20 x_PM_CLKBUF_X2%3_19 0.76
R_x_PM_CLKBUF_X2%3_r20 x_PM_CLKBUF_X2%3_22 x_PM_CLKBUF_X2%3_15 0.212317
R_x_PM_CLKBUF_X2%3_r21 N_3_M0_s x_PM_CLKBUF_X2%3_15 0.393571
R_x_PM_CLKBUF_X2%3_r22 x_PM_CLKBUF_X2%3_20 x_PM_CLKBUF_X2%3_11 0.212317
R_x_PM_CLKBUF_X2%3_r23 N_3_M2_s x_PM_CLKBUF_X2%3_11 1.045
R_x_PM_CLKBUF_X2%3_r24 N_3_M1_g x_PM_CLKBUF_X2%3_33 90.48
R_x_PM_CLKBUF_X2%3_r25 x_PM_CLKBUF_X2%3_VSS x_PM_CLKBUF_X2%3_31 4.74714
R_x_PM_CLKBUF_X2%3_r26 N_3_M3_g x_PM_CLKBUF_X2%3_VSS 47.58
C_x_PM_CLKBUF_X2%A_c0 VSS x_PM_CLKBUF_X2%A_14 7.21828e-18
C_x_PM_CLKBUF_X2%A_c1 VSS x_PM_CLKBUF_X2%A_12 5.77636e-17
C_x_PM_CLKBUF_X2%A_c2 VSS N_A_M0_g 6.77924e-17
C_x_PM_CLKBUF_X2%A_c3 VSS N_A_M2_g 5.46651e-17
R_x_PM_CLKBUF_X2%A_r4 x_PM_CLKBUF_X2%A_18 x_PM_CLKBUF_X2%A_14 4.7687
R_x_PM_CLKBUF_X2%A_r5 x_PM_CLKBUF_X2%A_17 x_PM_CLKBUF_X2%A_14 4.7687
R_x_PM_CLKBUF_X2%A_r6 x_PM_CLKBUF_X2%A_14 x_PM_CLKBUF_X2%A_12 25.0012
R_x_PM_CLKBUF_X2%A_r7 x_PM_CLKBUF_X2%A_12 A 0.169643
R_x_PM_CLKBUF_X2%A_r8 N_A_M0_g x_PM_CLKBUF_X2%A_18 84.63
R_x_PM_CLKBUF_X2%A_r9 N_A_M2_g x_PM_CLKBUF_X2%A_17 56.94
C_x_PM_CLKBUF_X2%Z_c0 VSS N_Z_M3_d 3.4635e-17
C_x_PM_CLKBUF_X2%Z_c1 VSS Z 8.34713e-17
C_x_PM_CLKBUF_X2%Z_c2 VSS N_Z_M1_d 5.18012e-17
C_x_PM_CLKBUF_X2%Z_c3 VSS x_PM_CLKBUF_X2%Z_3 6.62175e-18
R_x_PM_CLKBUF_X2%Z_r4 Z x_PM_CLKBUF_X2%Z_8 1.87286
R_x_PM_CLKBUF_X2%Z_r5 x_PM_CLKBUF_X2%Z_7 N_Z_M3_d 0.30478
R_x_PM_CLKBUF_X2%Z_r6 Z x_PM_CLKBUF_X2%Z_7 1.79143
R_x_PM_CLKBUF_X2%Z_r7 x_PM_CLKBUF_X2%Z_8 x_PM_CLKBUF_X2%Z_3 0.20978
R_x_PM_CLKBUF_X2%Z_r8 N_Z_M1_d x_PM_CLKBUF_X2%Z_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKBUF_X3.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKBUF_X3 VSS VDD A Z
*.PININFO VSS:B VDD:B A:I Z:O
M_M2 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_Z_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.405000U L=0.050000U
M_M0 N_VSS_M2_d N_A_M2_g N_3_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Z_M3_d N_3_M3_g N_VSS_M2_d VSS NMOS_VTL W=0.270000U L=0.050000U
C_x_PM_CLKBUF_X3%VSS_c0 VSS VSS 1.13361e-16
R_x_PM_CLKBUF_X3%VSS_r1 N_VSS_M2_d VSS 0.597143
C_x_PM_CLKBUF_X3%VDD_c0 VSS VDD 6.82761e-17
C_x_PM_CLKBUF_X3%VDD_c1 VSS N_VDD_M0_d 3.55465e-17
R_x_PM_CLKBUF_X3%VDD_r2 VDD x_PM_CLKBUF_X3%VDD_4 0.145286
R_x_PM_CLKBUF_X3%VDD_r3 N_VDD_M0_d x_PM_CLKBUF_X3%VDD_4 0.393571
C_x_PM_CLKBUF_X3%3_c0 VSS x_PM_CLKBUF_X3%3_34 1.14932e-17
C_x_PM_CLKBUF_X3%3_c1 VSS x_PM_CLKBUF_X3%3_30 1.52721e-17
C_x_PM_CLKBUF_X3%3_c2 VSS x_PM_CLKBUF_X3%3_28 3.39318e-17
C_x_PM_CLKBUF_X3%3_c3 VSS x_PM_CLKBUF_X3%3_26 7.35787e-17
C_x_PM_CLKBUF_X3%3_c4 VSS x_PM_CLKBUF_X3%3_22 4.38633e-18
C_x_PM_CLKBUF_X3%3_c5 VSS x_PM_CLKBUF_X3%3_21 4.06226e-17
C_x_PM_CLKBUF_X3%3_c6 VSS x_PM_CLKBUF_X3%3_20 6.47306e-18
C_x_PM_CLKBUF_X3%3_c7 VSS x_PM_CLKBUF_X3%3_19 4.15609e-17
C_x_PM_CLKBUF_X3%3_c8 VSS N_3_M0_s 2.95804e-17
C_x_PM_CLKBUF_X3%3_c9 VSS N_3_M2_s 3.47994e-17
C_x_PM_CLKBUF_X3%3_c10 VSS N_3_M1_g 7.94484e-17
C_x_PM_CLKBUF_X3%3_c11 VSS N_3_M3_g 4.7301e-17
R_x_PM_CLKBUF_X3%3_r12 x_PM_CLKBUF_X3%3_34 x_PM_CLKBUF_X3%3_32 3.38
R_x_PM_CLKBUF_X3%3_r13 x_PM_CLKBUF_X3%3_31 x_PM_CLKBUF_X3%3_28 0.286607
R_x_PM_CLKBUF_X3%3_r14 x_PM_CLKBUF_X3%3_30 x_PM_CLKBUF_X3%3_28 0.286607
R_x_PM_CLKBUF_X3%3_r15 x_PM_CLKBUF_X3%3_32 x_PM_CLKBUF_X3%3_28 25.0012
R_x_PM_CLKBUF_X3%3_r16 x_PM_CLKBUF_X3%3_26 x_PM_CLKBUF_X3%3_31 2.25286
R_x_PM_CLKBUF_X3%3_r17 x_PM_CLKBUF_X3%3_30 x_PM_CLKBUF_X3%3_23 0.461429
R_x_PM_CLKBUF_X3%3_r18 x_PM_CLKBUF_X3%3_26 x_PM_CLKBUF_X3%3_21 0.212317
R_x_PM_CLKBUF_X3%3_r19 x_PM_CLKBUF_X3%3_22 x_PM_CLKBUF_X3%3_21 0.76
R_x_PM_CLKBUF_X3%3_r20 x_PM_CLKBUF_X3%3_23 x_PM_CLKBUF_X3%3_19 0.212317
R_x_PM_CLKBUF_X3%3_r21 x_PM_CLKBUF_X3%3_20 x_PM_CLKBUF_X3%3_19 0.76
R_x_PM_CLKBUF_X3%3_r22 x_PM_CLKBUF_X3%3_22 x_PM_CLKBUF_X3%3_15 0.212317
R_x_PM_CLKBUF_X3%3_r23 N_3_M0_s x_PM_CLKBUF_X3%3_15 0.393571
R_x_PM_CLKBUF_X3%3_r24 x_PM_CLKBUF_X3%3_20 x_PM_CLKBUF_X3%3_11 0.212317
R_x_PM_CLKBUF_X3%3_r25 N_3_M2_s x_PM_CLKBUF_X3%3_11 0.637857
R_x_PM_CLKBUF_X3%3_r26 x_PM_CLKBUF_X3%3_34 x_PM_CLKBUF_X3%3_5 1.95
R_x_PM_CLKBUF_X3%3_r27 N_3_M1_g x_PM_CLKBUF_X3%3_5 75.27
R_x_PM_CLKBUF_X3%3_r28 x_PM_CLKBUF_X3%3_34 x_PM_CLKBUF_X3%3_VSS 1.95
R_x_PM_CLKBUF_X3%3_r29 N_3_M3_g x_PM_CLKBUF_X3%3_VSS 34.32
C_x_PM_CLKBUF_X3%A_c0 VSS x_PM_CLKBUF_X3%A_14 7.10642e-18
C_x_PM_CLKBUF_X3%A_c1 VSS x_PM_CLKBUF_X3%A_12 4.05575e-17
C_x_PM_CLKBUF_X3%A_c2 VSS N_A_M0_g 6.82246e-17
C_x_PM_CLKBUF_X3%A_c3 VSS N_A_M2_g 5.40997e-17
R_x_PM_CLKBUF_X3%A_r4 x_PM_CLKBUF_X3%A_18 x_PM_CLKBUF_X3%A_14 4.7687
R_x_PM_CLKBUF_X3%A_r5 x_PM_CLKBUF_X3%A_17 x_PM_CLKBUF_X3%A_14 4.7687
R_x_PM_CLKBUF_X3%A_r6 x_PM_CLKBUF_X3%A_14 x_PM_CLKBUF_X3%A_12 25.0012
R_x_PM_CLKBUF_X3%A_r7 x_PM_CLKBUF_X3%A_12 A 0.169643
R_x_PM_CLKBUF_X3%A_r8 N_A_M0_g x_PM_CLKBUF_X3%A_18 85.41
R_x_PM_CLKBUF_X3%A_r9 N_A_M2_g x_PM_CLKBUF_X3%A_17 59.28
C_x_PM_CLKBUF_X3%Z_c0 VSS Z 4.77743e-17
C_x_PM_CLKBUF_X3%Z_c1 VSS x_PM_CLKBUF_X3%Z_11 6.53929e-18
C_x_PM_CLKBUF_X3%Z_c2 VSS N_Z_M1_d 3.78282e-17
C_x_PM_CLKBUF_X3%Z_c3 VSS x_PM_CLKBUF_X3%Z_7 6.53929e-18
C_x_PM_CLKBUF_X3%Z_c4 VSS N_Z_M3_d 3.93382e-17
R_x_PM_CLKBUF_X3%Z_r5 Z x_PM_CLKBUF_X3%Z_12 1.16714
R_x_PM_CLKBUF_X3%Z_r6 Z x_PM_CLKBUF_X3%Z_11 0.895714
R_x_PM_CLKBUF_X3%Z_r7 x_PM_CLKBUF_X3%Z_12 x_PM_CLKBUF_X3%Z_7 0.20978
R_x_PM_CLKBUF_X3%Z_r8 N_Z_M1_d x_PM_CLKBUF_X3%Z_7 0.686111
R_x_PM_CLKBUF_X3%Z_r9 x_PM_CLKBUF_X3%Z_11 x_PM_CLKBUF_X3%Z_3 0.20978
R_x_PM_CLKBUF_X3%Z_r10 N_Z_M3_d x_PM_CLKBUF_X3%Z_3 0.095
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X1.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X1 VSS VDD SE E CK GCK
*.PININFO VSS:B VDD:B SE:I E:I CK:I GCK:O
M_M12 13 N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.450000U L=0.050000U
M_M13 N_VDD_M1_d N_E_M1_g 13 VDD PMOS_VTL W=0.450000U L=0.050000U
M_M14 14 N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_7_M3_d N_6_M3_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 15 N_9_M4_g N_7_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_VDD_M5_d N_8_M5_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_6_M6_d N_9_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VDD_M7_d N_7_M7_g N_8_M7_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_9_M8_d N_CK_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_10_M9_d N_CK_M9_g N_VDD_M9_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_VDD_M10_d N_7_M10_g N_10_M9_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 N_GCK_M11_d N_10_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M0 N_3_M12_d N_SE_M12_g N_VSS_M12_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M13_d N_E_M13_g N_3_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 16 N_3_M14_g N_VSS_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M15_d N_9_M15_g 16 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 17 N_6_M16_g N_7_M15_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M17_d N_8_M17_g 17 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_6_M18_d N_9_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M19_d N_7_M19_g N_8_M19_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_9_M20_d N_CK_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 18 N_CK_M21_g N_10_M21_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M10 N_VSS_M22_d N_7_M22_g 18 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M11 N_GCK_M23_d N_10_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_CLKGATETST_X1%VSS_c0 VSS x_PM_CLKGATETST_X1%VSS_37 5.70612e-17
C_x_PM_CLKGATETST_X1%VSS_c1 VSS x_PM_CLKGATETST_X1%VSS_36 4.64667e-18
C_x_PM_CLKGATETST_X1%VSS_c2 VSS x_PM_CLKGATETST_X1%VSS_35 8.86015e-18
C_x_PM_CLKGATETST_X1%VSS_c3 VSS x_PM_CLKGATETST_X1%VSS_34 5.64357e-18
C_x_PM_CLKGATETST_X1%VSS_c4 VSS N_VSS_M22_d 2.52804e-17
C_x_PM_CLKGATETST_X1%VSS_c5 VSS x_PM_CLKGATETST_X1%VSS_26 8.30371e-17
C_x_PM_CLKGATETST_X1%VSS_c6 VSS N_VSS_M19_d 4.82152e-17
C_x_PM_CLKGATETST_X1%VSS_c7 VSS x_PM_CLKGATETST_X1%VSS_18 4.5177e-17
C_x_PM_CLKGATETST_X1%VSS_c8 VSS x_PM_CLKGATETST_X1%VSS_17 5.24597e-17
C_x_PM_CLKGATETST_X1%VSS_c9 VSS x_PM_CLKGATETST_X1%VSS_14 1.05848e-16
C_x_PM_CLKGATETST_X1%VSS_c10 VSS x_PM_CLKGATETST_X1%VSS_13 4.82997e-17
C_x_PM_CLKGATETST_X1%VSS_c11 VSS x_PM_CLKGATETST_X1%VSS_11 1.1006e-17
C_x_PM_CLKGATETST_X1%VSS_c12 VSS x_PM_CLKGATETST_X1%VSS_10 1.86746e-17
C_x_PM_CLKGATETST_X1%VSS_c13 VSS N_VSS_M12_s 1.59597e-17
R_x_PM_CLKGATETST_X1%VSS_r14 x_PM_CLKGATETST_X1%VSS_37 x_PM_CLKGATETST_X1%VSS_28 0.0680382
R_x_PM_CLKGATETST_X1%VSS_r15 N_VSS_M22_d x_PM_CLKGATETST_X1%VSS_28 0.330741
R_x_PM_CLKGATETST_X1%VSS_r16 x_PM_CLKGATETST_X1%VSS_36 x_PM_CLKGATETST_X1%VSS_27 0.0731438
R_x_PM_CLKGATETST_X1%VSS_r17 x_PM_CLKGATETST_X1%VSS_37 x_PM_CLKGATETST_X1%VSS_26 0.132285
R_x_PM_CLKGATETST_X1%VSS_r18 x_PM_CLKGATETST_X1%VSS_27 x_PM_CLKGATETST_X1%VSS_26 1.39706
R_x_PM_CLKGATETST_X1%VSS_r19 x_PM_CLKGATETST_X1%VSS_36 x_PM_CLKGATETST_X1%VSS_22 0.145286
R_x_PM_CLKGATETST_X1%VSS_r20 N_VSS_M19_d x_PM_CLKGATETST_X1%VSS_22 1.615
R_x_PM_CLKGATETST_X1%VSS_r21 x_PM_CLKGATETST_X1%VSS_35 x_PM_CLKGATETST_X1%VSS_19 0.132285
R_x_PM_CLKGATETST_X1%VSS_r22 VSS x_PM_CLKGATETST_X1%VSS_19 0.324118
R_x_PM_CLKGATETST_X1%VSS_r23 x_PM_CLKGATETST_X1%VSS_36 x_PM_CLKGATETST_X1%VSS_18 0.0731438
R_x_PM_CLKGATETST_X1%VSS_r24 VSS x_PM_CLKGATETST_X1%VSS_18 0.681765
R_x_PM_CLKGATETST_X1%VSS_r25 x_PM_CLKGATETST_X1%VSS_35 x_PM_CLKGATETST_X1%VSS_17 0.0680382
R_x_PM_CLKGATETST_X1%VSS_r26 x_PM_CLKGATETST_X1%VSS_17 N_VSS_M17_d 0.403583
R_x_PM_CLKGATETST_X1%VSS_r27 x_PM_CLKGATETST_X1%VSS_34 x_PM_CLKGATETST_X1%VSS_15 0.132285
R_x_PM_CLKGATETST_X1%VSS_r28 x_PM_CLKGATETST_X1%VSS_35 x_PM_CLKGATETST_X1%VSS_14 0.132285
R_x_PM_CLKGATETST_X1%VSS_r29 x_PM_CLKGATETST_X1%VSS_15 x_PM_CLKGATETST_X1%VSS_14 1.38588
R_x_PM_CLKGATETST_X1%VSS_r30 x_PM_CLKGATETST_X1%VSS_34 x_PM_CLKGATETST_X1%VSS_13 0.0680382
R_x_PM_CLKGATETST_X1%VSS_r31 x_PM_CLKGATETST_X1%VSS_13 N_VSS_M13_d 0.403583
R_x_PM_CLKGATETST_X1%VSS_r32 x_PM_CLKGATETST_X1%VSS_34 x_PM_CLKGATETST_X1%VSS_10 0.132285
R_x_PM_CLKGATETST_X1%VSS_r33 x_PM_CLKGATETST_X1%VSS_11 x_PM_CLKGATETST_X1%VSS_10 0.625882
R_x_PM_CLKGATETST_X1%VSS_r34 x_PM_CLKGATETST_X1%VSS_11 x_PM_CLKGATETST_X1%VSS_6 0.264221
R_x_PM_CLKGATETST_X1%VSS_r35 N_VSS_M12_s x_PM_CLKGATETST_X1%VSS_6 0.909286
C_x_PM_CLKGATETST_X1%VDD_c0 VSS x_PM_CLKGATETST_X1%VDD_38 4.14599e-17
C_x_PM_CLKGATETST_X1%VDD_c1 VSS x_PM_CLKGATETST_X1%VDD_37 8.86015e-18
C_x_PM_CLKGATETST_X1%VDD_c2 VSS x_PM_CLKGATETST_X1%VDD_36 8.85742e-18
C_x_PM_CLKGATETST_X1%VDD_c3 VSS N_VDD_M5_d 4.95269e-17
C_x_PM_CLKGATETST_X1%VDD_c4 VSS N_VDD_M1_d 2.35246e-17
C_x_PM_CLKGATETST_X1%VDD_c5 VSS x_PM_CLKGATETST_X1%VDD_23 2.77589e-17
C_x_PM_CLKGATETST_X1%VDD_c6 VSS x_PM_CLKGATETST_X1%VDD_20 2.25282e-17
C_x_PM_CLKGATETST_X1%VDD_c7 VSS x_PM_CLKGATETST_X1%VDD_19 1.50258e-17
C_x_PM_CLKGATETST_X1%VDD_c8 VSS x_PM_CLKGATETST_X1%VDD_16 1.78875e-17
C_x_PM_CLKGATETST_X1%VDD_c9 VSS x_PM_CLKGATETST_X1%VDD_15 1.6016e-17
C_x_PM_CLKGATETST_X1%VDD_c10 VSS x_PM_CLKGATETST_X1%VDD_12 4.08066e-17
C_x_PM_CLKGATETST_X1%VDD_c11 VSS x_PM_CLKGATETST_X1%VDD_10 1.23825e-16
C_x_PM_CLKGATETST_X1%VDD_c12 VSS x_PM_CLKGATETST_X1%VDD_6 3.70904e-17
R_x_PM_CLKGATETST_X1%VDD_r13 x_PM_CLKGATETST_X1%VDD_34 N_VDD_M5_d 0.443333
R_x_PM_CLKGATETST_X1%VDD_r14 x_PM_CLKGATETST_X1%VDD_29 N_VDD_M1_d 0.443333
R_x_PM_CLKGATETST_X1%VDD_r15 x_PM_CLKGATETST_X1%VDD_38 x_PM_CLKGATETST_X1%VDD_23 0.0680382
R_x_PM_CLKGATETST_X1%VDD_r16 x_PM_CLKGATETST_X1%VDD_23 N_VDD_M10_d 0.403583
R_x_PM_CLKGATETST_X1%VDD_r17 x_PM_CLKGATETST_X1%VDD_37 x_PM_CLKGATETST_X1%VDD_21 0.132285
R_x_PM_CLKGATETST_X1%VDD_r18 x_PM_CLKGATETST_X1%VDD_38 x_PM_CLKGATETST_X1%VDD_20 0.132285
R_x_PM_CLKGATETST_X1%VDD_r19 x_PM_CLKGATETST_X1%VDD_21 x_PM_CLKGATETST_X1%VDD_20 0.547647
R_x_PM_CLKGATETST_X1%VDD_r20 x_PM_CLKGATETST_X1%VDD_37 x_PM_CLKGATETST_X1%VDD_19 0.0680382
R_x_PM_CLKGATETST_X1%VDD_r21 x_PM_CLKGATETST_X1%VDD_19 N_VDD_M9_s 0.403583
R_x_PM_CLKGATETST_X1%VDD_r22 x_PM_CLKGATETST_X1%VDD_36 x_PM_CLKGATETST_X1%VDD_17 0.132285
R_x_PM_CLKGATETST_X1%VDD_r23 x_PM_CLKGATETST_X1%VDD_37 x_PM_CLKGATETST_X1%VDD_16 0.132285
R_x_PM_CLKGATETST_X1%VDD_r24 x_PM_CLKGATETST_X1%VDD_17 x_PM_CLKGATETST_X1%VDD_16 0.469412
R_x_PM_CLKGATETST_X1%VDD_r25 x_PM_CLKGATETST_X1%VDD_36 x_PM_CLKGATETST_X1%VDD_15 0.0680382
R_x_PM_CLKGATETST_X1%VDD_r26 x_PM_CLKGATETST_X1%VDD_15 N_VDD_M7_d 0.403583
R_x_PM_CLKGATETST_X1%VDD_r27 x_PM_CLKGATETST_X1%VDD_34 x_PM_CLKGATETST_X1%VDD_13 0.095
R_x_PM_CLKGATETST_X1%VDD_r28 x_PM_CLKGATETST_X1%VDD_36 x_PM_CLKGATETST_X1%VDD_12 0.132285
R_x_PM_CLKGATETST_X1%VDD_r29 x_PM_CLKGATETST_X1%VDD_13 x_PM_CLKGATETST_X1%VDD_12 0.938824
R_x_PM_CLKGATETST_X1%VDD_r30 x_PM_CLKGATETST_X1%VDD_29 x_PM_CLKGATETST_X1%VDD_11 0.095
R_x_PM_CLKGATETST_X1%VDD_r31 x_PM_CLKGATETST_X1%VDD_34 x_PM_CLKGATETST_X1%VDD_10 0.095
R_x_PM_CLKGATETST_X1%VDD_r32 x_PM_CLKGATETST_X1%VDD_11 x_PM_CLKGATETST_X1%VDD_10 1.39706
R_x_PM_CLKGATETST_X1%VDD_r33 x_PM_CLKGATETST_X1%VDD_29 x_PM_CLKGATETST_X1%VDD_6 0.095
R_x_PM_CLKGATETST_X1%VDD_r34 VDD x_PM_CLKGATETST_X1%VDD_6 0.430294
C_x_PM_CLKGATETST_X1%3_c0 VSS x_PM_CLKGATETST_X1%3_28 8.21298e-18
C_x_PM_CLKGATETST_X1%3_c1 VSS x_PM_CLKGATETST_X1%3_22 7.88889e-17
C_x_PM_CLKGATETST_X1%3_c2 VSS x_PM_CLKGATETST_X1%3_18 2.19169e-17
C_x_PM_CLKGATETST_X1%3_c3 VSS x_PM_CLKGATETST_X1%3_17 4.61938e-17
C_x_PM_CLKGATETST_X1%3_c4 VSS x_PM_CLKGATETST_X1%3_16 1.06587e-17
C_x_PM_CLKGATETST_X1%3_c5 VSS x_PM_CLKGATETST_X1%3_15 5.88283e-17
C_x_PM_CLKGATETST_X1%3_c6 VSS N_3_M0_s 1.83921e-17
C_x_PM_CLKGATETST_X1%3_c7 VSS N_3_M2_g 7.21452e-17
C_x_PM_CLKGATETST_X1%3_c8 VSS N_3_M14_g 2.49164e-17
R_x_PM_CLKGATETST_X1%3_r9 x_PM_CLKGATETST_X1%3_30 x_PM_CLKGATETST_X1%3_28 4.7687
R_x_PM_CLKGATETST_X1%3_r10 x_PM_CLKGATETST_X1%3_28 x_PM_CLKGATETST_X1%3_22 25.0012
R_x_PM_CLKGATETST_X1%3_r11 x_PM_CLKGATETST_X1%3_22 x_PM_CLKGATETST_X1%3_20 1.72357
R_x_PM_CLKGATETST_X1%3_r12 x_PM_CLKGATETST_X1%3_22 x_PM_CLKGATETST_X1%3_19 0.339286
R_x_PM_CLKGATETST_X1%3_r13 x_PM_CLKGATETST_X1%3_18 N_3_M12_d 0.297071
R_x_PM_CLKGATETST_X1%3_r14 x_PM_CLKGATETST_X1%3_19 x_PM_CLKGATETST_X1%3_17 0.212317
R_x_PM_CLKGATETST_X1%3_r15 x_PM_CLKGATETST_X1%3_18 x_PM_CLKGATETST_X1%3_17 0.922857
R_x_PM_CLKGATETST_X1%3_r16 x_PM_CLKGATETST_X1%3_20 x_PM_CLKGATETST_X1%3_15 0.212317
R_x_PM_CLKGATETST_X1%3_r17 x_PM_CLKGATETST_X1%3_16 x_PM_CLKGATETST_X1%3_15 2.11714
R_x_PM_CLKGATETST_X1%3_r18 x_PM_CLKGATETST_X1%3_16 x_PM_CLKGATETST_X1%3_11 0.212317
R_x_PM_CLKGATETST_X1%3_r19 N_3_M0_s x_PM_CLKGATETST_X1%3_11 0.746429
R_x_PM_CLKGATETST_X1%3_r20 N_3_M2_g x_PM_CLKGATETST_X1%3_30 97.5
R_x_PM_CLKGATETST_X1%3_r21 x_PM_CLKGATETST_X1%3_VSS x_PM_CLKGATETST_X1%3_28 4.7687
R_x_PM_CLKGATETST_X1%3_r22 N_3_M14_g x_PM_CLKGATETST_X1%3_VSS 21.84
C_x_PM_CLKGATETST_X1%SE_c0 VSS x_PM_CLKGATETST_X1%SE_18 1.10882e-17
C_x_PM_CLKGATETST_X1%SE_c1 VSS x_PM_CLKGATETST_X1%SE_9 4.61027e-17
C_x_PM_CLKGATETST_X1%SE_c2 VSS N_SE_M0_g 7.12763e-17
C_x_PM_CLKGATETST_X1%SE_c3 VSS N_SE_M12_g 3.96835e-17
R_x_PM_CLKGATETST_X1%SE_r4 x_PM_CLKGATETST_X1%SE_18 x_PM_CLKGATETST_X1%SE_11 5.46
R_x_PM_CLKGATETST_X1%SE_r5 x_PM_CLKGATETST_X1%SE_11 x_PM_CLKGATETST_X1%SE_9 25.0012
R_x_PM_CLKGATETST_X1%SE_r6 SE x_PM_CLKGATETST_X1%SE_9 0.105556
R_x_PM_CLKGATETST_X1%SE_r7 x_PM_CLKGATETST_X1%SE_18 x_PM_CLKGATETST_X1%SE_5 1.95
R_x_PM_CLKGATETST_X1%SE_r8 N_SE_M0_g x_PM_CLKGATETST_X1%SE_5 66.3
R_x_PM_CLKGATETST_X1%SE_r9 x_PM_CLKGATETST_X1%SE_18 x_PM_CLKGATETST_X1%SE_VSS 1.95
R_x_PM_CLKGATETST_X1%SE_r10 N_SE_M12_g x_PM_CLKGATETST_X1%SE_VSS 39
C_x_PM_CLKGATETST_X1%E_c0 VSS x_PM_CLKGATETST_X1%E_14 8.55427e-18
C_x_PM_CLKGATETST_X1%E_c1 VSS x_PM_CLKGATETST_X1%E_12 9.19488e-17
C_x_PM_CLKGATETST_X1%E_c2 VSS N_E_M1_g 7.06472e-17
C_x_PM_CLKGATETST_X1%E_c3 VSS N_E_M13_g 4.27274e-17
R_x_PM_CLKGATETST_X1%E_r4 x_PM_CLKGATETST_X1%E_18 x_PM_CLKGATETST_X1%E_14 4.7687
R_x_PM_CLKGATETST_X1%E_r5 x_PM_CLKGATETST_X1%E_17 x_PM_CLKGATETST_X1%E_14 4.7687
R_x_PM_CLKGATETST_X1%E_r6 x_PM_CLKGATETST_X1%E_14 x_PM_CLKGATETST_X1%E_12 25.0012
R_x_PM_CLKGATETST_X1%E_r7 x_PM_CLKGATETST_X1%E_12 E 0.2375
R_x_PM_CLKGATETST_X1%E_r8 N_E_M1_g x_PM_CLKGATETST_X1%E_18 66.3
R_x_PM_CLKGATETST_X1%E_r9 N_E_M13_g x_PM_CLKGATETST_X1%E_17 39
C_x_PM_CLKGATETST_X1%6_c0 VSS x_PM_CLKGATETST_X1%6_45 1.17494e-17
C_x_PM_CLKGATETST_X1%6_c1 VSS x_PM_CLKGATETST_X1%6_34 4.08429e-17
C_x_PM_CLKGATETST_X1%6_c2 VSS x_PM_CLKGATETST_X1%6_33 1.83689e-17
C_x_PM_CLKGATETST_X1%6_c3 VSS N_6_M6_d 6.66311e-17
C_x_PM_CLKGATETST_X1%6_c4 VSS x_PM_CLKGATETST_X1%6_27 5.34439e-17
C_x_PM_CLKGATETST_X1%6_c5 VSS x_PM_CLKGATETST_X1%6_25 1.47553e-17
C_x_PM_CLKGATETST_X1%6_c6 VSS x_PM_CLKGATETST_X1%6_23 2.9502e-17
C_x_PM_CLKGATETST_X1%6_c7 VSS x_PM_CLKGATETST_X1%6_21 1.53789e-17
C_x_PM_CLKGATETST_X1%6_c8 VSS x_PM_CLKGATETST_X1%6_19 2.80674e-17
C_x_PM_CLKGATETST_X1%6_c9 VSS x_PM_CLKGATETST_X1%6_18 6.60061e-17
C_x_PM_CLKGATETST_X1%6_c10 VSS x_PM_CLKGATETST_X1%6_17 2.8091e-17
C_x_PM_CLKGATETST_X1%6_c11 VSS x_PM_CLKGATETST_X1%6_16 8.58115e-17
C_x_PM_CLKGATETST_X1%6_c12 VSS x_PM_CLKGATETST_X1%6_13 2.14524e-16
C_x_PM_CLKGATETST_X1%6_c13 VSS N_6_M18_d 1.56074e-17
C_x_PM_CLKGATETST_X1%6_c14 VSS N_6_M16_g 2.59433e-17
C_x_PM_CLKGATETST_X1%6_c15 VSS N_6_M3_g 3.47849e-17
R_x_PM_CLKGATETST_X1%6_r16 x_PM_CLKGATETST_X1%6_36 x_PM_CLKGATETST_X1%6_34 0.57
R_x_PM_CLKGATETST_X1%6_r17 x_PM_CLKGATETST_X1%6_34 x_PM_CLKGATETST_X1%6_29 0.095
R_x_PM_CLKGATETST_X1%6_r18 N_6_M6_d x_PM_CLKGATETST_X1%6_29 1.75071
R_x_PM_CLKGATETST_X1%6_r19 x_PM_CLKGATETST_X1%6_33 x_PM_CLKGATETST_X1%6_28 0.0418175
R_x_PM_CLKGATETST_X1%6_r20 x_PM_CLKGATETST_X1%6_41 x_PM_CLKGATETST_X1%6_27 0.095
R_x_PM_CLKGATETST_X1%6_r21 x_PM_CLKGATETST_X1%6_28 x_PM_CLKGATETST_X1%6_27 1.92714
R_x_PM_CLKGATETST_X1%6_r22 x_PM_CLKGATETST_X1%6_25 x_PM_CLKGATETST_X1%6_47 4.42
R_x_PM_CLKGATETST_X1%6_r23 x_PM_CLKGATETST_X1%6_25 x_PM_CLKGATETST_X1%6_23 25.0012
R_x_PM_CLKGATETST_X1%6_r24 x_PM_CLKGATETST_X1%6_33 x_PM_CLKGATETST_X1%6_22 0.160909
R_x_PM_CLKGATETST_X1%6_r25 x_PM_CLKGATETST_X1%6_23 x_PM_CLKGATETST_X1%6_22 0.339286
R_x_PM_CLKGATETST_X1%6_r26 x_PM_CLKGATETST_X1%6_33 x_PM_CLKGATETST_X1%6_21 0.160909
R_x_PM_CLKGATETST_X1%6_r27 x_PM_CLKGATETST_X1%6_21 x_PM_CLKGATETST_X1%6_20 0.678571
R_x_PM_CLKGATETST_X1%6_r28 x_PM_CLKGATETST_X1%6_36 x_PM_CLKGATETST_X1%6_18 0.095
R_x_PM_CLKGATETST_X1%6_r29 x_PM_CLKGATETST_X1%6_19 x_PM_CLKGATETST_X1%6_18 1.46571
R_x_PM_CLKGATETST_X1%6_r30 x_PM_CLKGATETST_X1%6_20 x_PM_CLKGATETST_X1%6_16 0.212317
R_x_PM_CLKGATETST_X1%6_r31 x_PM_CLKGATETST_X1%6_17 x_PM_CLKGATETST_X1%6_16 1.08571
R_x_PM_CLKGATETST_X1%6_r32 x_PM_CLKGATETST_X1%6_45 x_PM_CLKGATETST_X1%6_15 3.38
R_x_PM_CLKGATETST_X1%6_r33 x_PM_CLKGATETST_X1%6_15 x_PM_CLKGATETST_X1%6_13 25.0012
R_x_PM_CLKGATETST_X1%6_r34 x_PM_CLKGATETST_X1%6_19 x_PM_CLKGATETST_X1%6_12 0.212317
R_x_PM_CLKGATETST_X1%6_r35 x_PM_CLKGATETST_X1%6_13 x_PM_CLKGATETST_X1%6_12 1.39786
R_x_PM_CLKGATETST_X1%6_r36 x_PM_CLKGATETST_X1%6_17 x_PM_CLKGATETST_X1%6_11 0.212317
R_x_PM_CLKGATETST_X1%6_r37 x_PM_CLKGATETST_X1%6_13 x_PM_CLKGATETST_X1%6_11 3.78643
R_x_PM_CLKGATETST_X1%6_r38 x_PM_CLKGATETST_X1%6_41 N_6_M18_d 0.176429
R_x_PM_CLKGATETST_X1%6_r39 x_PM_CLKGATETST_X1%6_47 x_PM_CLKGATETST_X1%6_5 1.95
R_x_PM_CLKGATETST_X1%6_r40 N_6_M16_g x_PM_CLKGATETST_X1%6_5 21.84
R_x_PM_CLKGATETST_X1%6_r41 x_PM_CLKGATETST_X1%6_45 x_PM_CLKGATETST_X1%6_VSS 1.95
R_x_PM_CLKGATETST_X1%6_r42 N_6_M3_g x_PM_CLKGATETST_X1%6_VSS 28.86
C_x_PM_CLKGATETST_X1%7_c0 VSS x_PM_CLKGATETST_X1%7_34 3.69347e-17
C_x_PM_CLKGATETST_X1%7_c1 VSS x_PM_CLKGATETST_X1%7_31 1.72433e-16
C_x_PM_CLKGATETST_X1%7_c2 VSS N_7_M3_d 6.96836e-17
C_x_PM_CLKGATETST_X1%7_c3 VSS N_7_M15_d 1.54673e-16
C_x_PM_CLKGATETST_X1%7_c4 VSS x_PM_CLKGATETST_X1%7_18 4.45394e-18
C_x_PM_CLKGATETST_X1%7_c5 VSS x_PM_CLKGATETST_X1%7_17 3.10589e-17
C_x_PM_CLKGATETST_X1%7_c6 VSS N_7_M22_g 1.24451e-16
C_x_PM_CLKGATETST_X1%7_c7 VSS x_PM_CLKGATETST_X1%7_10 6.93726e-18
C_x_PM_CLKGATETST_X1%7_c8 VSS x_PM_CLKGATETST_X1%7_9 7.6708e-17
C_x_PM_CLKGATETST_X1%7_c9 VSS N_7_M7_g 4.56152e-17
C_x_PM_CLKGATETST_X1%7_c10 VSS N_7_M19_g 5.66403e-17
R_x_PM_CLKGATETST_X1%7_r11 x_PM_CLKGATETST_X1%7_35 x_PM_CLKGATETST_X1%7_31 25.0012
R_x_PM_CLKGATETST_X1%7_r12 x_PM_CLKGATETST_X1%7_34 x_PM_CLKGATETST_X1%7_29 0.0272847
R_x_PM_CLKGATETST_X1%7_r13 x_PM_CLKGATETST_X1%7_31 x_PM_CLKGATETST_X1%7_29 1.62556
R_x_PM_CLKGATETST_X1%7_r14 x_PM_CLKGATETST_X1%7_34 x_PM_CLKGATETST_X1%7_25 0.266978
R_x_PM_CLKGATETST_X1%7_r15 N_7_M3_d x_PM_CLKGATETST_X1%7_25 0.855
R_x_PM_CLKGATETST_X1%7_r16 x_PM_CLKGATETST_X1%7_34 x_PM_CLKGATETST_X1%7_21 0.266978
R_x_PM_CLKGATETST_X1%7_r17 N_7_M15_d x_PM_CLKGATETST_X1%7_21 2.15786
R_x_PM_CLKGATETST_X1%7_r18 x_PM_CLKGATETST_X1%7_35 x_PM_CLKGATETST_X1%7_17 20.54
R_x_PM_CLKGATETST_X1%7_r19 x_PM_CLKGATETST_X1%7_18 x_PM_CLKGATETST_X1%7_17 0.043368
R_x_PM_CLKGATETST_X1%7_r20 N_7_M10_g N_7_M22_g 124.02
R_x_PM_CLKGATETST_X1%7_r21 N_7_M10_g x_PM_CLKGATETST_X1%7_11 40.56
R_x_PM_CLKGATETST_X1%7_r22 x_PM_CLKGATETST_X1%7_11 x_PM_CLKGATETST_X1%7_9 4.35808
R_x_PM_CLKGATETST_X1%7_r23 x_PM_CLKGATETST_X1%7_10 x_PM_CLKGATETST_X1%7_9 104.52
R_x_PM_CLKGATETST_X1%7_r24 x_PM_CLKGATETST_X1%7_10 x_PM_CLKGATETST_X1%7_6 4.35808
R_x_PM_CLKGATETST_X1%7_r25 N_7_M7_g x_PM_CLKGATETST_X1%7_6 40.56
R_x_PM_CLKGATETST_X1%7_r26 x_PM_CLKGATETST_X1%7_18 x_PM_CLKGATETST_X1%7_5 4.56151
R_x_PM_CLKGATETST_X1%7_r27 N_7_M7_g x_PM_CLKGATETST_X1%7_5 29.64
R_x_PM_CLKGATETST_X1%7_r28 x_PM_CLKGATETST_X1%7_18 x_PM_CLKGATETST_X1%7_VSS 4.56151
R_x_PM_CLKGATETST_X1%7_r29 N_7_M19_g x_PM_CLKGATETST_X1%7_VSS 54.6
C_x_PM_CLKGATETST_X1%8_c0 VSS x_PM_CLKGATETST_X1%8_24 4.75393e-18
C_x_PM_CLKGATETST_X1%8_c1 VSS N_8_M7_s 5.32584e-17
C_x_PM_CLKGATETST_X1%8_c2 VSS x_PM_CLKGATETST_X1%8_14 8.57903e-18
C_x_PM_CLKGATETST_X1%8_c3 VSS x_PM_CLKGATETST_X1%8_11 9.44439e-17
C_x_PM_CLKGATETST_X1%8_c4 VSS N_8_M19_s 2.06595e-17
C_x_PM_CLKGATETST_X1%8_c5 VSS N_8_M5_g 7.17832e-17
C_x_PM_CLKGATETST_X1%8_c6 VSS N_8_M17_g 4.93408e-17
R_x_PM_CLKGATETST_X1%8_r7 x_PM_CLKGATETST_X1%8_24 x_PM_CLKGATETST_X1%8_20 0.160909
R_x_PM_CLKGATETST_X1%8_r8 N_8_M7_s x_PM_CLKGATETST_X1%8_20 1.45214
R_x_PM_CLKGATETST_X1%8_r9 x_PM_CLKGATETST_X1%8_24 x_PM_CLKGATETST_X1%8_16 0.160909
R_x_PM_CLKGATETST_X1%8_r10 x_PM_CLKGATETST_X1%8_27 x_PM_CLKGATETST_X1%8_14 4.7687
R_x_PM_CLKGATETST_X1%8_r11 x_PM_CLKGATETST_X1%8_26 x_PM_CLKGATETST_X1%8_14 4.7687
R_x_PM_CLKGATETST_X1%8_r12 x_PM_CLKGATETST_X1%8_14 x_PM_CLKGATETST_X1%8_12 25.0012
R_x_PM_CLKGATETST_X1%8_r13 x_PM_CLKGATETST_X1%8_24 x_PM_CLKGATETST_X1%8_11 0.0418175
R_x_PM_CLKGATETST_X1%8_r14 x_PM_CLKGATETST_X1%8_12 x_PM_CLKGATETST_X1%8_11 2.26643
R_x_PM_CLKGATETST_X1%8_r15 N_8_M19_s x_PM_CLKGATETST_X1%8_16 0.692143
R_x_PM_CLKGATETST_X1%8_r16 N_8_M5_g x_PM_CLKGATETST_X1%8_27 71.76
R_x_PM_CLKGATETST_X1%8_r17 N_8_M17_g x_PM_CLKGATETST_X1%8_26 47.58
C_x_PM_CLKGATETST_X1%9_c0 VSS x_PM_CLKGATETST_X1%9_35 4.9621e-17
C_x_PM_CLKGATETST_X1%9_c1 VSS x_PM_CLKGATETST_X1%9_33 1.32987e-17
C_x_PM_CLKGATETST_X1%9_c2 VSS N_9_M20_d 9.81315e-17
C_x_PM_CLKGATETST_X1%9_c3 VSS x_PM_CLKGATETST_X1%9_21 3.01228e-18
C_x_PM_CLKGATETST_X1%9_c4 VSS x_PM_CLKGATETST_X1%9_19 7.30521e-17
C_x_PM_CLKGATETST_X1%9_c5 VSS N_9_M18_g 1.41583e-16
C_x_PM_CLKGATETST_X1%9_c6 VSS N_9_M4_g 7.98534e-17
C_x_PM_CLKGATETST_X1%9_c7 VSS x_PM_CLKGATETST_X1%9_8 6.03697e-18
C_x_PM_CLKGATETST_X1%9_c8 VSS x_PM_CLKGATETST_X1%9_7 2.29217e-17
C_x_PM_CLKGATETST_X1%9_c9 VSS x_PM_CLKGATETST_X1%9_6 6.31501e-18
C_x_PM_CLKGATETST_X1%9_c10 VSS x_PM_CLKGATETST_X1%9_5 5.92164e-17
C_x_PM_CLKGATETST_X1%9_c11 VSS N_9_M15_g 5.24694e-17
R_x_PM_CLKGATETST_X1%9_r12 x_PM_CLKGATETST_X1%9_33 x_PM_CLKGATETST_X1%9_31 25.0012
R_x_PM_CLKGATETST_X1%9_r13 x_PM_CLKGATETST_X1%9_35 x_PM_CLKGATETST_X1%9_31 0.0678571
R_x_PM_CLKGATETST_X1%9_r14 x_PM_CLKGATETST_X1%9_35 x_PM_CLKGATETST_X1%9_25 0.095
R_x_PM_CLKGATETST_X1%9_r15 N_9_M8_d N_9_M20_d 3.09429
R_x_PM_CLKGATETST_X1%9_r16 N_9_M20_d x_PM_CLKGATETST_X1%9_25 0.882143
R_x_PM_CLKGATETST_X1%9_r17 x_PM_CLKGATETST_X1%9_33 x_PM_CLKGATETST_X1%9_22 9.62
R_x_PM_CLKGATETST_X1%9_r18 x_PM_CLKGATETST_X1%9_21 x_PM_CLKGATETST_X1%9_20 3.30287
R_x_PM_CLKGATETST_X1%9_r19 x_PM_CLKGATETST_X1%9_22 x_PM_CLKGATETST_X1%9_19 4.58872
R_x_PM_CLKGATETST_X1%9_r20 x_PM_CLKGATETST_X1%9_20 x_PM_CLKGATETST_X1%9_19 88.92
R_x_PM_CLKGATETST_X1%9_r21 N_9_M6_g N_9_M18_g 131.04
R_x_PM_CLKGATETST_X1%9_r22 x_PM_CLKGATETST_X1%9_21 x_PM_CLKGATETST_X1%9_13 0.858359
R_x_PM_CLKGATETST_X1%9_r23 N_9_M18_g x_PM_CLKGATETST_X1%9_13 33.54
R_x_PM_CLKGATETST_X1%9_r24 N_9_M4_g x_PM_CLKGATETST_X1%9_9 78
R_x_PM_CLKGATETST_X1%9_r25 x_PM_CLKGATETST_X1%9_9 x_PM_CLKGATETST_X1%9_7 4.35808
R_x_PM_CLKGATETST_X1%9_r26 x_PM_CLKGATETST_X1%9_8 x_PM_CLKGATETST_X1%9_7 21.84
R_x_PM_CLKGATETST_X1%9_r27 x_PM_CLKGATETST_X1%9_21 x_PM_CLKGATETST_X1%9_5 3.30287
R_x_PM_CLKGATETST_X1%9_r28 x_PM_CLKGATETST_X1%9_6 x_PM_CLKGATETST_X1%9_5 81.12
R_x_PM_CLKGATETST_X1%9_r29 x_PM_CLKGATETST_X1%9_8 x_PM_CLKGATETST_X1%9_2 4.35808
R_x_PM_CLKGATETST_X1%9_r30 N_9_M15_g x_PM_CLKGATETST_X1%9_2 45.24
R_x_PM_CLKGATETST_X1%9_r31 x_PM_CLKGATETST_X1%9_6 x_PM_CLKGATETST_X1%9_VSS 4.35808
R_x_PM_CLKGATETST_X1%9_r32 N_9_M15_g x_PM_CLKGATETST_X1%9_VSS 33.54
C_x_PM_CLKGATETST_X1%10_c0 VSS x_PM_CLKGATETST_X1%10_21 9.52923e-18
C_x_PM_CLKGATETST_X1%10_c1 VSS x_PM_CLKGATETST_X1%10_18 2.78695e-17
C_x_PM_CLKGATETST_X1%10_c2 VSS x_PM_CLKGATETST_X1%10_17 5.12048e-17
C_x_PM_CLKGATETST_X1%10_c3 VSS x_PM_CLKGATETST_X1%10_14 4.93045e-17
C_x_PM_CLKGATETST_X1%10_c4 VSS x_PM_CLKGATETST_X1%10_12 6.40431e-17
C_x_PM_CLKGATETST_X1%10_c5 VSS N_10_M11_g 4.66759e-17
C_x_PM_CLKGATETST_X1%10_c6 VSS N_10_M23_g 7.27144e-17
R_x_PM_CLKGATETST_X1%10_r7 x_PM_CLKGATETST_X1%10_23 x_PM_CLKGATETST_X1%10_21 4.7687
R_x_PM_CLKGATETST_X1%10_r8 N_10_M9_d x_PM_CLKGATETST_X1%10_18 0.768647
R_x_PM_CLKGATETST_X1%10_r9 x_PM_CLKGATETST_X1%10_18 x_PM_CLKGATETST_X1%10_17 0.108091
R_x_PM_CLKGATETST_X1%10_r10 x_PM_CLKGATETST_X1%10_17 x_PM_CLKGATETST_X1%10_15 0.53025
R_x_PM_CLKGATETST_X1%10_r11 x_PM_CLKGATETST_X1%10_21 x_PM_CLKGATETST_X1%10_15 25.0012
R_x_PM_CLKGATETST_X1%10_r12 x_PM_CLKGATETST_X1%10_18 x_PM_CLKGATETST_X1%10_14 0.330235
R_x_PM_CLKGATETST_X1%10_r13 x_PM_CLKGATETST_X1%10_14 x_PM_CLKGATETST_X1%10_13 1.9
R_x_PM_CLKGATETST_X1%10_r14 x_PM_CLKGATETST_X1%10_13 x_PM_CLKGATETST_X1%10_12 0.241334
R_x_PM_CLKGATETST_X1%10_r15 x_PM_CLKGATETST_X1%10_12 N_10_M21_s 0.431731
R_x_PM_CLKGATETST_X1%10_r16 N_10_M11_g x_PM_CLKGATETST_X1%10_23 48.36
R_x_PM_CLKGATETST_X1%10_r17 x_PM_CLKGATETST_X1%10_VSS x_PM_CLKGATETST_X1%10_21 4.7687
R_x_PM_CLKGATETST_X1%10_r18 N_10_M23_g x_PM_CLKGATETST_X1%10_VSS 85.02
C_x_PM_CLKGATETST_X1%CK_c0 VSS x_PM_CLKGATETST_X1%CK_25 4.66706e-18
C_x_PM_CLKGATETST_X1%CK_c1 VSS x_PM_CLKGATETST_X1%CK_23 3.28163e-17
C_x_PM_CLKGATETST_X1%CK_c2 VSS x_PM_CLKGATETST_X1%CK_19 4.45394e-18
C_x_PM_CLKGATETST_X1%CK_c3 VSS N_CK_M9_g 6.02055e-17
C_x_PM_CLKGATETST_X1%CK_c4 VSS N_CK_M21_g 5.50475e-17
C_x_PM_CLKGATETST_X1%CK_c5 VSS x_PM_CLKGATETST_X1%CK_9 2.64361e-17
C_x_PM_CLKGATETST_X1%CK_c6 VSS N_CK_M8_g 6.47949e-17
C_x_PM_CLKGATETST_X1%CK_c7 VSS N_CK_M20_g 3.67833e-17
R_x_PM_CLKGATETST_X1%CK_r8 x_PM_CLKGATETST_X1%CK_25 x_PM_CLKGATETST_X1%CK_23 25.0012
R_x_PM_CLKGATETST_X1%CK_r9 x_PM_CLKGATETST_X1%CK_23 CK 0.0203571
R_x_PM_CLKGATETST_X1%CK_r10 x_PM_CLKGATETST_X1%CK_25 x_PM_CLKGATETST_X1%CK_15 4.56151
R_x_PM_CLKGATETST_X1%CK_r11 N_CK_M9_g x_PM_CLKGATETST_X1%CK_15 60.06
R_x_PM_CLKGATETST_X1%CK_r12 x_PM_CLKGATETST_X1%CK_25 x_PM_CLKGATETST_X1%CK_11 4.56151
R_x_PM_CLKGATETST_X1%CK_r13 N_CK_M21_g x_PM_CLKGATETST_X1%CK_11 52.26
R_x_PM_CLKGATETST_X1%CK_r14 x_PM_CLKGATETST_X1%CK_19 x_PM_CLKGATETST_X1%CK_10 0.043368
R_x_PM_CLKGATETST_X1%CK_r15 x_PM_CLKGATETST_X1%CK_25 x_PM_CLKGATETST_X1%CK_9 0.043368
R_x_PM_CLKGATETST_X1%CK_r16 x_PM_CLKGATETST_X1%CK_10 x_PM_CLKGATETST_X1%CK_9 30.16
R_x_PM_CLKGATETST_X1%CK_r17 x_PM_CLKGATETST_X1%CK_19 x_PM_CLKGATETST_X1%CK_5 4.56151
R_x_PM_CLKGATETST_X1%CK_r18 N_CK_M8_g x_PM_CLKGATETST_X1%CK_5 60.06
R_x_PM_CLKGATETST_X1%CK_r19 x_PM_CLKGATETST_X1%CK_19 x_PM_CLKGATETST_X1%CK_VSS 4.56151
R_x_PM_CLKGATETST_X1%CK_r20 N_CK_M20_g x_PM_CLKGATETST_X1%CK_VSS 24.18
C_x_PM_CLKGATETST_X1%GCK_c0 VSS N_GCK_M11_d 3.94874e-17
C_x_PM_CLKGATETST_X1%GCK_c1 VSS N_GCK_M23_d 6.00508e-17
C_x_PM_CLKGATETST_X1%GCK_c2 VSS GCK 8.12898e-17
R_x_PM_CLKGATETST_X1%GCK_r3 x_PM_CLKGATETST_X1%GCK_4 N_GCK_M11_d 0.189317
R_x_PM_CLKGATETST_X1%GCK_r4 GCK x_PM_CLKGATETST_X1%GCK_4 1.3775
R_x_PM_CLKGATETST_X1%GCK_r5 x_PM_CLKGATETST_X1%GCK_3 N_GCK_M23_d 0.189317
R_x_PM_CLKGATETST_X1%GCK_r6 GCK x_PM_CLKGATETST_X1%GCK_3 1.0925
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X2.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X2 VSS VDD SE E CK GCK
*.PININFO VSS:B VDD:B SE:I E:I CK:I GCK:O
M_M12 13 N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.450000U L=0.050000U
M_M13 N_VDD_M1_d N_E_M1_g 13 VDD PMOS_VTL W=0.450000U L=0.050000U
M_M14 14 N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_7_M3_d N_6_M3_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 15 N_9_M4_g N_7_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_VDD_M5_d N_8_M5_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_6_M6_d N_9_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VDD_M7_d N_7_M7_g N_8_M7_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_9_M8_d N_CK_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_10_M9_d N_CK_M9_g N_VDD_M9_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_VDD_M10_d N_7_M10_g N_10_M9_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 N_GCK_M11_d N_10_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M0 N_3_M12_d N_SE_M12_g N_VSS_M12_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M13_d N_E_M13_g N_3_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 16 N_3_M14_g N_VSS_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M15_d N_9_M15_g 16 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 17 N_6_M16_g N_7_M15_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M17_d N_8_M17_g 17 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_6_M18_d N_9_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M19_d N_7_M19_g N_8_M19_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_9_M20_d N_CK_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 18 N_CK_M21_g N_10_M21_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M10 N_VSS_M22_d N_7_M22_g 18 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M11 N_GCK_M23_d N_10_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_CLKGATETST_X2%VSS_c0 VSS N_VSS_M22_d 6.14438e-17
C_x_PM_CLKGATETST_X2%VSS_c1 VSS x_PM_CLKGATETST_X2%VSS_32 4.64667e-18
C_x_PM_CLKGATETST_X2%VSS_c2 VSS x_PM_CLKGATETST_X2%VSS_31 8.86015e-18
C_x_PM_CLKGATETST_X2%VSS_c3 VSS x_PM_CLKGATETST_X2%VSS_30 5.64357e-18
C_x_PM_CLKGATETST_X2%VSS_c4 VSS x_PM_CLKGATETST_X2%VSS_26 9.17723e-17
C_x_PM_CLKGATETST_X2%VSS_c5 VSS N_VSS_M19_d 5.09283e-17
C_x_PM_CLKGATETST_X2%VSS_c6 VSS x_PM_CLKGATETST_X2%VSS_18 4.58734e-17
C_x_PM_CLKGATETST_X2%VSS_c7 VSS x_PM_CLKGATETST_X2%VSS_17 5.17757e-17
C_x_PM_CLKGATETST_X2%VSS_c8 VSS x_PM_CLKGATETST_X2%VSS_14 1.06102e-16
C_x_PM_CLKGATETST_X2%VSS_c9 VSS x_PM_CLKGATETST_X2%VSS_13 4.90115e-17
C_x_PM_CLKGATETST_X2%VSS_c10 VSS x_PM_CLKGATETST_X2%VSS_11 1.1006e-17
C_x_PM_CLKGATETST_X2%VSS_c11 VSS x_PM_CLKGATETST_X2%VSS_10 1.86991e-17
C_x_PM_CLKGATETST_X2%VSS_c12 VSS N_VSS_M12_s 1.57531e-17
R_x_PM_CLKGATETST_X2%VSS_r13 x_PM_CLKGATETST_X2%VSS_32 x_PM_CLKGATETST_X2%VSS_27 0.0731438
R_x_PM_CLKGATETST_X2%VSS_r14 x_PM_CLKGATETST_X2%VSS_26 N_VSS_M22_d 0.140674
R_x_PM_CLKGATETST_X2%VSS_r15 x_PM_CLKGATETST_X2%VSS_27 x_PM_CLKGATETST_X2%VSS_26 1.37471
R_x_PM_CLKGATETST_X2%VSS_r16 x_PM_CLKGATETST_X2%VSS_32 x_PM_CLKGATETST_X2%VSS_22 0.145286
R_x_PM_CLKGATETST_X2%VSS_r17 N_VSS_M19_d x_PM_CLKGATETST_X2%VSS_22 1.615
R_x_PM_CLKGATETST_X2%VSS_r18 x_PM_CLKGATETST_X2%VSS_31 x_PM_CLKGATETST_X2%VSS_19 0.132285
R_x_PM_CLKGATETST_X2%VSS_r19 VSS x_PM_CLKGATETST_X2%VSS_19 0.324118
R_x_PM_CLKGATETST_X2%VSS_r20 x_PM_CLKGATETST_X2%VSS_32 x_PM_CLKGATETST_X2%VSS_18 0.0731438
R_x_PM_CLKGATETST_X2%VSS_r21 VSS x_PM_CLKGATETST_X2%VSS_18 0.692941
R_x_PM_CLKGATETST_X2%VSS_r22 x_PM_CLKGATETST_X2%VSS_31 x_PM_CLKGATETST_X2%VSS_17 0.0680382
R_x_PM_CLKGATETST_X2%VSS_r23 x_PM_CLKGATETST_X2%VSS_17 N_VSS_M17_d 0.403583
R_x_PM_CLKGATETST_X2%VSS_r24 x_PM_CLKGATETST_X2%VSS_30 x_PM_CLKGATETST_X2%VSS_15 0.132285
R_x_PM_CLKGATETST_X2%VSS_r25 x_PM_CLKGATETST_X2%VSS_31 x_PM_CLKGATETST_X2%VSS_14 0.132285
R_x_PM_CLKGATETST_X2%VSS_r26 x_PM_CLKGATETST_X2%VSS_15 x_PM_CLKGATETST_X2%VSS_14 1.38588
R_x_PM_CLKGATETST_X2%VSS_r27 x_PM_CLKGATETST_X2%VSS_30 x_PM_CLKGATETST_X2%VSS_13 0.0680382
R_x_PM_CLKGATETST_X2%VSS_r28 x_PM_CLKGATETST_X2%VSS_13 N_VSS_M13_d 0.403583
R_x_PM_CLKGATETST_X2%VSS_r29 x_PM_CLKGATETST_X2%VSS_30 x_PM_CLKGATETST_X2%VSS_10 0.132285
R_x_PM_CLKGATETST_X2%VSS_r30 x_PM_CLKGATETST_X2%VSS_11 x_PM_CLKGATETST_X2%VSS_10 0.625882
R_x_PM_CLKGATETST_X2%VSS_r31 x_PM_CLKGATETST_X2%VSS_11 x_PM_CLKGATETST_X2%VSS_6 0.264221
R_x_PM_CLKGATETST_X2%VSS_r32 N_VSS_M12_s x_PM_CLKGATETST_X2%VSS_6 0.909286
C_x_PM_CLKGATETST_X2%VDD_c0 VSS x_PM_CLKGATETST_X2%VDD_40 3.36022e-17
C_x_PM_CLKGATETST_X2%VDD_c1 VSS x_PM_CLKGATETST_X2%VDD_39 8.94814e-18
C_x_PM_CLKGATETST_X2%VDD_c2 VSS x_PM_CLKGATETST_X2%VDD_38 8.91086e-18
C_x_PM_CLKGATETST_X2%VDD_c3 VSS N_VDD_M5_d 4.95258e-17
C_x_PM_CLKGATETST_X2%VDD_c4 VSS x_PM_CLKGATETST_X2%VDD_32 5.72257e-18
C_x_PM_CLKGATETST_X2%VDD_c5 VSS x_PM_CLKGATETST_X2%VDD_29 1.82905e-17
C_x_PM_CLKGATETST_X2%VDD_c6 VSS x_PM_CLKGATETST_X2%VDD_26 2.25271e-17
C_x_PM_CLKGATETST_X2%VDD_c7 VSS N_VDD_M9_s 2.93912e-17
C_x_PM_CLKGATETST_X2%VDD_c8 VSS x_PM_CLKGATETST_X2%VDD_20 1.76901e-17
C_x_PM_CLKGATETST_X2%VDD_c9 VSS x_PM_CLKGATETST_X2%VDD_19 2.51588e-17
C_x_PM_CLKGATETST_X2%VDD_c10 VSS x_PM_CLKGATETST_X2%VDD_16 4.10963e-17
C_x_PM_CLKGATETST_X2%VDD_c11 VSS x_PM_CLKGATETST_X2%VDD_14 1.25566e-16
C_x_PM_CLKGATETST_X2%VDD_c12 VSS N_VDD_M1_d 4.19171e-17
C_x_PM_CLKGATETST_X2%VDD_c13 VSS x_PM_CLKGATETST_X2%VDD_6 3.70967e-17
R_x_PM_CLKGATETST_X2%VDD_r14 x_PM_CLKGATETST_X2%VDD_36 N_VDD_M5_d 0.443333
R_x_PM_CLKGATETST_X2%VDD_r15 x_PM_CLKGATETST_X2%VDD_40 x_PM_CLKGATETST_X2%VDD_29 0.0680382
R_x_PM_CLKGATETST_X2%VDD_r16 x_PM_CLKGATETST_X2%VDD_29 N_VDD_M10_d 0.403583
R_x_PM_CLKGATETST_X2%VDD_r17 x_PM_CLKGATETST_X2%VDD_39 x_PM_CLKGATETST_X2%VDD_27 0.132285
R_x_PM_CLKGATETST_X2%VDD_r18 x_PM_CLKGATETST_X2%VDD_40 x_PM_CLKGATETST_X2%VDD_26 0.132285
R_x_PM_CLKGATETST_X2%VDD_r19 x_PM_CLKGATETST_X2%VDD_27 x_PM_CLKGATETST_X2%VDD_26 0.547647
R_x_PM_CLKGATETST_X2%VDD_r20 x_PM_CLKGATETST_X2%VDD_39 x_PM_CLKGATETST_X2%VDD_22 0.0680382
R_x_PM_CLKGATETST_X2%VDD_r21 N_VDD_M9_s x_PM_CLKGATETST_X2%VDD_22 0.471481
R_x_PM_CLKGATETST_X2%VDD_r22 x_PM_CLKGATETST_X2%VDD_38 x_PM_CLKGATETST_X2%VDD_21 0.132285
R_x_PM_CLKGATETST_X2%VDD_r23 x_PM_CLKGATETST_X2%VDD_39 x_PM_CLKGATETST_X2%VDD_20 0.132285
R_x_PM_CLKGATETST_X2%VDD_r24 x_PM_CLKGATETST_X2%VDD_21 x_PM_CLKGATETST_X2%VDD_20 0.469412
R_x_PM_CLKGATETST_X2%VDD_r25 x_PM_CLKGATETST_X2%VDD_38 x_PM_CLKGATETST_X2%VDD_19 0.0680382
R_x_PM_CLKGATETST_X2%VDD_r26 x_PM_CLKGATETST_X2%VDD_19 N_VDD_M7_d 0.628768
R_x_PM_CLKGATETST_X2%VDD_r27 x_PM_CLKGATETST_X2%VDD_36 x_PM_CLKGATETST_X2%VDD_17 0.095
R_x_PM_CLKGATETST_X2%VDD_r28 x_PM_CLKGATETST_X2%VDD_38 x_PM_CLKGATETST_X2%VDD_16 0.132285
R_x_PM_CLKGATETST_X2%VDD_r29 x_PM_CLKGATETST_X2%VDD_17 x_PM_CLKGATETST_X2%VDD_16 0.938824
R_x_PM_CLKGATETST_X2%VDD_r30 x_PM_CLKGATETST_X2%VDD_32 x_PM_CLKGATETST_X2%VDD_15 0.132285
R_x_PM_CLKGATETST_X2%VDD_r31 x_PM_CLKGATETST_X2%VDD_36 x_PM_CLKGATETST_X2%VDD_14 0.095
R_x_PM_CLKGATETST_X2%VDD_r32 x_PM_CLKGATETST_X2%VDD_15 x_PM_CLKGATETST_X2%VDD_14 1.39706
R_x_PM_CLKGATETST_X2%VDD_r33 x_PM_CLKGATETST_X2%VDD_32 x_PM_CLKGATETST_X2%VDD_10 0.0680382
R_x_PM_CLKGATETST_X2%VDD_r34 N_VDD_M1_d x_PM_CLKGATETST_X2%VDD_10 0.204074
R_x_PM_CLKGATETST_X2%VDD_r35 x_PM_CLKGATETST_X2%VDD_32 x_PM_CLKGATETST_X2%VDD_6 0.132285
R_x_PM_CLKGATETST_X2%VDD_r36 VDD x_PM_CLKGATETST_X2%VDD_6 0.430294
C_x_PM_CLKGATETST_X2%3_c0 VSS x_PM_CLKGATETST_X2%3_28 8.14252e-18
C_x_PM_CLKGATETST_X2%3_c1 VSS x_PM_CLKGATETST_X2%3_22 7.30057e-17
C_x_PM_CLKGATETST_X2%3_c2 VSS x_PM_CLKGATETST_X2%3_18 2.18396e-17
C_x_PM_CLKGATETST_X2%3_c3 VSS x_PM_CLKGATETST_X2%3_17 4.53886e-17
C_x_PM_CLKGATETST_X2%3_c4 VSS x_PM_CLKGATETST_X2%3_16 9.66185e-18
C_x_PM_CLKGATETST_X2%3_c5 VSS x_PM_CLKGATETST_X2%3_15 5.89088e-17
C_x_PM_CLKGATETST_X2%3_c6 VSS N_3_M0_s 1.83618e-17
C_x_PM_CLKGATETST_X2%3_c7 VSS N_3_M2_g 7.94519e-17
C_x_PM_CLKGATETST_X2%3_c8 VSS N_3_M14_g 2.57513e-17
R_x_PM_CLKGATETST_X2%3_r9 x_PM_CLKGATETST_X2%3_30 x_PM_CLKGATETST_X2%3_28 4.7687
R_x_PM_CLKGATETST_X2%3_r10 x_PM_CLKGATETST_X2%3_28 x_PM_CLKGATETST_X2%3_22 25.0012
R_x_PM_CLKGATETST_X2%3_r11 x_PM_CLKGATETST_X2%3_22 x_PM_CLKGATETST_X2%3_20 1.72357
R_x_PM_CLKGATETST_X2%3_r12 x_PM_CLKGATETST_X2%3_22 x_PM_CLKGATETST_X2%3_19 0.339286
R_x_PM_CLKGATETST_X2%3_r13 x_PM_CLKGATETST_X2%3_18 N_3_M12_d 0.297071
R_x_PM_CLKGATETST_X2%3_r14 x_PM_CLKGATETST_X2%3_19 x_PM_CLKGATETST_X2%3_17 0.212317
R_x_PM_CLKGATETST_X2%3_r15 x_PM_CLKGATETST_X2%3_18 x_PM_CLKGATETST_X2%3_17 0.895714
R_x_PM_CLKGATETST_X2%3_r16 x_PM_CLKGATETST_X2%3_20 x_PM_CLKGATETST_X2%3_15 0.212317
R_x_PM_CLKGATETST_X2%3_r17 x_PM_CLKGATETST_X2%3_16 x_PM_CLKGATETST_X2%3_15 2.09
R_x_PM_CLKGATETST_X2%3_r18 x_PM_CLKGATETST_X2%3_16 x_PM_CLKGATETST_X2%3_11 0.212317
R_x_PM_CLKGATETST_X2%3_r19 N_3_M0_s x_PM_CLKGATETST_X2%3_11 0.746429
R_x_PM_CLKGATETST_X2%3_r20 N_3_M2_g x_PM_CLKGATETST_X2%3_30 97.5
R_x_PM_CLKGATETST_X2%3_r21 x_PM_CLKGATETST_X2%3_VSS x_PM_CLKGATETST_X2%3_28 4.7687
R_x_PM_CLKGATETST_X2%3_r22 N_3_M14_g x_PM_CLKGATETST_X2%3_VSS 21.84
C_x_PM_CLKGATETST_X2%SE_c0 VSS x_PM_CLKGATETST_X2%SE_14 7.30425e-18
C_x_PM_CLKGATETST_X2%SE_c1 VSS x_PM_CLKGATETST_X2%SE_12 4.53532e-17
C_x_PM_CLKGATETST_X2%SE_c2 VSS N_SE_M0_g 6.88803e-17
C_x_PM_CLKGATETST_X2%SE_c3 VSS N_SE_M12_g 4.22251e-17
R_x_PM_CLKGATETST_X2%SE_r4 x_PM_CLKGATETST_X2%SE_18 x_PM_CLKGATETST_X2%SE_14 4.74714
R_x_PM_CLKGATETST_X2%SE_r5 x_PM_CLKGATETST_X2%SE_17 x_PM_CLKGATETST_X2%SE_14 4.74714
R_x_PM_CLKGATETST_X2%SE_r6 x_PM_CLKGATETST_X2%SE_14 x_PM_CLKGATETST_X2%SE_12 25.0012
R_x_PM_CLKGATETST_X2%SE_r7 x_PM_CLKGATETST_X2%SE_12 SE 0.156071
R_x_PM_CLKGATETST_X2%SE_r8 N_SE_M0_g x_PM_CLKGATETST_X2%SE_18 60.84
R_x_PM_CLKGATETST_X2%SE_r9 N_SE_M12_g x_PM_CLKGATETST_X2%SE_17 44.46
C_x_PM_CLKGATETST_X2%E_c0 VSS x_PM_CLKGATETST_X2%E_14 8.55712e-18
C_x_PM_CLKGATETST_X2%E_c1 VSS x_PM_CLKGATETST_X2%E_12 7.70577e-17
C_x_PM_CLKGATETST_X2%E_c2 VSS N_E_M1_g 7.03237e-17
C_x_PM_CLKGATETST_X2%E_c3 VSS N_E_M13_g 4.2643e-17
R_x_PM_CLKGATETST_X2%E_r4 x_PM_CLKGATETST_X2%E_18 x_PM_CLKGATETST_X2%E_14 4.7687
R_x_PM_CLKGATETST_X2%E_r5 x_PM_CLKGATETST_X2%E_17 x_PM_CLKGATETST_X2%E_14 4.7687
R_x_PM_CLKGATETST_X2%E_r6 x_PM_CLKGATETST_X2%E_14 x_PM_CLKGATETST_X2%E_12 25.0012
R_x_PM_CLKGATETST_X2%E_r7 x_PM_CLKGATETST_X2%E_12 E 0.169643
R_x_PM_CLKGATETST_X2%E_r8 N_E_M1_g x_PM_CLKGATETST_X2%E_18 66.3
R_x_PM_CLKGATETST_X2%E_r9 N_E_M13_g x_PM_CLKGATETST_X2%E_17 39
C_x_PM_CLKGATETST_X2%6_c0 VSS x_PM_CLKGATETST_X2%6_45 1.2843e-17
C_x_PM_CLKGATETST_X2%6_c1 VSS x_PM_CLKGATETST_X2%6_34 3.81792e-17
C_x_PM_CLKGATETST_X2%6_c2 VSS x_PM_CLKGATETST_X2%6_33 1.84728e-17
C_x_PM_CLKGATETST_X2%6_c3 VSS N_6_M6_d 6.32467e-17
C_x_PM_CLKGATETST_X2%6_c4 VSS x_PM_CLKGATETST_X2%6_27 6.23369e-17
C_x_PM_CLKGATETST_X2%6_c5 VSS x_PM_CLKGATETST_X2%6_25 1.38053e-17
C_x_PM_CLKGATETST_X2%6_c6 VSS x_PM_CLKGATETST_X2%6_23 3.28104e-17
C_x_PM_CLKGATETST_X2%6_c7 VSS x_PM_CLKGATETST_X2%6_21 1.51172e-17
C_x_PM_CLKGATETST_X2%6_c8 VSS x_PM_CLKGATETST_X2%6_19 2.85644e-17
C_x_PM_CLKGATETST_X2%6_c9 VSS x_PM_CLKGATETST_X2%6_18 6.70913e-17
C_x_PM_CLKGATETST_X2%6_c10 VSS x_PM_CLKGATETST_X2%6_17 2.77171e-17
C_x_PM_CLKGATETST_X2%6_c11 VSS x_PM_CLKGATETST_X2%6_16 8.62619e-17
C_x_PM_CLKGATETST_X2%6_c12 VSS x_PM_CLKGATETST_X2%6_13 2.21075e-16
C_x_PM_CLKGATETST_X2%6_c13 VSS N_6_M18_d 1.78047e-17
C_x_PM_CLKGATETST_X2%6_c14 VSS N_6_M16_g 2.59109e-17
C_x_PM_CLKGATETST_X2%6_c15 VSS N_6_M3_g 3.48596e-17
R_x_PM_CLKGATETST_X2%6_r16 x_PM_CLKGATETST_X2%6_36 x_PM_CLKGATETST_X2%6_34 0.57
R_x_PM_CLKGATETST_X2%6_r17 x_PM_CLKGATETST_X2%6_34 x_PM_CLKGATETST_X2%6_29 0.095
R_x_PM_CLKGATETST_X2%6_r18 N_6_M6_d x_PM_CLKGATETST_X2%6_29 1.75071
R_x_PM_CLKGATETST_X2%6_r19 x_PM_CLKGATETST_X2%6_33 x_PM_CLKGATETST_X2%6_28 0.0418175
R_x_PM_CLKGATETST_X2%6_r20 x_PM_CLKGATETST_X2%6_41 x_PM_CLKGATETST_X2%6_27 0.095
R_x_PM_CLKGATETST_X2%6_r21 x_PM_CLKGATETST_X2%6_28 x_PM_CLKGATETST_X2%6_27 1.98143
R_x_PM_CLKGATETST_X2%6_r22 x_PM_CLKGATETST_X2%6_25 x_PM_CLKGATETST_X2%6_47 3.38
R_x_PM_CLKGATETST_X2%6_r23 x_PM_CLKGATETST_X2%6_25 x_PM_CLKGATETST_X2%6_23 25.0012
R_x_PM_CLKGATETST_X2%6_r24 x_PM_CLKGATETST_X2%6_33 x_PM_CLKGATETST_X2%6_22 0.160909
R_x_PM_CLKGATETST_X2%6_r25 x_PM_CLKGATETST_X2%6_23 x_PM_CLKGATETST_X2%6_22 0.339286
R_x_PM_CLKGATETST_X2%6_r26 x_PM_CLKGATETST_X2%6_33 x_PM_CLKGATETST_X2%6_21 0.160909
R_x_PM_CLKGATETST_X2%6_r27 x_PM_CLKGATETST_X2%6_21 x_PM_CLKGATETST_X2%6_20 0.678571
R_x_PM_CLKGATETST_X2%6_r28 x_PM_CLKGATETST_X2%6_36 x_PM_CLKGATETST_X2%6_18 0.095
R_x_PM_CLKGATETST_X2%6_r29 x_PM_CLKGATETST_X2%6_19 x_PM_CLKGATETST_X2%6_18 1.52
R_x_PM_CLKGATETST_X2%6_r30 x_PM_CLKGATETST_X2%6_20 x_PM_CLKGATETST_X2%6_16 0.212317
R_x_PM_CLKGATETST_X2%6_r31 x_PM_CLKGATETST_X2%6_17 x_PM_CLKGATETST_X2%6_16 1.08571
R_x_PM_CLKGATETST_X2%6_r32 x_PM_CLKGATETST_X2%6_45 x_PM_CLKGATETST_X2%6_15 4.42
R_x_PM_CLKGATETST_X2%6_r33 x_PM_CLKGATETST_X2%6_15 x_PM_CLKGATETST_X2%6_13 25.0012
R_x_PM_CLKGATETST_X2%6_r34 x_PM_CLKGATETST_X2%6_19 x_PM_CLKGATETST_X2%6_12 0.212317
R_x_PM_CLKGATETST_X2%6_r35 x_PM_CLKGATETST_X2%6_13 x_PM_CLKGATETST_X2%6_12 1.39786
R_x_PM_CLKGATETST_X2%6_r36 x_PM_CLKGATETST_X2%6_17 x_PM_CLKGATETST_X2%6_11 0.212317
R_x_PM_CLKGATETST_X2%6_r37 x_PM_CLKGATETST_X2%6_13 x_PM_CLKGATETST_X2%6_11 3.78643
R_x_PM_CLKGATETST_X2%6_r38 x_PM_CLKGATETST_X2%6_41 N_6_M18_d 0.176429
R_x_PM_CLKGATETST_X2%6_r39 x_PM_CLKGATETST_X2%6_47 x_PM_CLKGATETST_X2%6_5 1.95
R_x_PM_CLKGATETST_X2%6_r40 N_6_M16_g x_PM_CLKGATETST_X2%6_5 21.84
R_x_PM_CLKGATETST_X2%6_r41 x_PM_CLKGATETST_X2%6_45 x_PM_CLKGATETST_X2%6_VSS 1.95
R_x_PM_CLKGATETST_X2%6_r42 N_6_M3_g x_PM_CLKGATETST_X2%6_VSS 28.86
C_x_PM_CLKGATETST_X2%7_c0 VSS x_PM_CLKGATETST_X2%7_34 3.69673e-17
C_x_PM_CLKGATETST_X2%7_c1 VSS x_PM_CLKGATETST_X2%7_31 1.75787e-16
C_x_PM_CLKGATETST_X2%7_c2 VSS N_7_M3_d 8.48256e-17
C_x_PM_CLKGATETST_X2%7_c3 VSS N_7_M15_d 1.38657e-16
C_x_PM_CLKGATETST_X2%7_c4 VSS x_PM_CLKGATETST_X2%7_18 4.45394e-18
C_x_PM_CLKGATETST_X2%7_c5 VSS x_PM_CLKGATETST_X2%7_17 3.15091e-17
C_x_PM_CLKGATETST_X2%7_c6 VSS N_7_M22_g 1.31878e-16
C_x_PM_CLKGATETST_X2%7_c7 VSS x_PM_CLKGATETST_X2%7_10 6.89292e-18
C_x_PM_CLKGATETST_X2%7_c8 VSS x_PM_CLKGATETST_X2%7_9 7.58114e-17
C_x_PM_CLKGATETST_X2%7_c9 VSS N_7_M7_g 5.71388e-17
C_x_PM_CLKGATETST_X2%7_c10 VSS N_7_M19_g 4.78983e-17
R_x_PM_CLKGATETST_X2%7_r11 x_PM_CLKGATETST_X2%7_35 x_PM_CLKGATETST_X2%7_31 25.0012
R_x_PM_CLKGATETST_X2%7_r12 x_PM_CLKGATETST_X2%7_34 x_PM_CLKGATETST_X2%7_29 0.0272847
R_x_PM_CLKGATETST_X2%7_r13 x_PM_CLKGATETST_X2%7_31 x_PM_CLKGATETST_X2%7_29 1.63963
R_x_PM_CLKGATETST_X2%7_r14 x_PM_CLKGATETST_X2%7_34 x_PM_CLKGATETST_X2%7_25 0.266978
R_x_PM_CLKGATETST_X2%7_r15 N_7_M3_d x_PM_CLKGATETST_X2%7_25 1.26214
R_x_PM_CLKGATETST_X2%7_r16 x_PM_CLKGATETST_X2%7_34 x_PM_CLKGATETST_X2%7_21 0.266978
R_x_PM_CLKGATETST_X2%7_r17 N_7_M15_d x_PM_CLKGATETST_X2%7_21 1.75071
R_x_PM_CLKGATETST_X2%7_r18 x_PM_CLKGATETST_X2%7_35 x_PM_CLKGATETST_X2%7_17 21.06
R_x_PM_CLKGATETST_X2%7_r19 x_PM_CLKGATETST_X2%7_18 x_PM_CLKGATETST_X2%7_17 0.043368
R_x_PM_CLKGATETST_X2%7_r20 N_7_M10_g N_7_M22_g 135.72
R_x_PM_CLKGATETST_X2%7_r21 N_7_M10_g x_PM_CLKGATETST_X2%7_11 40.56
R_x_PM_CLKGATETST_X2%7_r22 x_PM_CLKGATETST_X2%7_11 x_PM_CLKGATETST_X2%7_9 4.35808
R_x_PM_CLKGATETST_X2%7_r23 x_PM_CLKGATETST_X2%7_10 x_PM_CLKGATETST_X2%7_9 104.52
R_x_PM_CLKGATETST_X2%7_r24 x_PM_CLKGATETST_X2%7_10 x_PM_CLKGATETST_X2%7_6 4.35808
R_x_PM_CLKGATETST_X2%7_r25 N_7_M7_g x_PM_CLKGATETST_X2%7_6 53.04
R_x_PM_CLKGATETST_X2%7_r26 x_PM_CLKGATETST_X2%7_18 x_PM_CLKGATETST_X2%7_5 4.56151
R_x_PM_CLKGATETST_X2%7_r27 N_7_M7_g x_PM_CLKGATETST_X2%7_5 28.86
R_x_PM_CLKGATETST_X2%7_r28 x_PM_CLKGATETST_X2%7_18 x_PM_CLKGATETST_X2%7_VSS 4.56151
R_x_PM_CLKGATETST_X2%7_r29 N_7_M19_g x_PM_CLKGATETST_X2%7_VSS 42.9
C_x_PM_CLKGATETST_X2%8_c0 VSS x_PM_CLKGATETST_X2%8_24 4.69746e-18
C_x_PM_CLKGATETST_X2%8_c1 VSS N_8_M7_s 6.84022e-17
C_x_PM_CLKGATETST_X2%8_c2 VSS x_PM_CLKGATETST_X2%8_14 8.40077e-18
C_x_PM_CLKGATETST_X2%8_c3 VSS x_PM_CLKGATETST_X2%8_11 1.10654e-16
C_x_PM_CLKGATETST_X2%8_c4 VSS N_8_M19_s 1.4596e-17
C_x_PM_CLKGATETST_X2%8_c5 VSS N_8_M5_g 7.83338e-17
C_x_PM_CLKGATETST_X2%8_c6 VSS N_8_M17_g 4.21532e-17
R_x_PM_CLKGATETST_X2%8_r7 x_PM_CLKGATETST_X2%8_24 x_PM_CLKGATETST_X2%8_20 0.160909
R_x_PM_CLKGATETST_X2%8_r8 N_8_M7_s x_PM_CLKGATETST_X2%8_20 2.15786
R_x_PM_CLKGATETST_X2%8_r9 x_PM_CLKGATETST_X2%8_24 x_PM_CLKGATETST_X2%8_16 0.160909
R_x_PM_CLKGATETST_X2%8_r10 x_PM_CLKGATETST_X2%8_27 x_PM_CLKGATETST_X2%8_14 4.7687
R_x_PM_CLKGATETST_X2%8_r11 x_PM_CLKGATETST_X2%8_26 x_PM_CLKGATETST_X2%8_14 4.7687
R_x_PM_CLKGATETST_X2%8_r12 x_PM_CLKGATETST_X2%8_14 x_PM_CLKGATETST_X2%8_12 25.0012
R_x_PM_CLKGATETST_X2%8_r13 x_PM_CLKGATETST_X2%8_24 x_PM_CLKGATETST_X2%8_11 0.0418175
R_x_PM_CLKGATETST_X2%8_r14 x_PM_CLKGATETST_X2%8_12 x_PM_CLKGATETST_X2%8_11 2.23929
R_x_PM_CLKGATETST_X2%8_r15 N_8_M19_s x_PM_CLKGATETST_X2%8_16 0.312143
R_x_PM_CLKGATETST_X2%8_r16 N_8_M5_g x_PM_CLKGATETST_X2%8_27 82.68
R_x_PM_CLKGATETST_X2%8_r17 N_8_M17_g x_PM_CLKGATETST_X2%8_26 36.66
C_x_PM_CLKGATETST_X2%9_c0 VSS x_PM_CLKGATETST_X2%9_35 5.79404e-17
C_x_PM_CLKGATETST_X2%9_c1 VSS x_PM_CLKGATETST_X2%9_33 1.34223e-17
C_x_PM_CLKGATETST_X2%9_c2 VSS N_9_M20_d 9.38448e-17
C_x_PM_CLKGATETST_X2%9_c3 VSS x_PM_CLKGATETST_X2%9_21 3.01228e-18
C_x_PM_CLKGATETST_X2%9_c4 VSS x_PM_CLKGATETST_X2%9_19 7.48332e-17
C_x_PM_CLKGATETST_X2%9_c5 VSS N_9_M18_g 1.42919e-16
C_x_PM_CLKGATETST_X2%9_c6 VSS N_9_M4_g 7.95873e-17
C_x_PM_CLKGATETST_X2%9_c7 VSS x_PM_CLKGATETST_X2%9_8 6.22395e-18
C_x_PM_CLKGATETST_X2%9_c8 VSS x_PM_CLKGATETST_X2%9_7 2.34672e-17
C_x_PM_CLKGATETST_X2%9_c9 VSS x_PM_CLKGATETST_X2%9_6 6.31501e-18
C_x_PM_CLKGATETST_X2%9_c10 VSS x_PM_CLKGATETST_X2%9_5 5.92823e-17
C_x_PM_CLKGATETST_X2%9_c11 VSS N_9_M15_g 5.29598e-17
R_x_PM_CLKGATETST_X2%9_r12 x_PM_CLKGATETST_X2%9_33 x_PM_CLKGATETST_X2%9_31 25.0012
R_x_PM_CLKGATETST_X2%9_r13 x_PM_CLKGATETST_X2%9_35 x_PM_CLKGATETST_X2%9_31 0.095
R_x_PM_CLKGATETST_X2%9_r14 x_PM_CLKGATETST_X2%9_35 x_PM_CLKGATETST_X2%9_25 0.095
R_x_PM_CLKGATETST_X2%9_r15 N_9_M8_d N_9_M20_d 2.66
R_x_PM_CLKGATETST_X2%9_r16 N_9_M20_d x_PM_CLKGATETST_X2%9_25 0.882143
R_x_PM_CLKGATETST_X2%9_r17 x_PM_CLKGATETST_X2%9_33 x_PM_CLKGATETST_X2%9_22 9.62
R_x_PM_CLKGATETST_X2%9_r18 x_PM_CLKGATETST_X2%9_21 x_PM_CLKGATETST_X2%9_20 3.30287
R_x_PM_CLKGATETST_X2%9_r19 x_PM_CLKGATETST_X2%9_22 x_PM_CLKGATETST_X2%9_19 4.58872
R_x_PM_CLKGATETST_X2%9_r20 x_PM_CLKGATETST_X2%9_20 x_PM_CLKGATETST_X2%9_19 88.14
R_x_PM_CLKGATETST_X2%9_r21 N_9_M6_g N_9_M18_g 131.04
R_x_PM_CLKGATETST_X2%9_r22 x_PM_CLKGATETST_X2%9_21 x_PM_CLKGATETST_X2%9_13 0.858359
R_x_PM_CLKGATETST_X2%9_r23 N_9_M18_g x_PM_CLKGATETST_X2%9_13 33.54
R_x_PM_CLKGATETST_X2%9_r24 N_9_M4_g x_PM_CLKGATETST_X2%9_9 78
R_x_PM_CLKGATETST_X2%9_r25 x_PM_CLKGATETST_X2%9_9 x_PM_CLKGATETST_X2%9_7 4.35808
R_x_PM_CLKGATETST_X2%9_r26 x_PM_CLKGATETST_X2%9_8 x_PM_CLKGATETST_X2%9_7 21.84
R_x_PM_CLKGATETST_X2%9_r27 x_PM_CLKGATETST_X2%9_21 x_PM_CLKGATETST_X2%9_5 3.30287
R_x_PM_CLKGATETST_X2%9_r28 x_PM_CLKGATETST_X2%9_6 x_PM_CLKGATETST_X2%9_5 81.12
R_x_PM_CLKGATETST_X2%9_r29 x_PM_CLKGATETST_X2%9_8 x_PM_CLKGATETST_X2%9_2 4.35808
R_x_PM_CLKGATETST_X2%9_r30 N_9_M15_g x_PM_CLKGATETST_X2%9_2 45.24
R_x_PM_CLKGATETST_X2%9_r31 x_PM_CLKGATETST_X2%9_6 x_PM_CLKGATETST_X2%9_VSS 4.35808
R_x_PM_CLKGATETST_X2%9_r32 N_9_M15_g x_PM_CLKGATETST_X2%9_VSS 33.54
C_x_PM_CLKGATETST_X2%10_c0 VSS x_PM_CLKGATETST_X2%10_30 1.51491e-17
C_x_PM_CLKGATETST_X2%10_c1 VSS x_PM_CLKGATETST_X2%10_25 4.27048e-17
C_x_PM_CLKGATETST_X2%10_c2 VSS N_10_M9_d 2.11775e-17
C_x_PM_CLKGATETST_X2%10_c3 VSS x_PM_CLKGATETST_X2%10_18 6.51622e-17
C_x_PM_CLKGATETST_X2%10_c4 VSS x_PM_CLKGATETST_X2%10_16 1.45997e-17
C_x_PM_CLKGATETST_X2%10_c5 VSS x_PM_CLKGATETST_X2%10_15 1.5047e-17
C_x_PM_CLKGATETST_X2%10_c6 VSS N_10_M21_s 3.75673e-17
C_x_PM_CLKGATETST_X2%10_c7 VSS N_10_M11_g 9.46041e-17
C_x_PM_CLKGATETST_X2%10_c8 VSS N_10_M23_g 3.19724e-17
R_x_PM_CLKGATETST_X2%10_r9 x_PM_CLKGATETST_X2%10_30 x_PM_CLKGATETST_X2%10_28 5.46
R_x_PM_CLKGATETST_X2%10_r10 x_PM_CLKGATETST_X2%10_28 x_PM_CLKGATETST_X2%10_25 25.0012
R_x_PM_CLKGATETST_X2%10_r11 x_PM_CLKGATETST_X2%10_25 x_PM_CLKGATETST_X2%10_23 1.12643
R_x_PM_CLKGATETST_X2%10_r12 x_PM_CLKGATETST_X2%10_18 N_10_M9_d 0.30478
R_x_PM_CLKGATETST_X2%10_r13 x_PM_CLKGATETST_X2%10_23 x_PM_CLKGATETST_X2%10_17 0.095
R_x_PM_CLKGATETST_X2%10_r14 x_PM_CLKGATETST_X2%10_18 x_PM_CLKGATETST_X2%10_17 2.68714
R_x_PM_CLKGATETST_X2%10_r15 x_PM_CLKGATETST_X2%10_23 x_PM_CLKGATETST_X2%10_15 0.19
R_x_PM_CLKGATETST_X2%10_r16 x_PM_CLKGATETST_X2%10_16 x_PM_CLKGATETST_X2%10_15 0.76
R_x_PM_CLKGATETST_X2%10_r17 x_PM_CLKGATETST_X2%10_16 x_PM_CLKGATETST_X2%10_11 0.212317
R_x_PM_CLKGATETST_X2%10_r18 N_10_M21_s x_PM_CLKGATETST_X2%10_11 0.475
R_x_PM_CLKGATETST_X2%10_r19 x_PM_CLKGATETST_X2%10_30 x_PM_CLKGATETST_X2%10_5 1.95
R_x_PM_CLKGATETST_X2%10_r20 N_10_M11_g x_PM_CLKGATETST_X2%10_5 109.2
R_x_PM_CLKGATETST_X2%10_r21 x_PM_CLKGATETST_X2%10_30 x_PM_CLKGATETST_X2%10_VSS 1.95
R_x_PM_CLKGATETST_X2%10_r22 N_10_M23_g x_PM_CLKGATETST_X2%10_VSS 21.84
C_x_PM_CLKGATETST_X2%CK_c0 VSS x_PM_CLKGATETST_X2%CK_25 4.66706e-18
C_x_PM_CLKGATETST_X2%CK_c1 VSS x_PM_CLKGATETST_X2%CK_23 3.3419e-17
C_x_PM_CLKGATETST_X2%CK_c2 VSS x_PM_CLKGATETST_X2%CK_19 4.44968e-18
C_x_PM_CLKGATETST_X2%CK_c3 VSS N_CK_M9_g 6.23955e-17
C_x_PM_CLKGATETST_X2%CK_c4 VSS N_CK_M21_g 6.20543e-17
C_x_PM_CLKGATETST_X2%CK_c5 VSS x_PM_CLKGATETST_X2%CK_9 2.68872e-17
C_x_PM_CLKGATETST_X2%CK_c6 VSS N_CK_M8_g 5.58697e-17
C_x_PM_CLKGATETST_X2%CK_c7 VSS N_CK_M20_g 3.70501e-17
R_x_PM_CLKGATETST_X2%CK_r8 x_PM_CLKGATETST_X2%CK_25 x_PM_CLKGATETST_X2%CK_23 25.0012
R_x_PM_CLKGATETST_X2%CK_r9 x_PM_CLKGATETST_X2%CK_23 CK 0.0203571
R_x_PM_CLKGATETST_X2%CK_r10 x_PM_CLKGATETST_X2%CK_25 x_PM_CLKGATETST_X2%CK_15 4.56151
R_x_PM_CLKGATETST_X2%CK_r11 N_CK_M9_g x_PM_CLKGATETST_X2%CK_15 60.06
R_x_PM_CLKGATETST_X2%CK_r12 x_PM_CLKGATETST_X2%CK_25 x_PM_CLKGATETST_X2%CK_11 4.56151
R_x_PM_CLKGATETST_X2%CK_r13 N_CK_M21_g x_PM_CLKGATETST_X2%CK_11 63.96
R_x_PM_CLKGATETST_X2%CK_r14 x_PM_CLKGATETST_X2%CK_19 x_PM_CLKGATETST_X2%CK_10 0.043368
R_x_PM_CLKGATETST_X2%CK_r15 x_PM_CLKGATETST_X2%CK_25 x_PM_CLKGATETST_X2%CK_9 0.043368
R_x_PM_CLKGATETST_X2%CK_r16 x_PM_CLKGATETST_X2%CK_10 x_PM_CLKGATETST_X2%CK_9 30.16
R_x_PM_CLKGATETST_X2%CK_r17 x_PM_CLKGATETST_X2%CK_19 x_PM_CLKGATETST_X2%CK_5 4.56151
R_x_PM_CLKGATETST_X2%CK_r18 N_CK_M8_g x_PM_CLKGATETST_X2%CK_5 47.58
R_x_PM_CLKGATETST_X2%CK_r19 x_PM_CLKGATETST_X2%CK_19 x_PM_CLKGATETST_X2%CK_VSS 4.56151
R_x_PM_CLKGATETST_X2%CK_r20 N_CK_M20_g x_PM_CLKGATETST_X2%CK_VSS 24.18
C_x_PM_CLKGATETST_X2%GCK_c0 VSS x_PM_CLKGATETST_X2%GCK_15 2.97081e-17
C_x_PM_CLKGATETST_X2%GCK_c1 VSS N_GCK_M23_d 5.19196e-17
C_x_PM_CLKGATETST_X2%GCK_c2 VSS N_GCK_M11_d 3.69622e-17
R_x_PM_CLKGATETST_X2%GCK_r3 x_PM_CLKGATETST_X2%GCK_15 x_PM_CLKGATETST_X2%GCK_14 0.0271429
R_x_PM_CLKGATETST_X2%GCK_r4 x_PM_CLKGATETST_X2%GCK_14 GCK 0.339286
R_x_PM_CLKGATETST_X2%GCK_r5 x_PM_CLKGATETST_X2%GCK_15 x_PM_CLKGATETST_X2%GCK_7 0.095
R_x_PM_CLKGATETST_X2%GCK_r6 N_GCK_M23_d x_PM_CLKGATETST_X2%GCK_7 1.77786
R_x_PM_CLKGATETST_X2%GCK_r7 x_PM_CLKGATETST_X2%GCK_14 x_PM_CLKGATETST_X2%GCK_3 0.095
R_x_PM_CLKGATETST_X2%GCK_r8 N_GCK_M11_d x_PM_CLKGATETST_X2%GCK_3 1.44611
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X4.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X4 VSS VDD SE E CK GCK
*.PININFO VSS:B VDD:B SE:I E:I CK:I GCK:O
M_M12 13 N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.450000U L=0.050000U
M_M13 N_VDD_M1_d N_E_M1_g 13 VDD PMOS_VTL W=0.450000U L=0.050000U
M_M14 14 N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_7_M3_d N_6_M3_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 15 N_9_M4_g N_7_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_VDD_M5_d N_8_M5_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_6_M6_d N_9_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VDD_M7_d N_7_M7_g N_8_M7_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_9_M8_d N_CK_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_10_M9_d N_CK_M9_g N_VDD_M9_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M22 N_VDD_M10_d N_7_M10_g N_10_M9_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M23 N_GCK_M11_d N_10_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M0 N_3_M12_d N_SE_M12_g N_VSS_M12_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M13_d N_E_M13_g N_3_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 16 N_3_M14_g N_VSS_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M15_d N_9_M15_g 16 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 17 N_6_M16_g N_7_M15_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M17_d N_8_M17_g 17 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_6_M18_d N_9_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M19_d N_7_M19_g N_8_M19_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_9_M20_d N_CK_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 18 N_CK_M21_g N_10_M21_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M10 N_VSS_M22_d N_7_M22_g 18 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M11 N_GCK_M23_d N_10_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_CLKGATETST_X4%VSS_c0 VSS N_VSS_M22_d 5.72894e-17
C_x_PM_CLKGATETST_X4%VSS_c1 VSS x_PM_CLKGATETST_X4%VSS_32 4.64667e-18
C_x_PM_CLKGATETST_X4%VSS_c2 VSS x_PM_CLKGATETST_X4%VSS_31 8.86015e-18
C_x_PM_CLKGATETST_X4%VSS_c3 VSS x_PM_CLKGATETST_X4%VSS_30 5.64357e-18
C_x_PM_CLKGATETST_X4%VSS_c4 VSS x_PM_CLKGATETST_X4%VSS_26 9.40724e-17
C_x_PM_CLKGATETST_X4%VSS_c5 VSS N_VSS_M19_d 4.68361e-17
C_x_PM_CLKGATETST_X4%VSS_c6 VSS x_PM_CLKGATETST_X4%VSS_18 4.44335e-17
C_x_PM_CLKGATETST_X4%VSS_c7 VSS x_PM_CLKGATETST_X4%VSS_17 5.24101e-17
C_x_PM_CLKGATETST_X4%VSS_c8 VSS x_PM_CLKGATETST_X4%VSS_14 1.05854e-16
C_x_PM_CLKGATETST_X4%VSS_c9 VSS x_PM_CLKGATETST_X4%VSS_13 4.5246e-17
C_x_PM_CLKGATETST_X4%VSS_c10 VSS x_PM_CLKGATETST_X4%VSS_11 1.1006e-17
C_x_PM_CLKGATETST_X4%VSS_c11 VSS x_PM_CLKGATETST_X4%VSS_10 1.86963e-17
C_x_PM_CLKGATETST_X4%VSS_c12 VSS N_VSS_M12_s 1.59654e-17
R_x_PM_CLKGATETST_X4%VSS_r13 x_PM_CLKGATETST_X4%VSS_32 x_PM_CLKGATETST_X4%VSS_27 0.0731438
R_x_PM_CLKGATETST_X4%VSS_r14 x_PM_CLKGATETST_X4%VSS_26 N_VSS_M22_d 0.140674
R_x_PM_CLKGATETST_X4%VSS_r15 x_PM_CLKGATETST_X4%VSS_27 x_PM_CLKGATETST_X4%VSS_26 1.38588
R_x_PM_CLKGATETST_X4%VSS_r16 x_PM_CLKGATETST_X4%VSS_32 x_PM_CLKGATETST_X4%VSS_22 0.145286
R_x_PM_CLKGATETST_X4%VSS_r17 N_VSS_M19_d x_PM_CLKGATETST_X4%VSS_22 1.615
R_x_PM_CLKGATETST_X4%VSS_r18 x_PM_CLKGATETST_X4%VSS_31 x_PM_CLKGATETST_X4%VSS_19 0.132285
R_x_PM_CLKGATETST_X4%VSS_r19 VSS x_PM_CLKGATETST_X4%VSS_19 0.324118
R_x_PM_CLKGATETST_X4%VSS_r20 x_PM_CLKGATETST_X4%VSS_32 x_PM_CLKGATETST_X4%VSS_18 0.0731438
R_x_PM_CLKGATETST_X4%VSS_r21 VSS x_PM_CLKGATETST_X4%VSS_18 0.670588
R_x_PM_CLKGATETST_X4%VSS_r22 x_PM_CLKGATETST_X4%VSS_31 x_PM_CLKGATETST_X4%VSS_17 0.0680382
R_x_PM_CLKGATETST_X4%VSS_r23 x_PM_CLKGATETST_X4%VSS_17 N_VSS_M17_d 0.403583
R_x_PM_CLKGATETST_X4%VSS_r24 x_PM_CLKGATETST_X4%VSS_30 x_PM_CLKGATETST_X4%VSS_15 0.132285
R_x_PM_CLKGATETST_X4%VSS_r25 x_PM_CLKGATETST_X4%VSS_31 x_PM_CLKGATETST_X4%VSS_14 0.132285
R_x_PM_CLKGATETST_X4%VSS_r26 x_PM_CLKGATETST_X4%VSS_15 x_PM_CLKGATETST_X4%VSS_14 1.38588
R_x_PM_CLKGATETST_X4%VSS_r27 x_PM_CLKGATETST_X4%VSS_30 x_PM_CLKGATETST_X4%VSS_13 0.0680382
R_x_PM_CLKGATETST_X4%VSS_r28 x_PM_CLKGATETST_X4%VSS_13 N_VSS_M13_d 0.403583
R_x_PM_CLKGATETST_X4%VSS_r29 x_PM_CLKGATETST_X4%VSS_30 x_PM_CLKGATETST_X4%VSS_10 0.132285
R_x_PM_CLKGATETST_X4%VSS_r30 x_PM_CLKGATETST_X4%VSS_11 x_PM_CLKGATETST_X4%VSS_10 0.625882
R_x_PM_CLKGATETST_X4%VSS_r31 x_PM_CLKGATETST_X4%VSS_11 x_PM_CLKGATETST_X4%VSS_6 0.264221
R_x_PM_CLKGATETST_X4%VSS_r32 N_VSS_M12_s x_PM_CLKGATETST_X4%VSS_6 0.909286
C_x_PM_CLKGATETST_X4%VDD_c0 VSS x_PM_CLKGATETST_X4%VDD_40 3.55354e-17
C_x_PM_CLKGATETST_X4%VDD_c1 VSS x_PM_CLKGATETST_X4%VDD_39 4.64934e-18
C_x_PM_CLKGATETST_X4%VDD_c2 VSS x_PM_CLKGATETST_X4%VDD_38 8.87861e-18
C_x_PM_CLKGATETST_X4%VDD_c3 VSS x_PM_CLKGATETST_X4%VDD_37 5.67481e-18
C_x_PM_CLKGATETST_X4%VDD_c4 VSS x_PM_CLKGATETST_X4%VDD_36 5.75507e-18
C_x_PM_CLKGATETST_X4%VDD_c5 VSS N_VDD_M10_d 3.75837e-17
C_x_PM_CLKGATETST_X4%VDD_c6 VSS x_PM_CLKGATETST_X4%VDD_28 2.41835e-17
C_x_PM_CLKGATETST_X4%VDD_c7 VSS N_VDD_M9_s 2.71544e-17
C_x_PM_CLKGATETST_X4%VDD_c8 VSS x_PM_CLKGATETST_X4%VDD_22 2.16604e-17
C_x_PM_CLKGATETST_X4%VDD_c9 VSS x_PM_CLKGATETST_X4%VDD_21 2.26588e-17
C_x_PM_CLKGATETST_X4%VDD_c10 VSS x_PM_CLKGATETST_X4%VDD_18 3.13195e-17
C_x_PM_CLKGATETST_X4%VDD_c11 VSS x_PM_CLKGATETST_X4%VDD_17 7.83478e-17
C_x_PM_CLKGATETST_X4%VDD_c12 VSS x_PM_CLKGATETST_X4%VDD_14 1.11056e-16
C_x_PM_CLKGATETST_X4%VDD_c13 VSS N_VDD_M1_d 6.61337e-17
C_x_PM_CLKGATETST_X4%VDD_c14 VSS x_PM_CLKGATETST_X4%VDD_6 3.4587e-17
R_x_PM_CLKGATETST_X4%VDD_r15 x_PM_CLKGATETST_X4%VDD_40 x_PM_CLKGATETST_X4%VDD_30 0.0680382
R_x_PM_CLKGATETST_X4%VDD_r16 N_VDD_M10_d x_PM_CLKGATETST_X4%VDD_30 0.471481
R_x_PM_CLKGATETST_X4%VDD_r17 x_PM_CLKGATETST_X4%VDD_39 x_PM_CLKGATETST_X4%VDD_29 0.0731438
R_x_PM_CLKGATETST_X4%VDD_r18 x_PM_CLKGATETST_X4%VDD_40 x_PM_CLKGATETST_X4%VDD_28 0.132285
R_x_PM_CLKGATETST_X4%VDD_r19 x_PM_CLKGATETST_X4%VDD_29 x_PM_CLKGATETST_X4%VDD_28 0.603529
R_x_PM_CLKGATETST_X4%VDD_r20 x_PM_CLKGATETST_X4%VDD_39 x_PM_CLKGATETST_X4%VDD_24 0.145286
R_x_PM_CLKGATETST_X4%VDD_r21 N_VDD_M9_s x_PM_CLKGATETST_X4%VDD_24 0.909286
R_x_PM_CLKGATETST_X4%VDD_r22 x_PM_CLKGATETST_X4%VDD_38 x_PM_CLKGATETST_X4%VDD_23 0.132285
R_x_PM_CLKGATETST_X4%VDD_r23 x_PM_CLKGATETST_X4%VDD_39 x_PM_CLKGATETST_X4%VDD_22 0.0731438
R_x_PM_CLKGATETST_X4%VDD_r24 x_PM_CLKGATETST_X4%VDD_23 x_PM_CLKGATETST_X4%VDD_22 0.547647
R_x_PM_CLKGATETST_X4%VDD_r25 x_PM_CLKGATETST_X4%VDD_38 x_PM_CLKGATETST_X4%VDD_21 0.0680382
R_x_PM_CLKGATETST_X4%VDD_r26 x_PM_CLKGATETST_X4%VDD_21 N_VDD_M7_d 0.488028
R_x_PM_CLKGATETST_X4%VDD_r27 x_PM_CLKGATETST_X4%VDD_37 x_PM_CLKGATETST_X4%VDD_19 0.132285
R_x_PM_CLKGATETST_X4%VDD_r28 x_PM_CLKGATETST_X4%VDD_38 x_PM_CLKGATETST_X4%VDD_18 0.132285
R_x_PM_CLKGATETST_X4%VDD_r29 x_PM_CLKGATETST_X4%VDD_19 x_PM_CLKGATETST_X4%VDD_18 0.927647
R_x_PM_CLKGATETST_X4%VDD_r30 x_PM_CLKGATETST_X4%VDD_37 x_PM_CLKGATETST_X4%VDD_17 0.0680382
R_x_PM_CLKGATETST_X4%VDD_r31 x_PM_CLKGATETST_X4%VDD_17 N_VDD_M5_d 0.53025
R_x_PM_CLKGATETST_X4%VDD_r32 x_PM_CLKGATETST_X4%VDD_36 x_PM_CLKGATETST_X4%VDD_15 0.132285
R_x_PM_CLKGATETST_X4%VDD_r33 x_PM_CLKGATETST_X4%VDD_37 x_PM_CLKGATETST_X4%VDD_14 0.132285
R_x_PM_CLKGATETST_X4%VDD_r34 x_PM_CLKGATETST_X4%VDD_15 x_PM_CLKGATETST_X4%VDD_14 1.39706
R_x_PM_CLKGATETST_X4%VDD_r35 x_PM_CLKGATETST_X4%VDD_36 x_PM_CLKGATETST_X4%VDD_10 0.0680382
R_x_PM_CLKGATETST_X4%VDD_r36 N_VDD_M1_d x_PM_CLKGATETST_X4%VDD_10 0.598148
R_x_PM_CLKGATETST_X4%VDD_r37 x_PM_CLKGATETST_X4%VDD_36 x_PM_CLKGATETST_X4%VDD_6 0.132285
R_x_PM_CLKGATETST_X4%VDD_r38 VDD x_PM_CLKGATETST_X4%VDD_6 0.430294
C_x_PM_CLKGATETST_X4%3_c0 VSS x_PM_CLKGATETST_X4%3_28 8.13136e-18
C_x_PM_CLKGATETST_X4%3_c1 VSS x_PM_CLKGATETST_X4%3_22 6.05573e-17
C_x_PM_CLKGATETST_X4%3_c2 VSS x_PM_CLKGATETST_X4%3_18 2.26956e-17
C_x_PM_CLKGATETST_X4%3_c3 VSS x_PM_CLKGATETST_X4%3_17 4.16026e-17
C_x_PM_CLKGATETST_X4%3_c4 VSS x_PM_CLKGATETST_X4%3_16 1.6874e-17
C_x_PM_CLKGATETST_X4%3_c5 VSS x_PM_CLKGATETST_X4%3_15 8.18259e-17
C_x_PM_CLKGATETST_X4%3_c6 VSS N_3_M0_s 1.80561e-17
C_x_PM_CLKGATETST_X4%3_c7 VSS N_3_M2_g 6.22979e-17
C_x_PM_CLKGATETST_X4%3_c8 VSS N_3_M14_g 2.5761e-17
R_x_PM_CLKGATETST_X4%3_r9 x_PM_CLKGATETST_X4%3_30 x_PM_CLKGATETST_X4%3_28 4.7687
R_x_PM_CLKGATETST_X4%3_r10 x_PM_CLKGATETST_X4%3_28 x_PM_CLKGATETST_X4%3_22 25.0012
R_x_PM_CLKGATETST_X4%3_r11 x_PM_CLKGATETST_X4%3_22 x_PM_CLKGATETST_X4%3_20 1.53357
R_x_PM_CLKGATETST_X4%3_r12 x_PM_CLKGATETST_X4%3_22 x_PM_CLKGATETST_X4%3_19 0.312143
R_x_PM_CLKGATETST_X4%3_r13 x_PM_CLKGATETST_X4%3_18 N_3_M12_d 0.29113
R_x_PM_CLKGATETST_X4%3_r14 x_PM_CLKGATETST_X4%3_19 x_PM_CLKGATETST_X4%3_17 0.212317
R_x_PM_CLKGATETST_X4%3_r15 x_PM_CLKGATETST_X4%3_18 x_PM_CLKGATETST_X4%3_17 0.895714
R_x_PM_CLKGATETST_X4%3_r16 x_PM_CLKGATETST_X4%3_20 x_PM_CLKGATETST_X4%3_15 0.212317
R_x_PM_CLKGATETST_X4%3_r17 x_PM_CLKGATETST_X4%3_16 x_PM_CLKGATETST_X4%3_15 2.09
R_x_PM_CLKGATETST_X4%3_r18 x_PM_CLKGATETST_X4%3_16 x_PM_CLKGATETST_X4%3_11 0.212317
R_x_PM_CLKGATETST_X4%3_r19 N_3_M0_s x_PM_CLKGATETST_X4%3_11 0.746429
R_x_PM_CLKGATETST_X4%3_r20 N_3_M2_g x_PM_CLKGATETST_X4%3_30 75.66
R_x_PM_CLKGATETST_X4%3_r21 x_PM_CLKGATETST_X4%3_VSS x_PM_CLKGATETST_X4%3_28 4.7687
R_x_PM_CLKGATETST_X4%3_r22 N_3_M14_g x_PM_CLKGATETST_X4%3_VSS 21.84
C_x_PM_CLKGATETST_X4%SE_c0 VSS x_PM_CLKGATETST_X4%SE_18 1.11323e-17
C_x_PM_CLKGATETST_X4%SE_c1 VSS x_PM_CLKGATETST_X4%SE_9 5.77004e-17
C_x_PM_CLKGATETST_X4%SE_c2 VSS N_SE_M0_g 5.92483e-17
C_x_PM_CLKGATETST_X4%SE_c3 VSS N_SE_M12_g 3.97038e-17
R_x_PM_CLKGATETST_X4%SE_r4 x_PM_CLKGATETST_X4%SE_18 x_PM_CLKGATETST_X4%SE_11 5.46
R_x_PM_CLKGATETST_X4%SE_r5 x_PM_CLKGATETST_X4%SE_11 x_PM_CLKGATETST_X4%SE_9 25.0012
R_x_PM_CLKGATETST_X4%SE_r6 SE x_PM_CLKGATETST_X4%SE_9 0.105556
R_x_PM_CLKGATETST_X4%SE_r7 x_PM_CLKGATETST_X4%SE_18 x_PM_CLKGATETST_X4%SE_5 1.95
R_x_PM_CLKGATETST_X4%SE_r8 N_SE_M0_g x_PM_CLKGATETST_X4%SE_5 44.46
R_x_PM_CLKGATETST_X4%SE_r9 x_PM_CLKGATETST_X4%SE_18 x_PM_CLKGATETST_X4%SE_VSS 1.95
R_x_PM_CLKGATETST_X4%SE_r10 N_SE_M12_g x_PM_CLKGATETST_X4%SE_VSS 39
C_x_PM_CLKGATETST_X4%E_c0 VSS x_PM_CLKGATETST_X4%E_14 8.61131e-18
C_x_PM_CLKGATETST_X4%E_c1 VSS x_PM_CLKGATETST_X4%E_12 9.18224e-17
C_x_PM_CLKGATETST_X4%E_c2 VSS N_E_M1_g 5.7028e-17
C_x_PM_CLKGATETST_X4%E_c3 VSS N_E_M13_g 4.2614e-17
R_x_PM_CLKGATETST_X4%E_r4 x_PM_CLKGATETST_X4%E_18 x_PM_CLKGATETST_X4%E_14 4.7687
R_x_PM_CLKGATETST_X4%E_r5 x_PM_CLKGATETST_X4%E_17 x_PM_CLKGATETST_X4%E_14 4.7687
R_x_PM_CLKGATETST_X4%E_r6 x_PM_CLKGATETST_X4%E_14 x_PM_CLKGATETST_X4%E_12 25.0012
R_x_PM_CLKGATETST_X4%E_r7 x_PM_CLKGATETST_X4%E_12 E 0.169643
R_x_PM_CLKGATETST_X4%E_r8 N_E_M1_g x_PM_CLKGATETST_X4%E_18 44.46
R_x_PM_CLKGATETST_X4%E_r9 N_E_M13_g x_PM_CLKGATETST_X4%E_17 39
C_x_PM_CLKGATETST_X4%6_c0 VSS x_PM_CLKGATETST_X4%6_42 1.25634e-17
C_x_PM_CLKGATETST_X4%6_c1 VSS x_PM_CLKGATETST_X4%6_38 7.77177e-17
C_x_PM_CLKGATETST_X4%6_c2 VSS x_PM_CLKGATETST_X4%6_35 1.87152e-17
C_x_PM_CLKGATETST_X4%6_c3 VSS N_6_M6_d 9.50958e-17
C_x_PM_CLKGATETST_X4%6_c4 VSS x_PM_CLKGATETST_X4%6_31 1.78605e-17
C_x_PM_CLKGATETST_X4%6_c5 VSS x_PM_CLKGATETST_X4%6_30 3.23684e-17
C_x_PM_CLKGATETST_X4%6_c6 VSS x_PM_CLKGATETST_X4%6_25 1.48642e-17
C_x_PM_CLKGATETST_X4%6_c7 VSS x_PM_CLKGATETST_X4%6_23 3.50362e-17
C_x_PM_CLKGATETST_X4%6_c8 VSS x_PM_CLKGATETST_X4%6_21 1.6068e-17
C_x_PM_CLKGATETST_X4%6_c9 VSS x_PM_CLKGATETST_X4%6_19 2.71738e-17
C_x_PM_CLKGATETST_X4%6_c10 VSS x_PM_CLKGATETST_X4%6_18 1.12763e-16
C_x_PM_CLKGATETST_X4%6_c11 VSS x_PM_CLKGATETST_X4%6_17 2.8091e-17
C_x_PM_CLKGATETST_X4%6_c12 VSS x_PM_CLKGATETST_X4%6_16 8.58115e-17
C_x_PM_CLKGATETST_X4%6_c13 VSS x_PM_CLKGATETST_X4%6_13 2.10962e-16
C_x_PM_CLKGATETST_X4%6_c14 VSS N_6_M18_d 3.74377e-17
C_x_PM_CLKGATETST_X4%6_c15 VSS N_6_M16_g 2.59506e-17
C_x_PM_CLKGATETST_X4%6_c16 VSS N_6_M3_g 3.36728e-17
R_x_PM_CLKGATETST_X4%6_r17 N_6_M6_d x_PM_CLKGATETST_X4%6_31 1.75071
R_x_PM_CLKGATETST_X4%6_r18 x_PM_CLKGATETST_X4%6_31 x_PM_CLKGATETST_X4%6_29 0.212317
R_x_PM_CLKGATETST_X4%6_r19 x_PM_CLKGATETST_X4%6_30 x_PM_CLKGATETST_X4%6_29 0.95
R_x_PM_CLKGATETST_X4%6_r20 x_PM_CLKGATETST_X4%6_35 x_PM_CLKGATETST_X4%6_28 0.0418175
R_x_PM_CLKGATETST_X4%6_r21 x_PM_CLKGATETST_X4%6_28 x_PM_CLKGATETST_X4%6_38 1.76429
R_x_PM_CLKGATETST_X4%6_r22 x_PM_CLKGATETST_X4%6_25 x_PM_CLKGATETST_X4%6_44 4.42
R_x_PM_CLKGATETST_X4%6_r23 x_PM_CLKGATETST_X4%6_25 x_PM_CLKGATETST_X4%6_23 25.0012
R_x_PM_CLKGATETST_X4%6_r24 x_PM_CLKGATETST_X4%6_35 x_PM_CLKGATETST_X4%6_22 0.160909
R_x_PM_CLKGATETST_X4%6_r25 x_PM_CLKGATETST_X4%6_23 x_PM_CLKGATETST_X4%6_22 0.339286
R_x_PM_CLKGATETST_X4%6_r26 x_PM_CLKGATETST_X4%6_35 x_PM_CLKGATETST_X4%6_21 0.160909
R_x_PM_CLKGATETST_X4%6_r27 x_PM_CLKGATETST_X4%6_21 x_PM_CLKGATETST_X4%6_20 0.678571
R_x_PM_CLKGATETST_X4%6_r28 x_PM_CLKGATETST_X4%6_30 x_PM_CLKGATETST_X4%6_18 0.212317
R_x_PM_CLKGATETST_X4%6_r29 x_PM_CLKGATETST_X4%6_19 x_PM_CLKGATETST_X4%6_18 1.46571
R_x_PM_CLKGATETST_X4%6_r30 x_PM_CLKGATETST_X4%6_20 x_PM_CLKGATETST_X4%6_16 0.212317
R_x_PM_CLKGATETST_X4%6_r31 x_PM_CLKGATETST_X4%6_17 x_PM_CLKGATETST_X4%6_16 1.08571
R_x_PM_CLKGATETST_X4%6_r32 x_PM_CLKGATETST_X4%6_42 x_PM_CLKGATETST_X4%6_15 3.38
R_x_PM_CLKGATETST_X4%6_r33 x_PM_CLKGATETST_X4%6_15 x_PM_CLKGATETST_X4%6_13 25.0012
R_x_PM_CLKGATETST_X4%6_r34 x_PM_CLKGATETST_X4%6_19 x_PM_CLKGATETST_X4%6_12 0.212317
R_x_PM_CLKGATETST_X4%6_r35 x_PM_CLKGATETST_X4%6_13 x_PM_CLKGATETST_X4%6_12 2.15786
R_x_PM_CLKGATETST_X4%6_r36 x_PM_CLKGATETST_X4%6_17 x_PM_CLKGATETST_X4%6_11 0.212317
R_x_PM_CLKGATETST_X4%6_r37 x_PM_CLKGATETST_X4%6_13 x_PM_CLKGATETST_X4%6_11 3.02643
R_x_PM_CLKGATETST_X4%6_r38 x_PM_CLKGATETST_X4%6_38 N_6_M18_d 0.297071
R_x_PM_CLKGATETST_X4%6_r39 x_PM_CLKGATETST_X4%6_44 x_PM_CLKGATETST_X4%6_5 1.95
R_x_PM_CLKGATETST_X4%6_r40 N_6_M16_g x_PM_CLKGATETST_X4%6_5 21.84
R_x_PM_CLKGATETST_X4%6_r41 x_PM_CLKGATETST_X4%6_42 x_PM_CLKGATETST_X4%6_VSS 1.95
R_x_PM_CLKGATETST_X4%6_r42 N_6_M3_g x_PM_CLKGATETST_X4%6_VSS 28.86
C_x_PM_CLKGATETST_X4%7_c0 VSS x_PM_CLKGATETST_X4%7_34 3.93781e-17
C_x_PM_CLKGATETST_X4%7_c1 VSS x_PM_CLKGATETST_X4%7_31 1.79734e-16
C_x_PM_CLKGATETST_X4%7_c2 VSS N_7_M3_d 8.25207e-17
C_x_PM_CLKGATETST_X4%7_c3 VSS N_7_M15_d 1.44619e-16
C_x_PM_CLKGATETST_X4%7_c4 VSS x_PM_CLKGATETST_X4%7_18 4.74632e-18
C_x_PM_CLKGATETST_X4%7_c5 VSS x_PM_CLKGATETST_X4%7_17 3.20742e-17
C_x_PM_CLKGATETST_X4%7_c6 VSS N_7_M22_g 1.30108e-16
C_x_PM_CLKGATETST_X4%7_c7 VSS x_PM_CLKGATETST_X4%7_10 5.17561e-18
C_x_PM_CLKGATETST_X4%7_c8 VSS x_PM_CLKGATETST_X4%7_9 7.79238e-17
C_x_PM_CLKGATETST_X4%7_c9 VSS N_7_M7_g 5.40267e-17
C_x_PM_CLKGATETST_X4%7_c10 VSS N_7_M19_g 5.08015e-17
R_x_PM_CLKGATETST_X4%7_r11 x_PM_CLKGATETST_X4%7_35 x_PM_CLKGATETST_X4%7_31 25.0012
R_x_PM_CLKGATETST_X4%7_r12 x_PM_CLKGATETST_X4%7_34 x_PM_CLKGATETST_X4%7_29 0.0272847
R_x_PM_CLKGATETST_X4%7_r13 x_PM_CLKGATETST_X4%7_31 x_PM_CLKGATETST_X4%7_29 1.61148
R_x_PM_CLKGATETST_X4%7_r14 x_PM_CLKGATETST_X4%7_34 x_PM_CLKGATETST_X4%7_25 0.266978
R_x_PM_CLKGATETST_X4%7_r15 N_7_M3_d x_PM_CLKGATETST_X4%7_25 1.09929
R_x_PM_CLKGATETST_X4%7_r16 x_PM_CLKGATETST_X4%7_34 x_PM_CLKGATETST_X4%7_21 0.266978
R_x_PM_CLKGATETST_X4%7_r17 N_7_M15_d x_PM_CLKGATETST_X4%7_21 1.91357
R_x_PM_CLKGATETST_X4%7_r18 x_PM_CLKGATETST_X4%7_35 x_PM_CLKGATETST_X4%7_17 19.2563
R_x_PM_CLKGATETST_X4%7_r19 x_PM_CLKGATETST_X4%7_18 x_PM_CLKGATETST_X4%7_17 0.179698
R_x_PM_CLKGATETST_X4%7_r20 N_7_M10_g N_7_M22_g 121.68
R_x_PM_CLKGATETST_X4%7_r21 N_7_M10_g x_PM_CLKGATETST_X4%7_11 47.58
R_x_PM_CLKGATETST_X4%7_r22 x_PM_CLKGATETST_X4%7_11 x_PM_CLKGATETST_X4%7_9 4.35808
R_x_PM_CLKGATETST_X4%7_r23 x_PM_CLKGATETST_X4%7_10 x_PM_CLKGATETST_X4%7_9 104.52
R_x_PM_CLKGATETST_X4%7_r24 x_PM_CLKGATETST_X4%7_10 x_PM_CLKGATETST_X4%7_6 4.35808
R_x_PM_CLKGATETST_X4%7_r25 N_7_M7_g x_PM_CLKGATETST_X4%7_6 45.24
R_x_PM_CLKGATETST_X4%7_r26 x_PM_CLKGATETST_X4%7_18 x_PM_CLKGATETST_X4%7_5 4.78783
R_x_PM_CLKGATETST_X4%7_r27 N_7_M7_g x_PM_CLKGATETST_X4%7_5 31.98
R_x_PM_CLKGATETST_X4%7_r28 x_PM_CLKGATETST_X4%7_18 x_PM_CLKGATETST_X4%7_VSS 4.78783
R_x_PM_CLKGATETST_X4%7_r29 N_7_M19_g x_PM_CLKGATETST_X4%7_VSS 46.8
C_x_PM_CLKGATETST_X4%8_c0 VSS N_8_M7_s 8.27037e-17
C_x_PM_CLKGATETST_X4%8_c1 VSS x_PM_CLKGATETST_X4%8_16 1.90144e-17
C_x_PM_CLKGATETST_X4%8_c2 VSS x_PM_CLKGATETST_X4%8_14 9.32951e-18
C_x_PM_CLKGATETST_X4%8_c3 VSS x_PM_CLKGATETST_X4%8_11 1.45852e-16
C_x_PM_CLKGATETST_X4%8_c4 VSS N_8_M5_g 6.60431e-17
C_x_PM_CLKGATETST_X4%8_c5 VSS N_8_M17_g 3.93872e-17
R_x_PM_CLKGATETST_X4%8_r6 N_8_M7_s x_PM_CLKGATETST_X4%8_16 2.45643
R_x_PM_CLKGATETST_X4%8_r7 x_PM_CLKGATETST_X4%8_23 x_PM_CLKGATETST_X4%8_14 4.7687
R_x_PM_CLKGATETST_X4%8_r8 x_PM_CLKGATETST_X4%8_22 x_PM_CLKGATETST_X4%8_14 4.7687
R_x_PM_CLKGATETST_X4%8_r9 x_PM_CLKGATETST_X4%8_14 x_PM_CLKGATETST_X4%8_12 25.0012
R_x_PM_CLKGATETST_X4%8_r10 x_PM_CLKGATETST_X4%8_12 x_PM_CLKGATETST_X4%8_11 1.16111
R_x_PM_CLKGATETST_X4%8_r11 N_8_M19_s x_PM_CLKGATETST_X4%8_16 0.140129
R_x_PM_CLKGATETST_X4%8_r12 N_8_M19_s x_PM_CLKGATETST_X4%8_11 0.101204
R_x_PM_CLKGATETST_X4%8_r13 N_8_M5_g x_PM_CLKGATETST_X4%8_23 64.74
R_x_PM_CLKGATETST_X4%8_r14 N_8_M17_g x_PM_CLKGATETST_X4%8_22 32.76
C_x_PM_CLKGATETST_X4%9_c0 VSS x_PM_CLKGATETST_X4%9_35 4.89487e-17
C_x_PM_CLKGATETST_X4%9_c1 VSS x_PM_CLKGATETST_X4%9_33 1.31807e-17
C_x_PM_CLKGATETST_X4%9_c2 VSS N_9_M20_d 1.02109e-16
C_x_PM_CLKGATETST_X4%9_c3 VSS x_PM_CLKGATETST_X4%9_21 3.01228e-18
C_x_PM_CLKGATETST_X4%9_c4 VSS x_PM_CLKGATETST_X4%9_19 7.51625e-17
C_x_PM_CLKGATETST_X4%9_c5 VSS N_9_M18_g 1.28101e-16
C_x_PM_CLKGATETST_X4%9_c6 VSS N_9_M4_g 6.30473e-17
C_x_PM_CLKGATETST_X4%9_c7 VSS x_PM_CLKGATETST_X4%9_8 6.95824e-18
C_x_PM_CLKGATETST_X4%9_c8 VSS x_PM_CLKGATETST_X4%9_7 2.31562e-17
C_x_PM_CLKGATETST_X4%9_c9 VSS x_PM_CLKGATETST_X4%9_6 6.31501e-18
C_x_PM_CLKGATETST_X4%9_c10 VSS x_PM_CLKGATETST_X4%9_5 5.92161e-17
C_x_PM_CLKGATETST_X4%9_c11 VSS N_9_M15_g 5.34363e-17
R_x_PM_CLKGATETST_X4%9_r12 x_PM_CLKGATETST_X4%9_33 x_PM_CLKGATETST_X4%9_31 25.0012
R_x_PM_CLKGATETST_X4%9_r13 x_PM_CLKGATETST_X4%9_35 x_PM_CLKGATETST_X4%9_31 0.0678571
R_x_PM_CLKGATETST_X4%9_r14 x_PM_CLKGATETST_X4%9_35 x_PM_CLKGATETST_X4%9_25 0.095
R_x_PM_CLKGATETST_X4%9_r15 N_9_M8_d N_9_M20_d 2.93143
R_x_PM_CLKGATETST_X4%9_r16 N_9_M20_d x_PM_CLKGATETST_X4%9_25 0.882143
R_x_PM_CLKGATETST_X4%9_r17 x_PM_CLKGATETST_X4%9_33 x_PM_CLKGATETST_X4%9_22 9.62
R_x_PM_CLKGATETST_X4%9_r18 x_PM_CLKGATETST_X4%9_21 x_PM_CLKGATETST_X4%9_20 3.30287
R_x_PM_CLKGATETST_X4%9_r19 x_PM_CLKGATETST_X4%9_22 x_PM_CLKGATETST_X4%9_19 4.58872
R_x_PM_CLKGATETST_X4%9_r20 x_PM_CLKGATETST_X4%9_20 x_PM_CLKGATETST_X4%9_19 88.92
R_x_PM_CLKGATETST_X4%9_r21 N_9_M6_g N_9_M18_g 109.2
R_x_PM_CLKGATETST_X4%9_r22 x_PM_CLKGATETST_X4%9_21 x_PM_CLKGATETST_X4%9_13 0.858359
R_x_PM_CLKGATETST_X4%9_r23 N_9_M18_g x_PM_CLKGATETST_X4%9_13 33.54
R_x_PM_CLKGATETST_X4%9_r24 N_9_M4_g x_PM_CLKGATETST_X4%9_9 56.16
R_x_PM_CLKGATETST_X4%9_r25 x_PM_CLKGATETST_X4%9_9 x_PM_CLKGATETST_X4%9_7 4.35808
R_x_PM_CLKGATETST_X4%9_r26 x_PM_CLKGATETST_X4%9_8 x_PM_CLKGATETST_X4%9_7 21.84
R_x_PM_CLKGATETST_X4%9_r27 x_PM_CLKGATETST_X4%9_21 x_PM_CLKGATETST_X4%9_5 3.30287
R_x_PM_CLKGATETST_X4%9_r28 x_PM_CLKGATETST_X4%9_6 x_PM_CLKGATETST_X4%9_5 81.12
R_x_PM_CLKGATETST_X4%9_r29 x_PM_CLKGATETST_X4%9_8 x_PM_CLKGATETST_X4%9_2 4.35808
R_x_PM_CLKGATETST_X4%9_r30 N_9_M15_g x_PM_CLKGATETST_X4%9_2 45.24
R_x_PM_CLKGATETST_X4%9_r31 x_PM_CLKGATETST_X4%9_6 x_PM_CLKGATETST_X4%9_VSS 4.35808
R_x_PM_CLKGATETST_X4%9_r32 N_9_M15_g x_PM_CLKGATETST_X4%9_VSS 33.54
C_x_PM_CLKGATETST_X4%10_c0 VSS x_PM_CLKGATETST_X4%10_29 1.41514e-17
C_x_PM_CLKGATETST_X4%10_c1 VSS x_PM_CLKGATETST_X4%10_26 1.69933e-17
C_x_PM_CLKGATETST_X4%10_c2 VSS N_10_M9_d 1.74242e-17
C_x_PM_CLKGATETST_X4%10_c3 VSS x_PM_CLKGATETST_X4%10_19 2.00149e-17
C_x_PM_CLKGATETST_X4%10_c4 VSS x_PM_CLKGATETST_X4%10_16 2.74871e-17
C_x_PM_CLKGATETST_X4%10_c5 VSS x_PM_CLKGATETST_X4%10_14 2.95518e-17
C_x_PM_CLKGATETST_X4%10_c6 VSS x_PM_CLKGATETST_X4%10_12 7.87277e-17
C_x_PM_CLKGATETST_X4%10_c7 VSS N_10_M11_g 6.89545e-17
C_x_PM_CLKGATETST_X4%10_c8 VSS N_10_M23_g 5.37818e-17
R_x_PM_CLKGATETST_X4%10_r9 x_PM_CLKGATETST_X4%10_29 x_PM_CLKGATETST_X4%10_27 5.46
R_x_PM_CLKGATETST_X4%10_r10 x_PM_CLKGATETST_X4%10_27 x_PM_CLKGATETST_X4%10_19 25.0012
R_x_PM_CLKGATETST_X4%10_r11 x_PM_CLKGATETST_X4%10_26 x_PM_CLKGATETST_X4%10_17 0.0418175
R_x_PM_CLKGATETST_X4%10_r12 x_PM_CLKGATETST_X4%10_19 x_PM_CLKGATETST_X4%10_17 0.936429
R_x_PM_CLKGATETST_X4%10_r13 x_PM_CLKGATETST_X4%10_16 N_10_M9_d 0.30478
R_x_PM_CLKGATETST_X4%10_r14 x_PM_CLKGATETST_X4%10_26 x_PM_CLKGATETST_X4%10_15 0.160909
R_x_PM_CLKGATETST_X4%10_r15 x_PM_CLKGATETST_X4%10_16 x_PM_CLKGATETST_X4%10_15 1.05857
R_x_PM_CLKGATETST_X4%10_r16 x_PM_CLKGATETST_X4%10_26 x_PM_CLKGATETST_X4%10_14 0.160909
R_x_PM_CLKGATETST_X4%10_r17 x_PM_CLKGATETST_X4%10_14 x_PM_CLKGATETST_X4%10_13 0.95
R_x_PM_CLKGATETST_X4%10_r18 x_PM_CLKGATETST_X4%10_13 x_PM_CLKGATETST_X4%10_12 0.241334
R_x_PM_CLKGATETST_X4%10_r19 x_PM_CLKGATETST_X4%10_12 N_10_M21_s 0.431731
R_x_PM_CLKGATETST_X4%10_r20 x_PM_CLKGATETST_X4%10_29 x_PM_CLKGATETST_X4%10_5 1.95
R_x_PM_CLKGATETST_X4%10_r21 N_10_M11_g x_PM_CLKGATETST_X4%10_5 63.18
R_x_PM_CLKGATETST_X4%10_r22 x_PM_CLKGATETST_X4%10_29 x_PM_CLKGATETST_X4%10_VSS 1.95
R_x_PM_CLKGATETST_X4%10_r23 N_10_M23_g x_PM_CLKGATETST_X4%10_VSS 39.78
C_x_PM_CLKGATETST_X4%CK_c0 VSS x_PM_CLKGATETST_X4%CK_25 4.66706e-18
C_x_PM_CLKGATETST_X4%CK_c1 VSS CK 7.02338e-17
C_x_PM_CLKGATETST_X4%CK_c2 VSS x_PM_CLKGATETST_X4%CK_19 4.45394e-18
C_x_PM_CLKGATETST_X4%CK_c3 VSS N_CK_M9_g 6.61617e-17
C_x_PM_CLKGATETST_X4%CK_c4 VSS N_CK_M21_g 5.76355e-17
C_x_PM_CLKGATETST_X4%CK_c5 VSS x_PM_CLKGATETST_X4%CK_9 2.66508e-17
C_x_PM_CLKGATETST_X4%CK_c6 VSS N_CK_M8_g 6.34533e-17
C_x_PM_CLKGATETST_X4%CK_c7 VSS N_CK_M20_g 3.48709e-17
R_x_PM_CLKGATETST_X4%CK_r8 x_PM_CLKGATETST_X4%CK_25 x_PM_CLKGATETST_X4%CK_23 25.0012
R_x_PM_CLKGATETST_X4%CK_r9 x_PM_CLKGATETST_X4%CK_23 CK 0.665
R_x_PM_CLKGATETST_X4%CK_r10 x_PM_CLKGATETST_X4%CK_25 x_PM_CLKGATETST_X4%CK_15 4.56151
R_x_PM_CLKGATETST_X4%CK_r11 N_CK_M9_g x_PM_CLKGATETST_X4%CK_15 55.38
R_x_PM_CLKGATETST_X4%CK_r12 x_PM_CLKGATETST_X4%CK_25 x_PM_CLKGATETST_X4%CK_11 4.56151
R_x_PM_CLKGATETST_X4%CK_r13 N_CK_M21_g x_PM_CLKGATETST_X4%CK_11 54.6
R_x_PM_CLKGATETST_X4%CK_r14 x_PM_CLKGATETST_X4%CK_19 x_PM_CLKGATETST_X4%CK_10 0.043368
R_x_PM_CLKGATETST_X4%CK_r15 x_PM_CLKGATETST_X4%CK_25 x_PM_CLKGATETST_X4%CK_9 0.043368
R_x_PM_CLKGATETST_X4%CK_r16 x_PM_CLKGATETST_X4%CK_10 x_PM_CLKGATETST_X4%CK_9 30.16
R_x_PM_CLKGATETST_X4%CK_r17 x_PM_CLKGATETST_X4%CK_19 x_PM_CLKGATETST_X4%CK_5 4.56151
R_x_PM_CLKGATETST_X4%CK_r18 N_CK_M8_g x_PM_CLKGATETST_X4%CK_5 57.72
R_x_PM_CLKGATETST_X4%CK_r19 x_PM_CLKGATETST_X4%CK_19 x_PM_CLKGATETST_X4%CK_VSS 4.56151
R_x_PM_CLKGATETST_X4%CK_r20 N_CK_M20_g x_PM_CLKGATETST_X4%CK_VSS 21.84
C_x_PM_CLKGATETST_X4%GCK_c0 VSS N_GCK_M23_d 4.18322e-17
C_x_PM_CLKGATETST_X4%GCK_c1 VSS GCK 2.33226e-17
C_x_PM_CLKGATETST_X4%GCK_c2 VSS N_GCK_M11_d 2.99016e-17
C_x_PM_CLKGATETST_X4%GCK_c3 VSS x_PM_CLKGATETST_X4%GCK_5 6.33898e-18
R_x_PM_CLKGATETST_X4%GCK_r4 GCK x_PM_CLKGATETST_X4%GCK_10 0.895714
R_x_PM_CLKGATETST_X4%GCK_r5 x_PM_CLKGATETST_X4%GCK_9 N_GCK_M23_d 0.279893
R_x_PM_CLKGATETST_X4%GCK_r6 GCK x_PM_CLKGATETST_X4%GCK_9 0.814286
R_x_PM_CLKGATETST_X4%GCK_r7 x_PM_CLKGATETST_X4%GCK_10 x_PM_CLKGATETST_X4%GCK_5 0.277749
R_x_PM_CLKGATETST_X4%GCK_r8 N_GCK_M11_d x_PM_CLKGATETST_X4%GCK_5 0.394074
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATETST_X8.                                                   *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATETST_X8 VSS VDD SE E CK GCK
*.PININFO VSS:B VDD:B SE:I E:I CK:I GCK:O
M_M13 13 N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.495000U L=0.050000U
M_M14 N_VDD_M1_d N_E_M1_g 13 VDD PMOS_VTL W=0.495000U L=0.050000U
M_M15 14 N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 N_7_M3_d N_6_M3_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 15 N_10_M4_g N_7_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_VDD_M5_d N_8_M5_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_6_M6_d N_10_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_VDD_M7_d N_7_M7_g N_8_M7_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_10_M8_d N_CK_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_11_M9_d N_CK_M9_g N_VDD_M9_s VDD PMOS_VTL W=0.495000U L=0.050000U
M_M23 N_VDD_M10_d N_7_M10_g N_11_M9_d VDD PMOS_VTL W=0.495000U L=0.050000U
M_M24 N_GCK_M11_d N_11_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M25 N_VDD_M12_d N_11_M12_g N_GCK_M11_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M0 N_3_M13_d N_SE_M13_g N_VSS_M13_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M14_d N_E_M14_g N_3_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 16 N_3_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M16_d N_10_M16_g 16 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 17 N_6_M17_g N_7_M16_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M18_d N_8_M18_g 17 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_6_M19_d N_10_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M20_d N_7_M20_g N_8_M20_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_10_M21_d N_CK_M21_g N_VSS_M20_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 18 N_CK_M22_g N_11_M22_s VSS NMOS_VTL W=0.430000U L=0.050000U
M_M10 N_VSS_M23_d N_7_M23_g 18 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M11 N_GCK_M24_d N_11_M24_g N_VSS_M23_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M12 N_VSS_M25_d N_11_M25_g N_GCK_M24_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_CLKGATETST_X8%VSS_c0 VSS x_PM_CLKGATETST_X8%VSS_42 5.79763e-18
C_x_PM_CLKGATETST_X8%VSS_c1 VSS x_PM_CLKGATETST_X8%VSS_41 2.68174e-18
C_x_PM_CLKGATETST_X8%VSS_c2 VSS x_PM_CLKGATETST_X8%VSS_40 8.86015e-18
C_x_PM_CLKGATETST_X8%VSS_c3 VSS x_PM_CLKGATETST_X8%VSS_39 5.64357e-18
C_x_PM_CLKGATETST_X8%VSS_c4 VSS N_VSS_M25_d 7.81878e-18
C_x_PM_CLKGATETST_X8%VSS_c5 VSS x_PM_CLKGATETST_X8%VSS_33 4.59453e-17
C_x_PM_CLKGATETST_X8%VSS_c6 VSS N_VSS_M23_d 2.9066e-17
C_x_PM_CLKGATETST_X8%VSS_c7 VSS x_PM_CLKGATETST_X8%VSS_27 9.99539e-17
C_x_PM_CLKGATETST_X8%VSS_c8 VSS N_VSS_M20_d 5.3352e-17
C_x_PM_CLKGATETST_X8%VSS_c9 VSS x_PM_CLKGATETST_X8%VSS_19 3.60486e-17
C_x_PM_CLKGATETST_X8%VSS_c10 VSS x_PM_CLKGATETST_X8%VSS_18 5.15697e-17
C_x_PM_CLKGATETST_X8%VSS_c11 VSS x_PM_CLKGATETST_X8%VSS_15 1.06441e-16
C_x_PM_CLKGATETST_X8%VSS_c12 VSS x_PM_CLKGATETST_X8%VSS_14 3.06623e-17
C_x_PM_CLKGATETST_X8%VSS_c13 VSS x_PM_CLKGATETST_X8%VSS_12 1.1006e-17
C_x_PM_CLKGATETST_X8%VSS_c14 VSS x_PM_CLKGATETST_X8%VSS_11 1.79496e-17
C_x_PM_CLKGATETST_X8%VSS_c15 VSS N_VSS_M13_s 1.6835e-17
R_x_PM_CLKGATETST_X8%VSS_r16 N_VSS_M25_d x_PM_CLKGATETST_X8%VSS_35 0.230714
R_x_PM_CLKGATETST_X8%VSS_r17 x_PM_CLKGATETST_X8%VSS_42 x_PM_CLKGATETST_X8%VSS_34 0.132285
R_x_PM_CLKGATETST_X8%VSS_r18 x_PM_CLKGATETST_X8%VSS_35 x_PM_CLKGATETST_X8%VSS_33 0.264221
R_x_PM_CLKGATETST_X8%VSS_r19 x_PM_CLKGATETST_X8%VSS_34 x_PM_CLKGATETST_X8%VSS_33 0.614706
R_x_PM_CLKGATETST_X8%VSS_r20 x_PM_CLKGATETST_X8%VSS_42 x_PM_CLKGATETST_X8%VSS_29 0.0680382
R_x_PM_CLKGATETST_X8%VSS_r21 N_VSS_M23_d x_PM_CLKGATETST_X8%VSS_29 0.513704
R_x_PM_CLKGATETST_X8%VSS_r22 x_PM_CLKGATETST_X8%VSS_41 x_PM_CLKGATETST_X8%VSS_28 0.0731438
R_x_PM_CLKGATETST_X8%VSS_r23 x_PM_CLKGATETST_X8%VSS_42 x_PM_CLKGATETST_X8%VSS_27 0.132285
R_x_PM_CLKGATETST_X8%VSS_r24 x_PM_CLKGATETST_X8%VSS_28 x_PM_CLKGATETST_X8%VSS_27 1.37471
R_x_PM_CLKGATETST_X8%VSS_r25 x_PM_CLKGATETST_X8%VSS_41 x_PM_CLKGATETST_X8%VSS_23 0.145286
R_x_PM_CLKGATETST_X8%VSS_r26 N_VSS_M20_d x_PM_CLKGATETST_X8%VSS_23 1.615
R_x_PM_CLKGATETST_X8%VSS_r27 x_PM_CLKGATETST_X8%VSS_40 x_PM_CLKGATETST_X8%VSS_20 0.132285
R_x_PM_CLKGATETST_X8%VSS_r28 VSS x_PM_CLKGATETST_X8%VSS_20 0.536471
R_x_PM_CLKGATETST_X8%VSS_r29 x_PM_CLKGATETST_X8%VSS_41 x_PM_CLKGATETST_X8%VSS_19 0.0731438
R_x_PM_CLKGATETST_X8%VSS_r30 VSS x_PM_CLKGATETST_X8%VSS_19 0.424706
R_x_PM_CLKGATETST_X8%VSS_r31 x_PM_CLKGATETST_X8%VSS_40 x_PM_CLKGATETST_X8%VSS_18 0.0680382
R_x_PM_CLKGATETST_X8%VSS_r32 x_PM_CLKGATETST_X8%VSS_18 N_VSS_M18_d 0.403583
R_x_PM_CLKGATETST_X8%VSS_r33 x_PM_CLKGATETST_X8%VSS_39 x_PM_CLKGATETST_X8%VSS_16 0.132285
R_x_PM_CLKGATETST_X8%VSS_r34 x_PM_CLKGATETST_X8%VSS_40 x_PM_CLKGATETST_X8%VSS_15 0.132285
R_x_PM_CLKGATETST_X8%VSS_r35 x_PM_CLKGATETST_X8%VSS_16 x_PM_CLKGATETST_X8%VSS_15 1.39706
R_x_PM_CLKGATETST_X8%VSS_r36 x_PM_CLKGATETST_X8%VSS_39 x_PM_CLKGATETST_X8%VSS_14 0.0680382
R_x_PM_CLKGATETST_X8%VSS_r37 x_PM_CLKGATETST_X8%VSS_14 N_VSS_M14_d 0.403583
R_x_PM_CLKGATETST_X8%VSS_r38 x_PM_CLKGATETST_X8%VSS_39 x_PM_CLKGATETST_X8%VSS_11 0.132285
R_x_PM_CLKGATETST_X8%VSS_r39 x_PM_CLKGATETST_X8%VSS_12 x_PM_CLKGATETST_X8%VSS_11 0.614706
R_x_PM_CLKGATETST_X8%VSS_r40 x_PM_CLKGATETST_X8%VSS_12 x_PM_CLKGATETST_X8%VSS_7 0.264221
R_x_PM_CLKGATETST_X8%VSS_r41 N_VSS_M13_s x_PM_CLKGATETST_X8%VSS_7 0.909286
C_x_PM_CLKGATETST_X8%VDD_c0 VSS x_PM_CLKGATETST_X8%VDD_49 6.48463e-18
C_x_PM_CLKGATETST_X8%VDD_c1 VSS x_PM_CLKGATETST_X8%VDD_48 8.94814e-18
C_x_PM_CLKGATETST_X8%VDD_c2 VSS x_PM_CLKGATETST_X8%VDD_47 8.92863e-18
C_x_PM_CLKGATETST_X8%VDD_c3 VSS x_PM_CLKGATETST_X8%VDD_46 5.70992e-18
C_x_PM_CLKGATETST_X8%VDD_c4 VSS N_VDD_M1_d 2.40191e-17
C_x_PM_CLKGATETST_X8%VDD_c5 VSS N_VDD_M12_d 2.00636e-17
C_x_PM_CLKGATETST_X8%VDD_c6 VSS x_PM_CLKGATETST_X8%VDD_35 3.56839e-17
C_x_PM_CLKGATETST_X8%VDD_c7 VSS N_VDD_M10_d 3.63423e-17
C_x_PM_CLKGATETST_X8%VDD_c8 VSS x_PM_CLKGATETST_X8%VDD_29 2.05841e-17
C_x_PM_CLKGATETST_X8%VDD_c9 VSS N_VDD_M9_s 2.11765e-17
C_x_PM_CLKGATETST_X8%VDD_c10 VSS x_PM_CLKGATETST_X8%VDD_23 1.76402e-17
C_x_PM_CLKGATETST_X8%VDD_c11 VSS N_VDD_M7_d 2.53053e-17
C_x_PM_CLKGATETST_X8%VDD_c12 VSS x_PM_CLKGATETST_X8%VDD_17 4.01146e-17
C_x_PM_CLKGATETST_X8%VDD_c13 VSS N_VDD_M5_d 9.91968e-17
C_x_PM_CLKGATETST_X8%VDD_c14 VSS x_PM_CLKGATETST_X8%VDD_11 1.14725e-16
C_x_PM_CLKGATETST_X8%VDD_c15 VSS x_PM_CLKGATETST_X8%VDD_7 3.62968e-17
R_x_PM_CLKGATETST_X8%VDD_r16 x_PM_CLKGATETST_X8%VDD_44 N_VDD_M1_d 0.457407
R_x_PM_CLKGATETST_X8%VDD_r17 N_VDD_M12_d x_PM_CLKGATETST_X8%VDD_37 1.64214
R_x_PM_CLKGATETST_X8%VDD_r18 x_PM_CLKGATETST_X8%VDD_49 x_PM_CLKGATETST_X8%VDD_36 0.132285
R_x_PM_CLKGATETST_X8%VDD_r19 x_PM_CLKGATETST_X8%VDD_37 x_PM_CLKGATETST_X8%VDD_35 0.264221
R_x_PM_CLKGATETST_X8%VDD_r20 x_PM_CLKGATETST_X8%VDD_36 x_PM_CLKGATETST_X8%VDD_35 0.614706
R_x_PM_CLKGATETST_X8%VDD_r21 x_PM_CLKGATETST_X8%VDD_49 x_PM_CLKGATETST_X8%VDD_31 0.0680382
R_x_PM_CLKGATETST_X8%VDD_r22 N_VDD_M10_d x_PM_CLKGATETST_X8%VDD_31 0.851481
R_x_PM_CLKGATETST_X8%VDD_r23 x_PM_CLKGATETST_X8%VDD_48 x_PM_CLKGATETST_X8%VDD_30 0.132285
R_x_PM_CLKGATETST_X8%VDD_r24 x_PM_CLKGATETST_X8%VDD_49 x_PM_CLKGATETST_X8%VDD_29 0.132285
R_x_PM_CLKGATETST_X8%VDD_r25 x_PM_CLKGATETST_X8%VDD_30 x_PM_CLKGATETST_X8%VDD_29 0.536471
R_x_PM_CLKGATETST_X8%VDD_r26 x_PM_CLKGATETST_X8%VDD_48 x_PM_CLKGATETST_X8%VDD_25 0.0680382
R_x_PM_CLKGATETST_X8%VDD_r27 N_VDD_M9_s x_PM_CLKGATETST_X8%VDD_25 0.471481
R_x_PM_CLKGATETST_X8%VDD_r28 x_PM_CLKGATETST_X8%VDD_47 x_PM_CLKGATETST_X8%VDD_24 0.132285
R_x_PM_CLKGATETST_X8%VDD_r29 x_PM_CLKGATETST_X8%VDD_48 x_PM_CLKGATETST_X8%VDD_23 0.132285
R_x_PM_CLKGATETST_X8%VDD_r30 x_PM_CLKGATETST_X8%VDD_24 x_PM_CLKGATETST_X8%VDD_23 0.469412
R_x_PM_CLKGATETST_X8%VDD_r31 x_PM_CLKGATETST_X8%VDD_47 x_PM_CLKGATETST_X8%VDD_19 0.0680382
R_x_PM_CLKGATETST_X8%VDD_r32 N_VDD_M7_d x_PM_CLKGATETST_X8%VDD_19 0.781111
R_x_PM_CLKGATETST_X8%VDD_r33 x_PM_CLKGATETST_X8%VDD_46 x_PM_CLKGATETST_X8%VDD_18 0.132285
R_x_PM_CLKGATETST_X8%VDD_r34 x_PM_CLKGATETST_X8%VDD_47 x_PM_CLKGATETST_X8%VDD_17 0.132285
R_x_PM_CLKGATETST_X8%VDD_r35 x_PM_CLKGATETST_X8%VDD_18 x_PM_CLKGATETST_X8%VDD_17 0.882941
R_x_PM_CLKGATETST_X8%VDD_r36 x_PM_CLKGATETST_X8%VDD_46 x_PM_CLKGATETST_X8%VDD_13 0.0680382
R_x_PM_CLKGATETST_X8%VDD_r37 N_VDD_M5_d x_PM_CLKGATETST_X8%VDD_13 0.218148
R_x_PM_CLKGATETST_X8%VDD_r38 x_PM_CLKGATETST_X8%VDD_44 x_PM_CLKGATETST_X8%VDD_12 0.095
R_x_PM_CLKGATETST_X8%VDD_r39 x_PM_CLKGATETST_X8%VDD_46 x_PM_CLKGATETST_X8%VDD_11 0.132285
R_x_PM_CLKGATETST_X8%VDD_r40 x_PM_CLKGATETST_X8%VDD_12 x_PM_CLKGATETST_X8%VDD_11 1.39706
R_x_PM_CLKGATETST_X8%VDD_r41 x_PM_CLKGATETST_X8%VDD_44 x_PM_CLKGATETST_X8%VDD_7 0.095
R_x_PM_CLKGATETST_X8%VDD_r42 VDD x_PM_CLKGATETST_X8%VDD_7 0.430294
C_x_PM_CLKGATETST_X8%3_c0 VSS x_PM_CLKGATETST_X8%3_27 7.91938e-18
C_x_PM_CLKGATETST_X8%3_c1 VSS x_PM_CLKGATETST_X8%3_24 5.63689e-17
C_x_PM_CLKGATETST_X8%3_c2 VSS x_PM_CLKGATETST_X8%3_23 1.21603e-17
C_x_PM_CLKGATETST_X8%3_c3 VSS x_PM_CLKGATETST_X8%3_22 1.49604e-17
C_x_PM_CLKGATETST_X8%3_c4 VSS x_PM_CLKGATETST_X8%3_21 2.87157e-17
C_x_PM_CLKGATETST_X8%3_c5 VSS N_3_M13_d 1.76373e-17
C_x_PM_CLKGATETST_X8%3_c6 VSS x_PM_CLKGATETST_X8%3_16 1.49419e-17
C_x_PM_CLKGATETST_X8%3_c7 VSS x_PM_CLKGATETST_X8%3_15 7.20563e-17
C_x_PM_CLKGATETST_X8%3_c8 VSS N_3_M0_s 1.80085e-17
C_x_PM_CLKGATETST_X8%3_c9 VSS N_3_M2_g 7.8755e-17
C_x_PM_CLKGATETST_X8%3_c10 VSS N_3_M15_g 2.719e-17
R_x_PM_CLKGATETST_X8%3_r11 x_PM_CLKGATETST_X8%3_29 x_PM_CLKGATETST_X8%3_27 4.7687
R_x_PM_CLKGATETST_X8%3_r12 x_PM_CLKGATETST_X8%3_27 x_PM_CLKGATETST_X8%3_25 25.0012
R_x_PM_CLKGATETST_X8%3_r13 x_PM_CLKGATETST_X8%3_25 x_PM_CLKGATETST_X8%3_23 0.0141545
R_x_PM_CLKGATETST_X8%3_r14 x_PM_CLKGATETST_X8%3_24 x_PM_CLKGATETST_X8%3_23 1.52
R_x_PM_CLKGATETST_X8%3_r15 x_PM_CLKGATETST_X8%3_25 x_PM_CLKGATETST_X8%3_21 0.198162
R_x_PM_CLKGATETST_X8%3_r16 x_PM_CLKGATETST_X8%3_22 x_PM_CLKGATETST_X8%3_21 1.05857
R_x_PM_CLKGATETST_X8%3_r17 x_PM_CLKGATETST_X8%3_22 x_PM_CLKGATETST_X8%3_17 0.212317
R_x_PM_CLKGATETST_X8%3_r18 N_3_M13_d x_PM_CLKGATETST_X8%3_17 0.312143
R_x_PM_CLKGATETST_X8%3_r19 x_PM_CLKGATETST_X8%3_24 x_PM_CLKGATETST_X8%3_15 0.212317
R_x_PM_CLKGATETST_X8%3_r20 x_PM_CLKGATETST_X8%3_16 x_PM_CLKGATETST_X8%3_15 2.09
R_x_PM_CLKGATETST_X8%3_r21 x_PM_CLKGATETST_X8%3_16 x_PM_CLKGATETST_X8%3_11 0.212317
R_x_PM_CLKGATETST_X8%3_r22 N_3_M0_s x_PM_CLKGATETST_X8%3_11 0.746429
R_x_PM_CLKGATETST_X8%3_r23 N_3_M2_g x_PM_CLKGATETST_X8%3_29 96.72
R_x_PM_CLKGATETST_X8%3_r24 x_PM_CLKGATETST_X8%3_VSS x_PM_CLKGATETST_X8%3_27 4.7687
R_x_PM_CLKGATETST_X8%3_r25 N_3_M15_g x_PM_CLKGATETST_X8%3_VSS 21.84
C_x_PM_CLKGATETST_X8%SE_c0 VSS x_PM_CLKGATETST_X8%SE_14 7.40899e-18
C_x_PM_CLKGATETST_X8%SE_c1 VSS x_PM_CLKGATETST_X8%SE_12 5.62155e-17
C_x_PM_CLKGATETST_X8%SE_c2 VSS N_SE_M0_g 6.82755e-17
C_x_PM_CLKGATETST_X8%SE_c3 VSS N_SE_M13_g 4.24665e-17
R_x_PM_CLKGATETST_X8%SE_r4 x_PM_CLKGATETST_X8%SE_18 x_PM_CLKGATETST_X8%SE_14 4.74714
R_x_PM_CLKGATETST_X8%SE_r5 x_PM_CLKGATETST_X8%SE_17 x_PM_CLKGATETST_X8%SE_14 4.74714
R_x_PM_CLKGATETST_X8%SE_r6 x_PM_CLKGATETST_X8%SE_14 x_PM_CLKGATETST_X8%SE_12 25.0012
R_x_PM_CLKGATETST_X8%SE_r7 x_PM_CLKGATETST_X8%SE_12 SE 0.156071
R_x_PM_CLKGATETST_X8%SE_r8 N_SE_M0_g x_PM_CLKGATETST_X8%SE_18 56.55
R_x_PM_CLKGATETST_X8%SE_r9 N_SE_M13_g x_PM_CLKGATETST_X8%SE_17 44.46
C_x_PM_CLKGATETST_X8%E_c0 VSS x_PM_CLKGATETST_X8%E_14 8.91227e-18
C_x_PM_CLKGATETST_X8%E_c1 VSS x_PM_CLKGATETST_X8%E_12 9.82895e-17
C_x_PM_CLKGATETST_X8%E_c2 VSS N_E_M1_g 6.75835e-17
C_x_PM_CLKGATETST_X8%E_c3 VSS N_E_M14_g 4.51459e-17
R_x_PM_CLKGATETST_X8%E_r4 x_PM_CLKGATETST_X8%E_18 x_PM_CLKGATETST_X8%E_14 4.7687
R_x_PM_CLKGATETST_X8%E_r5 x_PM_CLKGATETST_X8%E_17 x_PM_CLKGATETST_X8%E_14 4.7687
R_x_PM_CLKGATETST_X8%E_r6 x_PM_CLKGATETST_X8%E_14 x_PM_CLKGATETST_X8%E_12 25.0012
R_x_PM_CLKGATETST_X8%E_r7 x_PM_CLKGATETST_X8%E_12 E 0.2375
R_x_PM_CLKGATETST_X8%E_r8 N_E_M1_g x_PM_CLKGATETST_X8%E_18 56.55
R_x_PM_CLKGATETST_X8%E_r9 N_E_M14_g x_PM_CLKGATETST_X8%E_17 44.46
C_x_PM_CLKGATETST_X8%6_c0 VSS x_PM_CLKGATETST_X8%6_45 1.28664e-17
C_x_PM_CLKGATETST_X8%6_c1 VSS x_PM_CLKGATETST_X8%6_37 1.84728e-17
C_x_PM_CLKGATETST_X8%6_c2 VSS N_6_M6_d 4.9953e-17
C_x_PM_CLKGATETST_X8%6_c3 VSS x_PM_CLKGATETST_X8%6_32 1.18507e-17
C_x_PM_CLKGATETST_X8%6_c4 VSS x_PM_CLKGATETST_X8%6_31 6.07465e-17
C_x_PM_CLKGATETST_X8%6_c5 VSS x_PM_CLKGATETST_X8%6_30 3.19775e-17
C_x_PM_CLKGATETST_X8%6_c6 VSS x_PM_CLKGATETST_X8%6_27 9.15518e-17
C_x_PM_CLKGATETST_X8%6_c7 VSS x_PM_CLKGATETST_X8%6_25 1.38393e-17
C_x_PM_CLKGATETST_X8%6_c8 VSS x_PM_CLKGATETST_X8%6_23 4.91614e-17
C_x_PM_CLKGATETST_X8%6_c9 VSS x_PM_CLKGATETST_X8%6_21 1.51107e-17
C_x_PM_CLKGATETST_X8%6_c10 VSS x_PM_CLKGATETST_X8%6_19 2.55902e-17
C_x_PM_CLKGATETST_X8%6_c11 VSS x_PM_CLKGATETST_X8%6_18 1.11651e-16
C_x_PM_CLKGATETST_X8%6_c12 VSS x_PM_CLKGATETST_X8%6_17 2.74301e-17
C_x_PM_CLKGATETST_X8%6_c13 VSS x_PM_CLKGATETST_X8%6_16 8.62134e-17
C_x_PM_CLKGATETST_X8%6_c14 VSS x_PM_CLKGATETST_X8%6_13 2.10946e-16
C_x_PM_CLKGATETST_X8%6_c15 VSS N_6_M19_d 2.61439e-17
C_x_PM_CLKGATETST_X8%6_c16 VSS N_6_M17_g 2.59114e-17
C_x_PM_CLKGATETST_X8%6_c17 VSS N_6_M3_g 3.47309e-17
R_x_PM_CLKGATETST_X8%6_r18 N_6_M6_d x_PM_CLKGATETST_X8%6_33 0.990714
R_x_PM_CLKGATETST_X8%6_r19 x_PM_CLKGATETST_X8%6_33 x_PM_CLKGATETST_X8%6_31 0.212317
R_x_PM_CLKGATETST_X8%6_r20 x_PM_CLKGATETST_X8%6_32 x_PM_CLKGATETST_X8%6_31 1.54714
R_x_PM_CLKGATETST_X8%6_r21 x_PM_CLKGATETST_X8%6_32 x_PM_CLKGATETST_X8%6_29 0.212317
R_x_PM_CLKGATETST_X8%6_r22 x_PM_CLKGATETST_X8%6_30 x_PM_CLKGATETST_X8%6_29 0.95
R_x_PM_CLKGATETST_X8%6_r23 x_PM_CLKGATETST_X8%6_37 x_PM_CLKGATETST_X8%6_28 0.0418175
R_x_PM_CLKGATETST_X8%6_r24 x_PM_CLKGATETST_X8%6_41 x_PM_CLKGATETST_X8%6_27 0.095
R_x_PM_CLKGATETST_X8%6_r25 x_PM_CLKGATETST_X8%6_28 x_PM_CLKGATETST_X8%6_27 1.98143
R_x_PM_CLKGATETST_X8%6_r26 x_PM_CLKGATETST_X8%6_25 x_PM_CLKGATETST_X8%6_47 3.38
R_x_PM_CLKGATETST_X8%6_r27 x_PM_CLKGATETST_X8%6_25 x_PM_CLKGATETST_X8%6_23 25.0012
R_x_PM_CLKGATETST_X8%6_r28 x_PM_CLKGATETST_X8%6_37 x_PM_CLKGATETST_X8%6_22 0.160909
R_x_PM_CLKGATETST_X8%6_r29 x_PM_CLKGATETST_X8%6_23 x_PM_CLKGATETST_X8%6_22 0.339286
R_x_PM_CLKGATETST_X8%6_r30 x_PM_CLKGATETST_X8%6_37 x_PM_CLKGATETST_X8%6_21 0.160909
R_x_PM_CLKGATETST_X8%6_r31 x_PM_CLKGATETST_X8%6_21 x_PM_CLKGATETST_X8%6_20 0.678571
R_x_PM_CLKGATETST_X8%6_r32 x_PM_CLKGATETST_X8%6_30 x_PM_CLKGATETST_X8%6_18 0.212317
R_x_PM_CLKGATETST_X8%6_r33 x_PM_CLKGATETST_X8%6_19 x_PM_CLKGATETST_X8%6_18 1.52
R_x_PM_CLKGATETST_X8%6_r34 x_PM_CLKGATETST_X8%6_20 x_PM_CLKGATETST_X8%6_16 0.212317
R_x_PM_CLKGATETST_X8%6_r35 x_PM_CLKGATETST_X8%6_17 x_PM_CLKGATETST_X8%6_16 1.08571
R_x_PM_CLKGATETST_X8%6_r36 x_PM_CLKGATETST_X8%6_45 x_PM_CLKGATETST_X8%6_15 4.42
R_x_PM_CLKGATETST_X8%6_r37 x_PM_CLKGATETST_X8%6_15 x_PM_CLKGATETST_X8%6_13 25.0012
R_x_PM_CLKGATETST_X8%6_r38 x_PM_CLKGATETST_X8%6_19 x_PM_CLKGATETST_X8%6_12 0.212317
R_x_PM_CLKGATETST_X8%6_r39 x_PM_CLKGATETST_X8%6_13 x_PM_CLKGATETST_X8%6_12 1.39786
R_x_PM_CLKGATETST_X8%6_r40 x_PM_CLKGATETST_X8%6_17 x_PM_CLKGATETST_X8%6_11 0.212317
R_x_PM_CLKGATETST_X8%6_r41 x_PM_CLKGATETST_X8%6_13 x_PM_CLKGATETST_X8%6_11 3.75929
R_x_PM_CLKGATETST_X8%6_r42 x_PM_CLKGATETST_X8%6_41 N_6_M19_d 0.176429
R_x_PM_CLKGATETST_X8%6_r43 x_PM_CLKGATETST_X8%6_47 x_PM_CLKGATETST_X8%6_5 1.95
R_x_PM_CLKGATETST_X8%6_r44 N_6_M17_g x_PM_CLKGATETST_X8%6_5 21.84
R_x_PM_CLKGATETST_X8%6_r45 x_PM_CLKGATETST_X8%6_45 x_PM_CLKGATETST_X8%6_VSS 1.95
R_x_PM_CLKGATETST_X8%6_r46 N_6_M3_g x_PM_CLKGATETST_X8%6_VSS 28.86
C_x_PM_CLKGATETST_X8%7_c0 VSS x_PM_CLKGATETST_X8%7_34 4.08979e-17
C_x_PM_CLKGATETST_X8%7_c1 VSS x_PM_CLKGATETST_X8%7_31 1.90331e-16
C_x_PM_CLKGATETST_X8%7_c2 VSS N_7_M3_d 1.03337e-16
C_x_PM_CLKGATETST_X8%7_c3 VSS N_7_M16_d 1.23014e-16
C_x_PM_CLKGATETST_X8%7_c4 VSS x_PM_CLKGATETST_X8%7_18 4.2629e-18
C_x_PM_CLKGATETST_X8%7_c5 VSS x_PM_CLKGATETST_X8%7_17 2.8483e-17
C_x_PM_CLKGATETST_X8%7_c6 VSS N_7_M23_g 1.26989e-16
C_x_PM_CLKGATETST_X8%7_c7 VSS x_PM_CLKGATETST_X8%7_10 5.17789e-18
C_x_PM_CLKGATETST_X8%7_c8 VSS x_PM_CLKGATETST_X8%7_9 7.59791e-17
C_x_PM_CLKGATETST_X8%7_c9 VSS N_7_M7_g 6.45412e-17
C_x_PM_CLKGATETST_X8%7_c10 VSS N_7_M20_g 4.26137e-17
R_x_PM_CLKGATETST_X8%7_r11 x_PM_CLKGATETST_X8%7_35 x_PM_CLKGATETST_X8%7_31 25.0012
R_x_PM_CLKGATETST_X8%7_r12 x_PM_CLKGATETST_X8%7_34 x_PM_CLKGATETST_X8%7_29 0.0238872
R_x_PM_CLKGATETST_X8%7_r13 x_PM_CLKGATETST_X8%7_31 x_PM_CLKGATETST_X8%7_29 1.63963
R_x_PM_CLKGATETST_X8%7_r14 x_PM_CLKGATETST_X8%7_34 x_PM_CLKGATETST_X8%7_25 0.260444
R_x_PM_CLKGATETST_X8%7_r15 N_7_M3_d x_PM_CLKGATETST_X8%7_25 1.45667
R_x_PM_CLKGATETST_X8%7_r16 x_PM_CLKGATETST_X8%7_34 x_PM_CLKGATETST_X8%7_21 0.260444
R_x_PM_CLKGATETST_X8%7_r17 N_7_M16_d x_PM_CLKGATETST_X8%7_21 1.425
R_x_PM_CLKGATETST_X8%7_r18 x_PM_CLKGATETST_X8%7_35 x_PM_CLKGATETST_X8%7_17 17.94
R_x_PM_CLKGATETST_X8%7_r19 x_PM_CLKGATETST_X8%7_18 x_PM_CLKGATETST_X8%7_17 0.043368
R_x_PM_CLKGATETST_X8%7_r20 N_7_M10_g N_7_M23_g 98.67
R_x_PM_CLKGATETST_X8%7_r21 N_7_M10_g x_PM_CLKGATETST_X8%7_11 58.11
R_x_PM_CLKGATETST_X8%7_r22 x_PM_CLKGATETST_X8%7_11 x_PM_CLKGATETST_X8%7_9 4.35808
R_x_PM_CLKGATETST_X8%7_r23 x_PM_CLKGATETST_X8%7_10 x_PM_CLKGATETST_X8%7_9 104.52
R_x_PM_CLKGATETST_X8%7_r24 x_PM_CLKGATETST_X8%7_10 x_PM_CLKGATETST_X8%7_6 4.35808
R_x_PM_CLKGATETST_X8%7_r25 N_7_M7_g x_PM_CLKGATETST_X8%7_6 57.72
R_x_PM_CLKGATETST_X8%7_r26 x_PM_CLKGATETST_X8%7_18 x_PM_CLKGATETST_X8%7_5 4.56151
R_x_PM_CLKGATETST_X8%7_r27 N_7_M7_g x_PM_CLKGATETST_X8%7_5 33.54
R_x_PM_CLKGATETST_X8%7_r28 x_PM_CLKGATETST_X8%7_18 x_PM_CLKGATETST_X8%7_VSS 4.56151
R_x_PM_CLKGATETST_X8%7_r29 N_7_M20_g x_PM_CLKGATETST_X8%7_VSS 33.54
C_x_PM_CLKGATETST_X8%8_c0 VSS N_8_M7_s 1.77632e-17
C_x_PM_CLKGATETST_X8%8_c1 VSS x_PM_CLKGATETST_X8%8_17 4.64245e-17
C_x_PM_CLKGATETST_X8%8_c2 VSS x_PM_CLKGATETST_X8%8_14 8.95037e-18
C_x_PM_CLKGATETST_X8%8_c3 VSS x_PM_CLKGATETST_X8%8_11 1.57469e-16
C_x_PM_CLKGATETST_X8%8_c4 VSS N_8_M20_s 1.83988e-17
C_x_PM_CLKGATETST_X8%8_c5 VSS N_8_M5_g 8.2866e-17
C_x_PM_CLKGATETST_X8%8_c6 VSS N_8_M18_g 3.61224e-17
R_x_PM_CLKGATETST_X8%8_r7 x_PM_CLKGATETST_X8%8_22 x_PM_CLKGATETST_X8%8_21 0.167071
R_x_PM_CLKGATETST_X8%8_r8 x_PM_CLKGATETST_X8%8_17 N_8_M7_s 0.297071
R_x_PM_CLKGATETST_X8%8_r9 x_PM_CLKGATETST_X8%8_17 x_PM_CLKGATETST_X8%8_22 1.38429
R_x_PM_CLKGATETST_X8%8_r10 x_PM_CLKGATETST_X8%8_29 x_PM_CLKGATETST_X8%8_14 4.7687
R_x_PM_CLKGATETST_X8%8_r11 x_PM_CLKGATETST_X8%8_28 x_PM_CLKGATETST_X8%8_14 4.7687
R_x_PM_CLKGATETST_X8%8_r12 x_PM_CLKGATETST_X8%8_14 x_PM_CLKGATETST_X8%8_12 25.0012
R_x_PM_CLKGATETST_X8%8_r13 x_PM_CLKGATETST_X8%8_21 x_PM_CLKGATETST_X8%8_11 0.095
R_x_PM_CLKGATETST_X8%8_r14 x_PM_CLKGATETST_X8%8_12 x_PM_CLKGATETST_X8%8_11 2.13071
R_x_PM_CLKGATETST_X8%8_r15 x_PM_CLKGATETST_X8%8_21 N_8_M20_s 0.13
R_x_PM_CLKGATETST_X8%8_r16 N_8_M5_g x_PM_CLKGATETST_X8%8_29 91.26
R_x_PM_CLKGATETST_X8%8_r17 N_8_M18_g x_PM_CLKGATETST_X8%8_28 27.3
C_x_PM_CLKGATETST_X8%CK_c0 VSS x_PM_CLKGATETST_X8%CK_30 6.84583e-18
C_x_PM_CLKGATETST_X8%CK_c1 VSS x_PM_CLKGATETST_X8%CK_20 3.86303e-17
C_x_PM_CLKGATETST_X8%CK_c2 VSS x_PM_CLKGATETST_X8%CK_19 5.63932e-18
C_x_PM_CLKGATETST_X8%CK_c3 VSS N_CK_M9_g 7.15417e-17
C_x_PM_CLKGATETST_X8%CK_c4 VSS N_CK_M22_g 6.86827e-17
C_x_PM_CLKGATETST_X8%CK_c5 VSS x_PM_CLKGATETST_X8%CK_9 2.45042e-17
C_x_PM_CLKGATETST_X8%CK_c6 VSS N_CK_M8_g 5.24785e-17
C_x_PM_CLKGATETST_X8%CK_c7 VSS N_CK_M21_g 3.41469e-17
R_x_PM_CLKGATETST_X8%CK_r8 x_PM_CLKGATETST_X8%CK_30 x_PM_CLKGATETST_X8%CK_29 2.93445
R_x_PM_CLKGATETST_X8%CK_r9 x_PM_CLKGATETST_X8%CK_29 x_PM_CLKGATETST_X8%CK_22 2.34
R_x_PM_CLKGATETST_X8%CK_r10 x_PM_CLKGATETST_X8%CK_22 x_PM_CLKGATETST_X8%CK_20 25.0012
R_x_PM_CLKGATETST_X8%CK_r11 CK x_PM_CLKGATETST_X8%CK_20 0.083125
R_x_PM_CLKGATETST_X8%CK_r12 x_PM_CLKGATETST_X8%CK_19 x_PM_CLKGATETST_X8%CK_15 3.83331
R_x_PM_CLKGATETST_X8%CK_r13 N_CK_M9_g x_PM_CLKGATETST_X8%CK_15 47.19
R_x_PM_CLKGATETST_X8%CK_r14 x_PM_CLKGATETST_X8%CK_19 x_PM_CLKGATETST_X8%CK_11 3.83331
R_x_PM_CLKGATETST_X8%CK_r15 N_CK_M22_g x_PM_CLKGATETST_X8%CK_11 42.12
R_x_PM_CLKGATETST_X8%CK_r16 x_PM_CLKGATETST_X8%CK_19 x_PM_CLKGATETST_X8%CK_9 0.444357
R_x_PM_CLKGATETST_X8%CK_r17 x_PM_CLKGATETST_X8%CK_30 x_PM_CLKGATETST_X8%CK_9 37.7
R_x_PM_CLKGATETST_X8%CK_r18 x_PM_CLKGATETST_X8%CK_29 x_PM_CLKGATETST_X8%CK_5 1.95
R_x_PM_CLKGATETST_X8%CK_r19 N_CK_M8_g x_PM_CLKGATETST_X8%CK_5 45.24
R_x_PM_CLKGATETST_X8%CK_r20 x_PM_CLKGATETST_X8%CK_29 x_PM_CLKGATETST_X8%CK_VSS 1.95
R_x_PM_CLKGATETST_X8%CK_r21 N_CK_M21_g x_PM_CLKGATETST_X8%CK_VSS 21.84
C_x_PM_CLKGATETST_X8%10_c0 VSS x_PM_CLKGATETST_X8%10_44 1.35725e-17
C_x_PM_CLKGATETST_X8%10_c1 VSS x_PM_CLKGATETST_X8%10_42 6.33684e-18
C_x_PM_CLKGATETST_X8%10_c2 VSS x_PM_CLKGATETST_X8%10_40 5.72215e-17
C_x_PM_CLKGATETST_X8%10_c3 VSS x_PM_CLKGATETST_X8%10_35 5.36279e-17
C_x_PM_CLKGATETST_X8%10_c4 VSS N_10_M8_d 1.1509e-17
C_x_PM_CLKGATETST_X8%10_c5 VSS x_PM_CLKGATETST_X8%10_30 4.32915e-18
C_x_PM_CLKGATETST_X8%10_c6 VSS N_10_M21_d 3.31327e-17
C_x_PM_CLKGATETST_X8%10_c7 VSS x_PM_CLKGATETST_X8%10_21 1.2608e-17
C_x_PM_CLKGATETST_X8%10_c8 VSS x_PM_CLKGATETST_X8%10_19 6.05825e-17
C_x_PM_CLKGATETST_X8%10_c9 VSS N_10_M19_g 1.3633e-16
C_x_PM_CLKGATETST_X8%10_c10 VSS N_10_M4_g 7.78859e-17
C_x_PM_CLKGATETST_X8%10_c11 VSS x_PM_CLKGATETST_X8%10_8 6.21547e-18
C_x_PM_CLKGATETST_X8%10_c12 VSS x_PM_CLKGATETST_X8%10_7 2.50004e-17
C_x_PM_CLKGATETST_X8%10_c13 VSS x_PM_CLKGATETST_X8%10_6 6.3129e-18
C_x_PM_CLKGATETST_X8%10_c14 VSS x_PM_CLKGATETST_X8%10_5 5.92837e-17
C_x_PM_CLKGATETST_X8%10_c15 VSS N_10_M16_g 5.29547e-17
R_x_PM_CLKGATETST_X8%10_r16 x_PM_CLKGATETST_X8%10_38 x_PM_CLKGATETST_X8%10_44 4.42
R_x_PM_CLKGATETST_X8%10_r17 x_PM_CLKGATETST_X8%10_38 x_PM_CLKGATETST_X8%10_36 25.0012
R_x_PM_CLKGATETST_X8%10_r18 x_PM_CLKGATETST_X8%10_40 x_PM_CLKGATETST_X8%10_36 0.135714
R_x_PM_CLKGATETST_X8%10_r19 x_PM_CLKGATETST_X8%10_35 x_PM_CLKGATETST_X8%10_42 1.76429
R_x_PM_CLKGATETST_X8%10_r20 x_PM_CLKGATETST_X8%10_35 x_PM_CLKGATETST_X8%10_30 0.202958
R_x_PM_CLKGATETST_X8%10_r21 N_10_M8_d x_PM_CLKGATETST_X8%10_30 0.111765
R_x_PM_CLKGATETST_X8%10_r22 x_PM_CLKGATETST_X8%10_42 x_PM_CLKGATETST_X8%10_27 0.202958
R_x_PM_CLKGATETST_X8%10_r23 x_PM_CLKGATETST_X8%10_40 x_PM_CLKGATETST_X8%10_26 0.095
R_x_PM_CLKGATETST_X8%10_r24 N_10_M21_d x_PM_CLKGATETST_X8%10_27 0.111765
R_x_PM_CLKGATETST_X8%10_r25 N_10_M21_d x_PM_CLKGATETST_X8%10_26 0.726471
R_x_PM_CLKGATETST_X8%10_r26 x_PM_CLKGATETST_X8%10_23 x_PM_CLKGATETST_X8%10_21 11.7
R_x_PM_CLKGATETST_X8%10_r27 x_PM_CLKGATETST_X8%10_23 x_PM_CLKGATETST_X8%10_20 1.95
R_x_PM_CLKGATETST_X8%10_r28 x_PM_CLKGATETST_X8%10_44 x_PM_CLKGATETST_X8%10_19 1.95
R_x_PM_CLKGATETST_X8%10_r29 x_PM_CLKGATETST_X8%10_20 x_PM_CLKGATETST_X8%10_19 85.02
R_x_PM_CLKGATETST_X8%10_r30 N_10_M6_g N_10_M19_g 130.26
R_x_PM_CLKGATETST_X8%10_r31 x_PM_CLKGATETST_X8%10_23 x_PM_CLKGATETST_X8%10_13 3.9
R_x_PM_CLKGATETST_X8%10_r32 N_10_M19_g x_PM_CLKGATETST_X8%10_13 21.84
R_x_PM_CLKGATETST_X8%10_r33 N_10_M4_g x_PM_CLKGATETST_X8%10_9 77.22
R_x_PM_CLKGATETST_X8%10_r34 x_PM_CLKGATETST_X8%10_9 x_PM_CLKGATETST_X8%10_7 4.35808
R_x_PM_CLKGATETST_X8%10_r35 x_PM_CLKGATETST_X8%10_8 x_PM_CLKGATETST_X8%10_7 21.84
R_x_PM_CLKGATETST_X8%10_r36 x_PM_CLKGATETST_X8%10_21 x_PM_CLKGATETST_X8%10_5 1.95
R_x_PM_CLKGATETST_X8%10_r37 x_PM_CLKGATETST_X8%10_6 x_PM_CLKGATETST_X8%10_5 81.12
R_x_PM_CLKGATETST_X8%10_r38 x_PM_CLKGATETST_X8%10_8 x_PM_CLKGATETST_X8%10_2 4.35808
R_x_PM_CLKGATETST_X8%10_r39 N_10_M16_g x_PM_CLKGATETST_X8%10_2 45.24
R_x_PM_CLKGATETST_X8%10_r40 x_PM_CLKGATETST_X8%10_6 x_PM_CLKGATETST_X8%10_VSS 4.35808
R_x_PM_CLKGATETST_X8%10_r41 N_10_M16_g x_PM_CLKGATETST_X8%10_VSS 33.54
C_x_PM_CLKGATETST_X8%11_c0 VSS x_PM_CLKGATETST_X8%11_39 5.62331e-18
C_x_PM_CLKGATETST_X8%11_c1 VSS x_PM_CLKGATETST_X8%11_35 3.15366e-17
C_x_PM_CLKGATETST_X8%11_c2 VSS x_PM_CLKGATETST_X8%11_34 3.63528e-17
C_x_PM_CLKGATETST_X8%11_c3 VSS x_PM_CLKGATETST_X8%11_32 8.53474e-17
C_x_PM_CLKGATETST_X8%11_c4 VSS x_PM_CLKGATETST_X8%11_26 3.16878e-17
C_x_PM_CLKGATETST_X8%11_c5 VSS x_PM_CLKGATETST_X8%11_19 4.42905e-18
C_x_PM_CLKGATETST_X8%11_c6 VSS N_11_M12_g 3.77728e-17
C_x_PM_CLKGATETST_X8%11_c7 VSS N_11_M25_g 4.13002e-17
C_x_PM_CLKGATETST_X8%11_c8 VSS x_PM_CLKGATETST_X8%11_9 1.05571e-17
C_x_PM_CLKGATETST_X8%11_c9 VSS N_11_M11_g 3.34272e-17
C_x_PM_CLKGATETST_X8%11_c10 VSS N_11_M24_g 3.83462e-17
R_x_PM_CLKGATETST_X8%11_r11 N_11_M9_d x_PM_CLKGATETST_X8%11_34 0.298571
R_x_PM_CLKGATETST_X8%11_r12 x_PM_CLKGATETST_X8%11_35 x_PM_CLKGATETST_X8%11_34 0.217333
R_x_PM_CLKGATETST_X8%11_r13 x_PM_CLKGATETST_X8%11_32 N_11_M22_s 0.316667
R_x_PM_CLKGATETST_X8%11_r14 x_PM_CLKGATETST_X8%11_39 x_PM_CLKGATETST_X8%11_26 25.0012
R_x_PM_CLKGATETST_X8%11_r15 x_PM_CLKGATETST_X8%11_34 x_PM_CLKGATETST_X8%11_24 0.095
R_x_PM_CLKGATETST_X8%11_r16 x_PM_CLKGATETST_X8%11_26 x_PM_CLKGATETST_X8%11_24 1.12643
R_x_PM_CLKGATETST_X8%11_r17 x_PM_CLKGATETST_X8%11_32 x_PM_CLKGATETST_X8%11_22 0.095
R_x_PM_CLKGATETST_X8%11_r18 x_PM_CLKGATETST_X8%11_35 x_PM_CLKGATETST_X8%11_22 1.46571
R_x_PM_CLKGATETST_X8%11_r19 x_PM_CLKGATETST_X8%11_19 x_PM_CLKGATETST_X8%11_15 4.56151
R_x_PM_CLKGATETST_X8%11_r20 N_11_M12_g x_PM_CLKGATETST_X8%11_15 38.22
R_x_PM_CLKGATETST_X8%11_r21 x_PM_CLKGATETST_X8%11_19 x_PM_CLKGATETST_X8%11_11 4.56151
R_x_PM_CLKGATETST_X8%11_r22 N_11_M25_g x_PM_CLKGATETST_X8%11_11 43.68
R_x_PM_CLKGATETST_X8%11_r23 x_PM_CLKGATETST_X8%11_39 x_PM_CLKGATETST_X8%11_10 0.043368
R_x_PM_CLKGATETST_X8%11_r24 x_PM_CLKGATETST_X8%11_19 x_PM_CLKGATETST_X8%11_9 0.043368
R_x_PM_CLKGATETST_X8%11_r25 x_PM_CLKGATETST_X8%11_10 x_PM_CLKGATETST_X8%11_9 14.56
R_x_PM_CLKGATETST_X8%11_r26 x_PM_CLKGATETST_X8%11_39 x_PM_CLKGATETST_X8%11_5 4.56151
R_x_PM_CLKGATETST_X8%11_r27 N_11_M11_g x_PM_CLKGATETST_X8%11_5 38.22
R_x_PM_CLKGATETST_X8%11_r28 x_PM_CLKGATETST_X8%11_39 x_PM_CLKGATETST_X8%11_VSS 4.56151
R_x_PM_CLKGATETST_X8%11_r29 N_11_M24_g x_PM_CLKGATETST_X8%11_VSS 43.68
C_x_PM_CLKGATETST_X8%GCK_c0 VSS GCK 2.74755e-17
C_x_PM_CLKGATETST_X8%GCK_c1 VSS x_PM_CLKGATETST_X8%GCK_7 2.09654e-17
C_x_PM_CLKGATETST_X8%GCK_c2 VSS x_PM_CLKGATETST_X8%GCK_3 2.08806e-17
R_x_PM_CLKGATETST_X8%GCK_r3 GCK x_PM_CLKGATETST_X8%GCK_12 0.325714
R_x_PM_CLKGATETST_X8%GCK_r4 GCK x_PM_CLKGATETST_X8%GCK_11 0.977143
R_x_PM_CLKGATETST_X8%GCK_r5 x_PM_CLKGATETST_X8%GCK_12 x_PM_CLKGATETST_X8%GCK_7 0.212317
R_x_PM_CLKGATETST_X8%GCK_r6 N_GCK_M11_d x_PM_CLKGATETST_X8%GCK_7 0.339286
R_x_PM_CLKGATETST_X8%GCK_r7 x_PM_CLKGATETST_X8%GCK_11 x_PM_CLKGATETST_X8%GCK_3 0.212317
R_x_PM_CLKGATETST_X8%GCK_r8 N_GCK_M24_d x_PM_CLKGATETST_X8%GCK_3 0.339286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X1.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X1 VSS VDD E CK GCK
*.PININFO VSS:B VDD:B E:I CK:I GCK:O
M_M10 N_VDD_M0_d N_4_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 11 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 N_4_M2_d N_7_M2_g 11 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M13 12 N_5_M3_g N_4_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VDD_M4_d N_E_M4_g 12 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_5_M5_d N_7_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_9_M7_d N_3_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_VDD_M8_d N_CK_M8_g N_9_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_GCK_M9_d N_9_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M0 N_VSS_M10_d N_4_M10_g N_3_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 13 N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_4_M12_d N_5_M12_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 14 N_7_M13_g N_4_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M14_d N_E_M14_g 14 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_5_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M16_d N_CK_M16_g N_7_M16_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 15 N_3_M17_g N_VSS_M16_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_9_M18_d N_CK_M18_g 15 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 N_GCK_M19_d N_9_M19_g N_VSS_M19_s VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_CLKGATE_X1%VSS_c0 VSS x_PM_CLKGATE_X1%VSS_28 7.39509e-17
C_x_PM_CLKGATE_X1%VSS_c1 VSS x_PM_CLKGATE_X1%VSS_27 5.72329e-18
C_x_PM_CLKGATE_X1%VSS_c2 VSS x_PM_CLKGATE_X1%VSS_26 8.86015e-18
C_x_PM_CLKGATE_X1%VSS_c3 VSS x_PM_CLKGATE_X1%VSS_25 2.77839e-17
C_x_PM_CLKGATE_X1%VSS_c4 VSS x_PM_CLKGATE_X1%VSS_21 1.92195e-17
C_x_PM_CLKGATE_X1%VSS_c5 VSS N_VSS_M16_d 3.25778e-17
C_x_PM_CLKGATE_X1%VSS_c6 VSS x_PM_CLKGATE_X1%VSS_13 3.09522e-17
C_x_PM_CLKGATE_X1%VSS_c7 VSS x_PM_CLKGATE_X1%VSS_12 2.01013e-17
C_x_PM_CLKGATE_X1%VSS_c8 VSS x_PM_CLKGATE_X1%VSS_9 5.32858e-17
C_x_PM_CLKGATE_X1%VSS_c9 VSS x_PM_CLKGATE_X1%VSS_8 2.66882e-17
R_x_PM_CLKGATE_X1%VSS_r10 N_VSS_M19_s x_PM_CLKGATE_X1%VSS_28 0.471481
R_x_PM_CLKGATE_X1%VSS_r11 x_PM_CLKGATE_X1%VSS_27 x_PM_CLKGATE_X1%VSS_22 0.132285
R_x_PM_CLKGATE_X1%VSS_r12 x_PM_CLKGATE_X1%VSS_28 x_PM_CLKGATE_X1%VSS_21 0.095
R_x_PM_CLKGATE_X1%VSS_r13 x_PM_CLKGATE_X1%VSS_22 x_PM_CLKGATE_X1%VSS_21 0.581176
R_x_PM_CLKGATE_X1%VSS_r14 x_PM_CLKGATE_X1%VSS_27 x_PM_CLKGATE_X1%VSS_17 0.0680382
R_x_PM_CLKGATE_X1%VSS_r15 N_VSS_M16_d x_PM_CLKGATE_X1%VSS_17 0.823333
R_x_PM_CLKGATE_X1%VSS_r16 x_PM_CLKGATE_X1%VSS_26 x_PM_CLKGATE_X1%VSS_14 0.132285
R_x_PM_CLKGATE_X1%VSS_r17 VSS x_PM_CLKGATE_X1%VSS_14 0.100588
R_x_PM_CLKGATE_X1%VSS_r18 x_PM_CLKGATE_X1%VSS_27 x_PM_CLKGATE_X1%VSS_13 0.132285
R_x_PM_CLKGATE_X1%VSS_r19 VSS x_PM_CLKGATE_X1%VSS_13 0.827059
R_x_PM_CLKGATE_X1%VSS_r20 x_PM_CLKGATE_X1%VSS_26 x_PM_CLKGATE_X1%VSS_12 0.0680382
R_x_PM_CLKGATE_X1%VSS_r21 x_PM_CLKGATE_X1%VSS_12 N_VSS_M14_d 0.403583
R_x_PM_CLKGATE_X1%VSS_r22 x_PM_CLKGATE_X1%VSS_25 x_PM_CLKGATE_X1%VSS_10 0.132285
R_x_PM_CLKGATE_X1%VSS_r23 x_PM_CLKGATE_X1%VSS_26 x_PM_CLKGATE_X1%VSS_9 0.132285
R_x_PM_CLKGATE_X1%VSS_r24 x_PM_CLKGATE_X1%VSS_10 x_PM_CLKGATE_X1%VSS_9 1.39706
R_x_PM_CLKGATE_X1%VSS_r25 x_PM_CLKGATE_X1%VSS_25 x_PM_CLKGATE_X1%VSS_8 0.0680382
R_x_PM_CLKGATE_X1%VSS_r26 x_PM_CLKGATE_X1%VSS_8 N_VSS_M10_d 0.403583
C_x_PM_CLKGATE_X1%VDD_c0 VSS x_PM_CLKGATE_X1%VDD_32 3.65605e-17
C_x_PM_CLKGATE_X1%VDD_c1 VSS x_PM_CLKGATE_X1%VDD_31 8.85742e-18
C_x_PM_CLKGATE_X1%VDD_c2 VSS x_PM_CLKGATE_X1%VDD_30 8.93987e-18
C_x_PM_CLKGATE_X1%VDD_c3 VSS x_PM_CLKGATE_X1%VDD_29 6.41071e-18
C_x_PM_CLKGATE_X1%VDD_c4 VSS x_PM_CLKGATE_X1%VDD_26 3.39602e-17
C_x_PM_CLKGATE_X1%VDD_c5 VSS x_PM_CLKGATE_X1%VDD_23 1.6181e-17
C_x_PM_CLKGATE_X1%VDD_c6 VSS x_PM_CLKGATE_X1%VDD_22 1.57185e-17
C_x_PM_CLKGATE_X1%VDD_c7 VSS x_PM_CLKGATE_X1%VDD_19 4.04368e-17
C_x_PM_CLKGATE_X1%VDD_c8 VSS N_VDD_M4_d 3.39789e-17
C_x_PM_CLKGATE_X1%VDD_c9 VSS x_PM_CLKGATE_X1%VDD_13 6.47238e-17
C_x_PM_CLKGATE_X1%VDD_c10 VSS N_VDD_M0_d 3.27263e-17
C_x_PM_CLKGATE_X1%VDD_c11 VSS x_PM_CLKGATE_X1%VDD_5 2.027e-17
R_x_PM_CLKGATE_X1%VDD_r12 x_PM_CLKGATE_X1%VDD_32 x_PM_CLKGATE_X1%VDD_26 0.0680382
R_x_PM_CLKGATE_X1%VDD_r13 x_PM_CLKGATE_X1%VDD_26 N_VDD_M8_d 0.403583
R_x_PM_CLKGATE_X1%VDD_r14 x_PM_CLKGATE_X1%VDD_31 x_PM_CLKGATE_X1%VDD_24 0.132285
R_x_PM_CLKGATE_X1%VDD_r15 x_PM_CLKGATE_X1%VDD_32 x_PM_CLKGATE_X1%VDD_23 0.132285
R_x_PM_CLKGATE_X1%VDD_r16 x_PM_CLKGATE_X1%VDD_24 x_PM_CLKGATE_X1%VDD_23 0.536471
R_x_PM_CLKGATE_X1%VDD_r17 x_PM_CLKGATE_X1%VDD_31 x_PM_CLKGATE_X1%VDD_22 0.0680382
R_x_PM_CLKGATE_X1%VDD_r18 x_PM_CLKGATE_X1%VDD_22 N_VDD_M6_d 0.403583
R_x_PM_CLKGATE_X1%VDD_r19 x_PM_CLKGATE_X1%VDD_30 x_PM_CLKGATE_X1%VDD_20 0.132285
R_x_PM_CLKGATE_X1%VDD_r20 x_PM_CLKGATE_X1%VDD_31 x_PM_CLKGATE_X1%VDD_19 0.132285
R_x_PM_CLKGATE_X1%VDD_r21 x_PM_CLKGATE_X1%VDD_20 x_PM_CLKGATE_X1%VDD_19 0.927647
R_x_PM_CLKGATE_X1%VDD_r22 x_PM_CLKGATE_X1%VDD_30 x_PM_CLKGATE_X1%VDD_15 0.0680382
R_x_PM_CLKGATE_X1%VDD_r23 N_VDD_M4_d x_PM_CLKGATE_X1%VDD_15 0.823333
R_x_PM_CLKGATE_X1%VDD_r24 x_PM_CLKGATE_X1%VDD_29 x_PM_CLKGATE_X1%VDD_14 0.132285
R_x_PM_CLKGATE_X1%VDD_r25 x_PM_CLKGATE_X1%VDD_30 x_PM_CLKGATE_X1%VDD_13 0.132285
R_x_PM_CLKGATE_X1%VDD_r26 x_PM_CLKGATE_X1%VDD_14 x_PM_CLKGATE_X1%VDD_13 1.38588
R_x_PM_CLKGATE_X1%VDD_r27 x_PM_CLKGATE_X1%VDD_29 x_PM_CLKGATE_X1%VDD_9 0.0680382
R_x_PM_CLKGATE_X1%VDD_r28 N_VDD_M0_d x_PM_CLKGATE_X1%VDD_9 0.823333
R_x_PM_CLKGATE_X1%VDD_r29 x_PM_CLKGATE_X1%VDD_29 x_PM_CLKGATE_X1%VDD_5 0.132285
R_x_PM_CLKGATE_X1%VDD_r30 VDD x_PM_CLKGATE_X1%VDD_5 0.229118
C_x_PM_CLKGATE_X1%3_c0 VSS x_PM_CLKGATE_X1%3_36 8.37926e-18
C_x_PM_CLKGATE_X1%3_c1 VSS x_PM_CLKGATE_X1%3_34 2.30396e-18
C_x_PM_CLKGATE_X1%3_c2 VSS x_PM_CLKGATE_X1%3_31 6.3356e-17
C_x_PM_CLKGATE_X1%3_c3 VSS N_3_M0_s 9.80948e-18
C_x_PM_CLKGATE_X1%3_c4 VSS x_PM_CLKGATE_X1%3_25 2.97351e-18
C_x_PM_CLKGATE_X1%3_c5 VSS x_PM_CLKGATE_X1%3_24 3.39587e-17
C_x_PM_CLKGATE_X1%3_c6 VSS N_3_M10_s 1.62686e-17
C_x_PM_CLKGATE_X1%3_c7 VSS N_3_M17_g 1.0594e-16
C_x_PM_CLKGATE_X1%3_c8 VSS x_PM_CLKGATE_X1%3_10 5.10473e-18
C_x_PM_CLKGATE_X1%3_c9 VSS x_PM_CLKGATE_X1%3_9 1.65276e-16
C_x_PM_CLKGATE_X1%3_c10 VSS N_3_M1_g 7.98489e-17
C_x_PM_CLKGATE_X1%3_c11 VSS N_3_M11_g 2.78268e-17
R_x_PM_CLKGATE_X1%3_r12 x_PM_CLKGATE_X1%3_37 x_PM_CLKGATE_X1%3_36 4.7687
R_x_PM_CLKGATE_X1%3_r13 x_PM_CLKGATE_X1%3_36 x_PM_CLKGATE_X1%3_31 25.0012
R_x_PM_CLKGATE_X1%3_r14 x_PM_CLKGATE_X1%3_34 x_PM_CLKGATE_X1%3_29 0.0495914
R_x_PM_CLKGATE_X1%3_r15 x_PM_CLKGATE_X1%3_31 x_PM_CLKGATE_X1%3_29 1.425
R_x_PM_CLKGATE_X1%3_r16 N_3_M0_s x_PM_CLKGATE_X1%3_25 0.130625
R_x_PM_CLKGATE_X1%3_r17 x_PM_CLKGATE_X1%3_24 x_PM_CLKGATE_X1%3_25 0.196927
R_x_PM_CLKGATE_X1%3_r18 x_PM_CLKGATE_X1%3_34 x_PM_CLKGATE_X1%3_23 0.151873
R_x_PM_CLKGATE_X1%3_r19 x_PM_CLKGATE_X1%3_24 x_PM_CLKGATE_X1%3_23 1.33
R_x_PM_CLKGATE_X1%3_r20 x_PM_CLKGATE_X1%3_34 x_PM_CLKGATE_X1%3_19 0.151873
R_x_PM_CLKGATE_X1%3_r21 N_3_M10_s x_PM_CLKGATE_X1%3_19 0.415625
R_x_PM_CLKGATE_X1%3_r22 N_3_M7_g N_3_M17_g 96.72
R_x_PM_CLKGATE_X1%3_r23 N_3_M7_g x_PM_CLKGATE_X1%3_11 40.56
R_x_PM_CLKGATE_X1%3_r24 x_PM_CLKGATE_X1%3_11 x_PM_CLKGATE_X1%3_9 4.35808
R_x_PM_CLKGATE_X1%3_r25 x_PM_CLKGATE_X1%3_10 x_PM_CLKGATE_X1%3_9 195.78
R_x_PM_CLKGATE_X1%3_r26 x_PM_CLKGATE_X1%3_10 x_PM_CLKGATE_X1%3_6 4.35808
R_x_PM_CLKGATE_X1%3_r27 N_3_M1_g x_PM_CLKGATE_X1%3_6 60.06
R_x_PM_CLKGATE_X1%3_r28 x_PM_CLKGATE_X1%3_5 x_PM_CLKGATE_X1%3_36 4.7687
R_x_PM_CLKGATE_X1%3_r29 N_3_M1_g x_PM_CLKGATE_X1%3_5 63.18
R_x_PM_CLKGATE_X1%3_r30 N_3_M11_g x_PM_CLKGATE_X1%3_37 21.84
C_x_PM_CLKGATE_X1%4_c0 VSS x_PM_CLKGATE_X1%4_23 4.49093e-17
C_x_PM_CLKGATE_X1%4_c1 VSS x_PM_CLKGATE_X1%4_17 2.3823e-17
C_x_PM_CLKGATE_X1%4_c2 VSS x_PM_CLKGATE_X1%4_14 1.14049e-17
C_x_PM_CLKGATE_X1%4_c3 VSS x_PM_CLKGATE_X1%4_11 1.0223e-16
C_x_PM_CLKGATE_X1%4_c4 VSS N_4_M12_d 2.39921e-17
C_x_PM_CLKGATE_X1%4_c5 VSS N_4_M0_g 4.29754e-17
C_x_PM_CLKGATE_X1%4_c6 VSS N_4_M10_g 5.2213e-17
R_x_PM_CLKGATE_X1%4_r7 N_4_M2_d x_PM_CLKGATE_X1%4_23 0.685048
R_x_PM_CLKGATE_X1%4_r8 x_PM_CLKGATE_X1%4_23 x_PM_CLKGATE_X1%4_17 0.298035
R_x_PM_CLKGATE_X1%4_r9 x_PM_CLKGATE_X1%4_18 x_PM_CLKGATE_X1%4_16 0.095
R_x_PM_CLKGATE_X1%4_r10 x_PM_CLKGATE_X1%4_17 x_PM_CLKGATE_X1%4_16 0.895714
R_x_PM_CLKGATE_X1%4_r11 x_PM_CLKGATE_X1%4_14 x_PM_CLKGATE_X1%4_26 2.86
R_x_PM_CLKGATE_X1%4_r12 x_PM_CLKGATE_X1%4_14 x_PM_CLKGATE_X1%4_12 25.0012
R_x_PM_CLKGATE_X1%4_r13 x_PM_CLKGATE_X1%4_23 x_PM_CLKGATE_X1%4_11 0.125928
R_x_PM_CLKGATE_X1%4_r14 x_PM_CLKGATE_X1%4_12 x_PM_CLKGATE_X1%4_11 0.992222
R_x_PM_CLKGATE_X1%4_r15 N_4_M12_d x_PM_CLKGATE_X1%4_18 0.161852
R_x_PM_CLKGATE_X1%4_r16 x_PM_CLKGATE_X1%4_26 x_PM_CLKGATE_X1%4_5 1.95
R_x_PM_CLKGATE_X1%4_r17 N_4_M0_g x_PM_CLKGATE_X1%4_5 35.88
R_x_PM_CLKGATE_X1%4_r18 x_PM_CLKGATE_X1%4_26 x_PM_CLKGATE_X1%4_VSS 1.95
R_x_PM_CLKGATE_X1%4_r19 N_4_M10_g x_PM_CLKGATE_X1%4_VSS 49.14
C_x_PM_CLKGATE_X1%5_c0 VSS x_PM_CLKGATE_X1%5_35 3.60267e-18
C_x_PM_CLKGATE_X1%5_c1 VSS N_5_M5_d 3.42484e-17
C_x_PM_CLKGATE_X1%5_c2 VSS x_PM_CLKGATE_X1%5_29 2.23565e-17
C_x_PM_CLKGATE_X1%5_c3 VSS x_PM_CLKGATE_X1%5_23 8.72437e-18
C_x_PM_CLKGATE_X1%5_c4 VSS x_PM_CLKGATE_X1%5_21 3.60481e-17
C_x_PM_CLKGATE_X1%5_c5 VSS x_PM_CLKGATE_X1%5_18 9.19101e-18
C_x_PM_CLKGATE_X1%5_c6 VSS x_PM_CLKGATE_X1%5_15 6.83739e-17
C_x_PM_CLKGATE_X1%5_c7 VSS N_5_M15_d 1.46041e-17
C_x_PM_CLKGATE_X1%5_c8 VSS N_5_M3_g 4.23019e-17
C_x_PM_CLKGATE_X1%5_c9 VSS x_PM_CLKGATE_X1%5_6 7.22706e-18
C_x_PM_CLKGATE_X1%5_c10 VSS x_PM_CLKGATE_X1%5_5 2.37232e-17
C_x_PM_CLKGATE_X1%5_c11 VSS N_5_M12_g 4.56887e-17
R_x_PM_CLKGATE_X1%5_r12 x_PM_CLKGATE_X1%5_23 N_5_M5_d 0.29113
R_x_PM_CLKGATE_X1%5_r13 x_PM_CLKGATE_X1%5_29 x_PM_CLKGATE_X1%5_22 0.160909
R_x_PM_CLKGATE_X1%5_r14 x_PM_CLKGATE_X1%5_23 x_PM_CLKGATE_X1%5_22 0.352857
R_x_PM_CLKGATE_X1%5_r15 x_PM_CLKGATE_X1%5_29 x_PM_CLKGATE_X1%5_21 0.160909
R_x_PM_CLKGATE_X1%5_r16 x_PM_CLKGATE_X1%5_24 x_PM_CLKGATE_X1%5_20 0.095
R_x_PM_CLKGATE_X1%5_r17 x_PM_CLKGATE_X1%5_21 x_PM_CLKGATE_X1%5_20 1.27571
R_x_PM_CLKGATE_X1%5_r18 x_PM_CLKGATE_X1%5_35 x_PM_CLKGATE_X1%5_18 4.7687
R_x_PM_CLKGATE_X1%5_r19 x_PM_CLKGATE_X1%5_18 x_PM_CLKGATE_X1%5_16 25.0012
R_x_PM_CLKGATE_X1%5_r20 x_PM_CLKGATE_X1%5_29 x_PM_CLKGATE_X1%5_15 0.0418175
R_x_PM_CLKGATE_X1%5_r21 x_PM_CLKGATE_X1%5_16 x_PM_CLKGATE_X1%5_15 2.13071
R_x_PM_CLKGATE_X1%5_r22 N_5_M15_d x_PM_CLKGATE_X1%5_24 0.176429
R_x_PM_CLKGATE_X1%5_r23 N_5_M3_g x_PM_CLKGATE_X1%5_35 35.88
R_x_PM_CLKGATE_X1%5_r24 x_PM_CLKGATE_X1%5_18 x_PM_CLKGATE_X1%5_7 9.1
R_x_PM_CLKGATE_X1%5_r25 x_PM_CLKGATE_X1%5_7 x_PM_CLKGATE_X1%5_5 4.58872
R_x_PM_CLKGATE_X1%5_r26 x_PM_CLKGATE_X1%5_6 x_PM_CLKGATE_X1%5_5 21.84
R_x_PM_CLKGATE_X1%5_r27 x_PM_CLKGATE_X1%5_6 x_PM_CLKGATE_X1%5_VSS 4.35808
R_x_PM_CLKGATE_X1%5_r28 N_5_M12_g x_PM_CLKGATE_X1%5_VSS 33.54
C_x_PM_CLKGATE_X1%E_c0 VSS x_PM_CLKGATE_X1%E_14 7.74381e-18
C_x_PM_CLKGATE_X1%E_c1 VSS x_PM_CLKGATE_X1%E_12 4.22801e-17
C_x_PM_CLKGATE_X1%E_c2 VSS N_E_M4_g 6.09714e-17
C_x_PM_CLKGATE_X1%E_c3 VSS N_E_M14_g 2.94537e-17
R_x_PM_CLKGATE_X1%E_r4 x_PM_CLKGATE_X1%E_18 x_PM_CLKGATE_X1%E_14 4.7687
R_x_PM_CLKGATE_X1%E_r5 x_PM_CLKGATE_X1%E_17 x_PM_CLKGATE_X1%E_14 4.7687
R_x_PM_CLKGATE_X1%E_r6 x_PM_CLKGATE_X1%E_14 x_PM_CLKGATE_X1%E_12 25.0012
R_x_PM_CLKGATE_X1%E_r7 x_PM_CLKGATE_X1%E_12 E 0.183214
R_x_PM_CLKGATE_X1%E_r8 N_E_M4_g x_PM_CLKGATE_X1%E_18 61.62
R_x_PM_CLKGATE_X1%E_r9 N_E_M14_g x_PM_CLKGATE_X1%E_17 23.4
C_x_PM_CLKGATE_X1%7_c0 VSS N_7_M6_s 1.79556e-17
C_x_PM_CLKGATE_X1%7_c1 VSS x_PM_CLKGATE_X1%7_31 2.46983e-17
C_x_PM_CLKGATE_X1%7_c2 VSS x_PM_CLKGATE_X1%7_26 3.82364e-17
C_x_PM_CLKGATE_X1%7_c3 VSS x_PM_CLKGATE_X1%7_25 6.33899e-17
C_x_PM_CLKGATE_X1%7_c4 VSS x_PM_CLKGATE_X1%7_22 7.80487e-18
C_x_PM_CLKGATE_X1%7_c5 VSS N_7_M5_g 5.02755e-17
C_x_PM_CLKGATE_X1%7_c6 VSS N_7_M15_g 4.89273e-17
C_x_PM_CLKGATE_X1%7_c7 VSS x_PM_CLKGATE_X1%7_12 6.47474e-18
C_x_PM_CLKGATE_X1%7_c8 VSS x_PM_CLKGATE_X1%7_11 4.03644e-17
C_x_PM_CLKGATE_X1%7_c9 VSS N_7_M13_g 3.70913e-17
C_x_PM_CLKGATE_X1%7_c10 VSS x_PM_CLKGATE_X1%7_6 6.3741e-18
C_x_PM_CLKGATE_X1%7_c11 VSS x_PM_CLKGATE_X1%7_5 6.53208e-17
C_x_PM_CLKGATE_X1%7_c12 VSS N_7_M2_g 5.03163e-17
R_x_PM_CLKGATE_X1%7_r13 x_PM_CLKGATE_X1%7_31 x_PM_CLKGATE_X1%7_29 25.0012
R_x_PM_CLKGATE_X1%7_r14 x_PM_CLKGATE_X1%7_26 N_7_M6_s 0.286607
R_x_PM_CLKGATE_X1%7_r15 x_PM_CLKGATE_X1%7_29 x_PM_CLKGATE_X1%7_25 0.284995
R_x_PM_CLKGATE_X1%7_r16 x_PM_CLKGATE_X1%7_26 x_PM_CLKGATE_X1%7_25 1.05857
R_x_PM_CLKGATE_X1%7_r17 x_PM_CLKGATE_X1%7_29 N_7_M16_s 0.496269
R_x_PM_CLKGATE_X1%7_r18 x_PM_CLKGATE_X1%7_31 x_PM_CLKGATE_X1%7_21 17.42
R_x_PM_CLKGATE_X1%7_r19 x_PM_CLKGATE_X1%7_22 x_PM_CLKGATE_X1%7_21 0.043368
R_x_PM_CLKGATE_X1%7_r20 N_7_M5_g x_PM_CLKGATE_X1%7_18 40.56
R_x_PM_CLKGATE_X1%7_r21 x_PM_CLKGATE_X1%7_22 x_PM_CLKGATE_X1%7_17 4.56151
R_x_PM_CLKGATE_X1%7_r22 N_7_M5_g x_PM_CLKGATE_X1%7_17 41.34
R_x_PM_CLKGATE_X1%7_r23 x_PM_CLKGATE_X1%7_22 x_PM_CLKGATE_X1%7_14 4.56151
R_x_PM_CLKGATE_X1%7_r24 N_7_M15_g x_PM_CLKGATE_X1%7_14 43.68
R_x_PM_CLKGATE_X1%7_r25 N_7_M15_g x_PM_CLKGATE_X1%7_13 33.54
R_x_PM_CLKGATE_X1%7_r26 x_PM_CLKGATE_X1%7_13 x_PM_CLKGATE_X1%7_11 4.35808
R_x_PM_CLKGATE_X1%7_r27 x_PM_CLKGATE_X1%7_12 x_PM_CLKGATE_X1%7_11 51.48
R_x_PM_CLKGATE_X1%7_r28 x_PM_CLKGATE_X1%7_12 x_PM_CLKGATE_X1%7_7 4.35808
R_x_PM_CLKGATE_X1%7_r29 N_7_M13_g x_PM_CLKGATE_X1%7_7 33.54
R_x_PM_CLKGATE_X1%7_r30 x_PM_CLKGATE_X1%7_18 x_PM_CLKGATE_X1%7_5 4.35808
R_x_PM_CLKGATE_X1%7_r31 x_PM_CLKGATE_X1%7_6 x_PM_CLKGATE_X1%7_5 81.12
R_x_PM_CLKGATE_X1%7_r32 x_PM_CLKGATE_X1%7_6 x_PM_CLKGATE_X1%7_VSS 4.35808
R_x_PM_CLKGATE_X1%7_r33 N_7_M2_g x_PM_CLKGATE_X1%7_VSS 40.56
C_x_PM_CLKGATE_X1%CK_c0 VSS x_PM_CLKGATE_X1%CK_26 7.73821e-18
C_x_PM_CLKGATE_X1%CK_c1 VSS CK 4.42797e-17
C_x_PM_CLKGATE_X1%CK_c2 VSS x_PM_CLKGATE_X1%CK_20 1.1004e-17
C_x_PM_CLKGATE_X1%CK_c3 VSS x_PM_CLKGATE_X1%CK_17 2.2629e-17
C_x_PM_CLKGATE_X1%CK_c4 VSS N_CK_M8_g 5.41512e-17
C_x_PM_CLKGATE_X1%CK_c5 VSS N_CK_M18_g 3.28092e-17
C_x_PM_CLKGATE_X1%CK_c6 VSS N_CK_M6_g 5.90442e-17
C_x_PM_CLKGATE_X1%CK_c7 VSS N_CK_M16_g 3.61627e-17
R_x_PM_CLKGATE_X1%CK_r8 x_PM_CLKGATE_X1%CK_33 x_PM_CLKGATE_X1%CK_26 4.7687
R_x_PM_CLKGATE_X1%CK_r9 x_PM_CLKGATE_X1%CK_32 x_PM_CLKGATE_X1%CK_26 4.7687
R_x_PM_CLKGATE_X1%CK_r10 x_PM_CLKGATE_X1%CK_26 x_PM_CLKGATE_X1%CK_24 25.0012
R_x_PM_CLKGATE_X1%CK_r11 x_PM_CLKGATE_X1%CK_24 CK 1.04433
R_x_PM_CLKGATE_X1%CK_r12 x_PM_CLKGATE_X1%CK_20 x_PM_CLKGATE_X1%CK_27 3.9
R_x_PM_CLKGATE_X1%CK_r13 x_PM_CLKGATE_X1%CK_20 x_PM_CLKGATE_X1%CK_18 25.0012
R_x_PM_CLKGATE_X1%CK_r14 CK x_PM_CLKGATE_X1%CK_17 0.169652
R_x_PM_CLKGATE_X1%CK_r15 x_PM_CLKGATE_X1%CK_18 x_PM_CLKGATE_X1%CK_17 0.339286
R_x_PM_CLKGATE_X1%CK_r16 N_CK_M8_g x_PM_CLKGATE_X1%CK_33 54.6
R_x_PM_CLKGATE_X1%CK_r17 N_CK_M18_g x_PM_CLKGATE_X1%CK_32 30.42
R_x_PM_CLKGATE_X1%CK_r18 x_PM_CLKGATE_X1%CK_27 x_PM_CLKGATE_X1%CK_5 1.95
R_x_PM_CLKGATE_X1%CK_r19 N_CK_M6_g x_PM_CLKGATE_X1%CK_5 54.6
R_x_PM_CLKGATE_X1%CK_r20 x_PM_CLKGATE_X1%CK_27 x_PM_CLKGATE_X1%CK_VSS 1.95
R_x_PM_CLKGATE_X1%CK_r21 N_CK_M16_g x_PM_CLKGATE_X1%CK_VSS 30.42
C_x_PM_CLKGATE_X1%9_c0 VSS x_PM_CLKGATE_X1%9_24 9.48838e-18
C_x_PM_CLKGATE_X1%9_c1 VSS x_PM_CLKGATE_X1%9_22 7.90467e-17
C_x_PM_CLKGATE_X1%9_c2 VSS x_PM_CLKGATE_X1%9_15 2.80726e-17
C_x_PM_CLKGATE_X1%9_c3 VSS x_PM_CLKGATE_X1%9_11 5.32822e-17
C_x_PM_CLKGATE_X1%9_c4 VSS N_9_M9_g 6.1514e-17
C_x_PM_CLKGATE_X1%9_c5 VSS N_9_M19_g 5.69758e-17
R_x_PM_CLKGATE_X1%9_r6 x_PM_CLKGATE_X1%9_26 x_PM_CLKGATE_X1%9_24 4.7687
R_x_PM_CLKGATE_X1%9_r7 x_PM_CLKGATE_X1%9_24 x_PM_CLKGATE_X1%9_22 25.0012
R_x_PM_CLKGATE_X1%9_r8 x_PM_CLKGATE_X1%9_22 x_PM_CLKGATE_X1%9_20 1.615
R_x_PM_CLKGATE_X1%9_r9 x_PM_CLKGATE_X1%9_22 x_PM_CLKGATE_X1%9_19 0.529286
R_x_PM_CLKGATE_X1%9_r10 x_PM_CLKGATE_X1%9_19 x_PM_CLKGATE_X1%9_15 0.212317
R_x_PM_CLKGATE_X1%9_r11 N_9_M18_d x_PM_CLKGATE_X1%9_15 0.339286
R_x_PM_CLKGATE_X1%9_r12 x_PM_CLKGATE_X1%9_20 x_PM_CLKGATE_X1%9_11 0.212317
R_x_PM_CLKGATE_X1%9_r13 N_9_M7_d x_PM_CLKGATE_X1%9_11 1.34357
R_x_PM_CLKGATE_X1%9_r14 N_9_M9_g x_PM_CLKGATE_X1%9_26 75.66
R_x_PM_CLKGATE_X1%9_r15 x_PM_CLKGATE_X1%9_VSS x_PM_CLKGATE_X1%9_24 4.7687
R_x_PM_CLKGATE_X1%9_r16 N_9_M19_g x_PM_CLKGATE_X1%9_VSS 63.18
C_x_PM_CLKGATE_X1%GCK_c0 VSS N_GCK_M19_d 4.83314e-17
C_x_PM_CLKGATE_X1%GCK_c1 VSS x_PM_CLKGATE_X1%GCK_10 2.63441e-17
C_x_PM_CLKGATE_X1%GCK_c2 VSS GCK 1.36793e-16
R_x_PM_CLKGATE_X1%GCK_r3 x_PM_CLKGATE_X1%GCK_10 N_GCK_M9_d 0.203571
R_x_PM_CLKGATE_X1%GCK_r4 x_PM_CLKGATE_X1%GCK_10 x_PM_CLKGATE_X1%GCK_4 0.095
R_x_PM_CLKGATE_X1%GCK_r5 GCK x_PM_CLKGATE_X1%GCK_4 1.96333
R_x_PM_CLKGATE_X1%GCK_r6 x_PM_CLKGATE_X1%GCK_3 N_GCK_M19_d 0.147877
R_x_PM_CLKGATE_X1%GCK_r7 GCK x_PM_CLKGATE_X1%GCK_3 1.73111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X2.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X2 VSS VDD E CK GCK
*.PININFO VSS:B VDD:B E:I CK:I GCK:O
M_M10 N_VDD_M0_d N_4_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 11 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 N_4_M2_d N_7_M2_g 11 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M13 12 N_5_M3_g N_4_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VDD_M4_d N_E_M4_g 12 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_5_M5_d N_7_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_8_M7_d N_CK_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_VDD_M8_d N_3_M8_g N_8_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_GCK_M9_d N_8_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M0 N_VSS_M10_d N_4_M10_g N_3_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 13 N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_4_M12_d N_5_M12_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 14 N_7_M13_g N_4_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M14_d N_E_M14_g 14 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_5_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M16_d N_CK_M16_g N_7_M16_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 15 N_CK_M17_g N_8_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_VSS_M18_d N_3_M18_g 15 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 N_GCK_M19_d N_8_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_CLKGATE_X2%VSS_c0 VSS x_PM_CLKGATE_X2%VSS_36 2.89143e-17
C_x_PM_CLKGATE_X2%VSS_c1 VSS x_PM_CLKGATE_X2%VSS_35 2.71388e-18
C_x_PM_CLKGATE_X2%VSS_c2 VSS x_PM_CLKGATE_X2%VSS_34 4.6069e-18
C_x_PM_CLKGATE_X2%VSS_c3 VSS x_PM_CLKGATE_X2%VSS_33 2.83134e-17
C_x_PM_CLKGATE_X2%VSS_c4 VSS N_VSS_M18_d 3.31931e-17
C_x_PM_CLKGATE_X2%VSS_c5 VSS x_PM_CLKGATE_X2%VSS_25 2.71452e-17
C_x_PM_CLKGATE_X2%VSS_c6 VSS N_VSS_M16_d 1.14519e-17
C_x_PM_CLKGATE_X2%VSS_c7 VSS x_PM_CLKGATE_X2%VSS_17 5.82234e-17
C_x_PM_CLKGATE_X2%VSS_c8 VSS N_VSS_M14_d 3.86869e-17
C_x_PM_CLKGATE_X2%VSS_c9 VSS x_PM_CLKGATE_X2%VSS_11 6.03589e-17
C_x_PM_CLKGATE_X2%VSS_c10 VSS N_VSS_M10_d 2.83457e-17
R_x_PM_CLKGATE_X2%VSS_r11 x_PM_CLKGATE_X2%VSS_36 x_PM_CLKGATE_X2%VSS_27 0.145286
R_x_PM_CLKGATE_X2%VSS_r12 N_VSS_M18_d x_PM_CLKGATE_X2%VSS_27 1.15357
R_x_PM_CLKGATE_X2%VSS_r13 x_PM_CLKGATE_X2%VSS_35 x_PM_CLKGATE_X2%VSS_26 0.0731438
R_x_PM_CLKGATE_X2%VSS_r14 x_PM_CLKGATE_X2%VSS_36 x_PM_CLKGATE_X2%VSS_25 0.0731438
R_x_PM_CLKGATE_X2%VSS_r15 x_PM_CLKGATE_X2%VSS_26 x_PM_CLKGATE_X2%VSS_25 0.76
R_x_PM_CLKGATE_X2%VSS_r16 x_PM_CLKGATE_X2%VSS_35 x_PM_CLKGATE_X2%VSS_21 0.145286
R_x_PM_CLKGATE_X2%VSS_r17 N_VSS_M16_d x_PM_CLKGATE_X2%VSS_21 0.230714
R_x_PM_CLKGATE_X2%VSS_r18 x_PM_CLKGATE_X2%VSS_34 x_PM_CLKGATE_X2%VSS_18 0.0731438
R_x_PM_CLKGATE_X2%VSS_r19 VSS x_PM_CLKGATE_X2%VSS_18 0.156471
R_x_PM_CLKGATE_X2%VSS_r20 x_PM_CLKGATE_X2%VSS_35 x_PM_CLKGATE_X2%VSS_17 0.0731438
R_x_PM_CLKGATE_X2%VSS_r21 VSS x_PM_CLKGATE_X2%VSS_17 0.882941
R_x_PM_CLKGATE_X2%VSS_r22 x_PM_CLKGATE_X2%VSS_34 x_PM_CLKGATE_X2%VSS_13 0.145286
R_x_PM_CLKGATE_X2%VSS_r23 N_VSS_M14_d x_PM_CLKGATE_X2%VSS_13 0.909286
R_x_PM_CLKGATE_X2%VSS_r24 x_PM_CLKGATE_X2%VSS_33 x_PM_CLKGATE_X2%VSS_12 0.0731438
R_x_PM_CLKGATE_X2%VSS_r25 x_PM_CLKGATE_X2%VSS_34 x_PM_CLKGATE_X2%VSS_11 0.0731438
R_x_PM_CLKGATE_X2%VSS_r26 x_PM_CLKGATE_X2%VSS_12 x_PM_CLKGATE_X2%VSS_11 1.54235
R_x_PM_CLKGATE_X2%VSS_r27 x_PM_CLKGATE_X2%VSS_33 x_PM_CLKGATE_X2%VSS_7 0.145286
R_x_PM_CLKGATE_X2%VSS_r28 N_VSS_M10_d x_PM_CLKGATE_X2%VSS_7 0.909286
C_x_PM_CLKGATE_X2%VDD_c0 VSS x_PM_CLKGATE_X2%VDD_36 3.04307e-17
C_x_PM_CLKGATE_X2%VDD_c1 VSS x_PM_CLKGATE_X2%VDD_35 4.64934e-18
C_x_PM_CLKGATE_X2%VDD_c2 VSS x_PM_CLKGATE_X2%VDD_34 4.64531e-18
C_x_PM_CLKGATE_X2%VDD_c3 VSS x_PM_CLKGATE_X2%VDD_33 2.78648e-18
C_x_PM_CLKGATE_X2%VDD_c4 VSS N_VDD_M8_d 2.73528e-17
C_x_PM_CLKGATE_X2%VDD_c5 VSS x_PM_CLKGATE_X2%VDD_25 3.06328e-17
C_x_PM_CLKGATE_X2%VDD_c6 VSS N_VDD_M6_d 4.17822e-17
C_x_PM_CLKGATE_X2%VDD_c7 VSS x_PM_CLKGATE_X2%VDD_19 4.8098e-17
C_x_PM_CLKGATE_X2%VDD_c8 VSS N_VDD_M4_d 3.22937e-17
C_x_PM_CLKGATE_X2%VDD_c9 VSS x_PM_CLKGATE_X2%VDD_13 7.14057e-17
C_x_PM_CLKGATE_X2%VDD_c10 VSS N_VDD_M0_d 3.36025e-17
C_x_PM_CLKGATE_X2%VDD_c11 VSS x_PM_CLKGATE_X2%VDD_5 2.39662e-17
R_x_PM_CLKGATE_X2%VDD_r12 x_PM_CLKGATE_X2%VDD_36 x_PM_CLKGATE_X2%VDD_27 0.145286
R_x_PM_CLKGATE_X2%VDD_r13 N_VDD_M8_d x_PM_CLKGATE_X2%VDD_27 0.909286
R_x_PM_CLKGATE_X2%VDD_r14 x_PM_CLKGATE_X2%VDD_35 x_PM_CLKGATE_X2%VDD_26 0.0731438
R_x_PM_CLKGATE_X2%VDD_r15 x_PM_CLKGATE_X2%VDD_36 x_PM_CLKGATE_X2%VDD_25 0.0731438
R_x_PM_CLKGATE_X2%VDD_r16 x_PM_CLKGATE_X2%VDD_26 x_PM_CLKGATE_X2%VDD_25 0.681765
R_x_PM_CLKGATE_X2%VDD_r17 x_PM_CLKGATE_X2%VDD_35 x_PM_CLKGATE_X2%VDD_21 0.145286
R_x_PM_CLKGATE_X2%VDD_r18 N_VDD_M6_d x_PM_CLKGATE_X2%VDD_21 0.909286
R_x_PM_CLKGATE_X2%VDD_r19 x_PM_CLKGATE_X2%VDD_34 x_PM_CLKGATE_X2%VDD_20 0.0731438
R_x_PM_CLKGATE_X2%VDD_r20 x_PM_CLKGATE_X2%VDD_35 x_PM_CLKGATE_X2%VDD_19 0.0731438
R_x_PM_CLKGATE_X2%VDD_r21 x_PM_CLKGATE_X2%VDD_20 x_PM_CLKGATE_X2%VDD_19 1.07294
R_x_PM_CLKGATE_X2%VDD_r22 x_PM_CLKGATE_X2%VDD_34 x_PM_CLKGATE_X2%VDD_15 0.145286
R_x_PM_CLKGATE_X2%VDD_r23 N_VDD_M4_d x_PM_CLKGATE_X2%VDD_15 1.58786
R_x_PM_CLKGATE_X2%VDD_r24 x_PM_CLKGATE_X2%VDD_33 x_PM_CLKGATE_X2%VDD_14 0.0731438
R_x_PM_CLKGATE_X2%VDD_r25 x_PM_CLKGATE_X2%VDD_34 x_PM_CLKGATE_X2%VDD_13 0.0731438
R_x_PM_CLKGATE_X2%VDD_r26 x_PM_CLKGATE_X2%VDD_14 x_PM_CLKGATE_X2%VDD_13 1.52
R_x_PM_CLKGATE_X2%VDD_r27 x_PM_CLKGATE_X2%VDD_33 x_PM_CLKGATE_X2%VDD_9 0.145286
R_x_PM_CLKGATE_X2%VDD_r28 N_VDD_M0_d x_PM_CLKGATE_X2%VDD_9 1.58786
R_x_PM_CLKGATE_X2%VDD_r29 x_PM_CLKGATE_X2%VDD_33 x_PM_CLKGATE_X2%VDD_5 0.0731438
R_x_PM_CLKGATE_X2%VDD_r30 VDD x_PM_CLKGATE_X2%VDD_5 0.279412
C_x_PM_CLKGATE_X2%3_c0 VSS x_PM_CLKGATE_X2%3_36 8.3205e-18
C_x_PM_CLKGATE_X2%3_c1 VSS x_PM_CLKGATE_X2%3_34 2.72287e-18
C_x_PM_CLKGATE_X2%3_c2 VSS x_PM_CLKGATE_X2%3_31 6.52339e-17
C_x_PM_CLKGATE_X2%3_c3 VSS N_3_M0_s 2.36418e-17
C_x_PM_CLKGATE_X2%3_c4 VSS x_PM_CLKGATE_X2%3_25 2.67284e-18
C_x_PM_CLKGATE_X2%3_c5 VSS x_PM_CLKGATE_X2%3_24 2.58217e-17
C_x_PM_CLKGATE_X2%3_c6 VSS N_3_M10_s 1.87828e-17
C_x_PM_CLKGATE_X2%3_c7 VSS N_3_M18_g 1.06919e-16
C_x_PM_CLKGATE_X2%3_c8 VSS x_PM_CLKGATE_X2%3_10 5.67781e-18
C_x_PM_CLKGATE_X2%3_c9 VSS x_PM_CLKGATE_X2%3_9 1.94521e-16
C_x_PM_CLKGATE_X2%3_c10 VSS N_3_M1_g 8.24801e-17
C_x_PM_CLKGATE_X2%3_c11 VSS N_3_M11_g 2.88194e-17
R_x_PM_CLKGATE_X2%3_r12 x_PM_CLKGATE_X2%3_37 x_PM_CLKGATE_X2%3_36 4.7687
R_x_PM_CLKGATE_X2%3_r13 x_PM_CLKGATE_X2%3_36 x_PM_CLKGATE_X2%3_31 25.0012
R_x_PM_CLKGATE_X2%3_r14 x_PM_CLKGATE_X2%3_34 x_PM_CLKGATE_X2%3_29 0.0569232
R_x_PM_CLKGATE_X2%3_r15 x_PM_CLKGATE_X2%3_31 x_PM_CLKGATE_X2%3_29 1.28929
R_x_PM_CLKGATE_X2%3_r16 N_3_M0_s x_PM_CLKGATE_X2%3_25 0.861333
R_x_PM_CLKGATE_X2%3_r17 x_PM_CLKGATE_X2%3_24 x_PM_CLKGATE_X2%3_25 0.192227
R_x_PM_CLKGATE_X2%3_r18 x_PM_CLKGATE_X2%3_34 x_PM_CLKGATE_X2%3_23 0.143785
R_x_PM_CLKGATE_X2%3_r19 x_PM_CLKGATE_X2%3_24 x_PM_CLKGATE_X2%3_23 1.33
R_x_PM_CLKGATE_X2%3_r20 x_PM_CLKGATE_X2%3_34 x_PM_CLKGATE_X2%3_19 0.143785
R_x_PM_CLKGATE_X2%3_r21 N_3_M10_s x_PM_CLKGATE_X2%3_19 0.369444
R_x_PM_CLKGATE_X2%3_r22 N_3_M8_g N_3_M18_g 95.16
R_x_PM_CLKGATE_X2%3_r23 N_3_M8_g x_PM_CLKGATE_X2%3_11 40.56
R_x_PM_CLKGATE_X2%3_r24 x_PM_CLKGATE_X2%3_11 x_PM_CLKGATE_X2%3_9 4.35808
R_x_PM_CLKGATE_X2%3_r25 x_PM_CLKGATE_X2%3_10 x_PM_CLKGATE_X2%3_9 225.42
R_x_PM_CLKGATE_X2%3_r26 x_PM_CLKGATE_X2%3_10 x_PM_CLKGATE_X2%3_6 4.35808
R_x_PM_CLKGATE_X2%3_r27 N_3_M1_g x_PM_CLKGATE_X2%3_6 60.06
R_x_PM_CLKGATE_X2%3_r28 x_PM_CLKGATE_X2%3_5 x_PM_CLKGATE_X2%3_36 4.7687
R_x_PM_CLKGATE_X2%3_r29 N_3_M1_g x_PM_CLKGATE_X2%3_5 63.18
R_x_PM_CLKGATE_X2%3_r30 N_3_M11_g x_PM_CLKGATE_X2%3_37 21.84
C_x_PM_CLKGATE_X2%4_c0 VSS N_4_M2_d 2.11583e-17
C_x_PM_CLKGATE_X2%4_c1 VSS x_PM_CLKGATE_X2%4_25 1.44882e-17
C_x_PM_CLKGATE_X2%4_c2 VSS x_PM_CLKGATE_X2%4_19 1.49597e-17
C_x_PM_CLKGATE_X2%4_c3 VSS x_PM_CLKGATE_X2%4_17 2.03563e-17
C_x_PM_CLKGATE_X2%4_c4 VSS x_PM_CLKGATE_X2%4_14 1.53684e-17
C_x_PM_CLKGATE_X2%4_c5 VSS x_PM_CLKGATE_X2%4_11 7.84138e-17
C_x_PM_CLKGATE_X2%4_c6 VSS N_4_M12_d 2.94027e-17
C_x_PM_CLKGATE_X2%4_c7 VSS N_4_M0_g 5.15154e-17
C_x_PM_CLKGATE_X2%4_c8 VSS N_4_M10_g 4.9065e-17
R_x_PM_CLKGATE_X2%4_r9 N_4_M2_d x_PM_CLKGATE_X2%4_26 0.161852
R_x_PM_CLKGATE_X2%4_r10 x_PM_CLKGATE_X2%4_26 x_PM_CLKGATE_X2%4_19 0.095
R_x_PM_CLKGATE_X2%4_r11 x_PM_CLKGATE_X2%4_25 x_PM_CLKGATE_X2%4_18 0.160909
R_x_PM_CLKGATE_X2%4_r12 x_PM_CLKGATE_X2%4_19 x_PM_CLKGATE_X2%4_18 0.597143
R_x_PM_CLKGATE_X2%4_r13 x_PM_CLKGATE_X2%4_25 x_PM_CLKGATE_X2%4_17 0.160909
R_x_PM_CLKGATE_X2%4_r14 x_PM_CLKGATE_X2%4_20 x_PM_CLKGATE_X2%4_16 0.095
R_x_PM_CLKGATE_X2%4_r15 x_PM_CLKGATE_X2%4_17 x_PM_CLKGATE_X2%4_16 0.841429
R_x_PM_CLKGATE_X2%4_r16 x_PM_CLKGATE_X2%4_14 x_PM_CLKGATE_X2%4_31 5.46
R_x_PM_CLKGATE_X2%4_r17 x_PM_CLKGATE_X2%4_14 x_PM_CLKGATE_X2%4_12 25.0012
R_x_PM_CLKGATE_X2%4_r18 x_PM_CLKGATE_X2%4_25 x_PM_CLKGATE_X2%4_11 0.0418175
R_x_PM_CLKGATE_X2%4_r19 x_PM_CLKGATE_X2%4_12 x_PM_CLKGATE_X2%4_11 1.77786
R_x_PM_CLKGATE_X2%4_r20 N_4_M12_d x_PM_CLKGATE_X2%4_20 0.161852
R_x_PM_CLKGATE_X2%4_r21 x_PM_CLKGATE_X2%4_31 x_PM_CLKGATE_X2%4_5 1.95
R_x_PM_CLKGATE_X2%4_r22 N_4_M0_g x_PM_CLKGATE_X2%4_5 42.12
R_x_PM_CLKGATE_X2%4_r23 x_PM_CLKGATE_X2%4_31 x_PM_CLKGATE_X2%4_VSS 1.95
R_x_PM_CLKGATE_X2%4_r24 N_4_M10_g x_PM_CLKGATE_X2%4_VSS 42.9
C_x_PM_CLKGATE_X2%5_c0 VSS x_PM_CLKGATE_X2%5_32 8.42412e-18
C_x_PM_CLKGATE_X2%5_c1 VSS x_PM_CLKGATE_X2%5_30 1.57629e-17
C_x_PM_CLKGATE_X2%5_c2 VSS N_5_M5_d 5.73704e-17
C_x_PM_CLKGATE_X2%5_c3 VSS x_PM_CLKGATE_X2%5_19 5.59585e-17
C_x_PM_CLKGATE_X2%5_c4 VSS x_PM_CLKGATE_X2%5_13 6.81705e-17
C_x_PM_CLKGATE_X2%5_c5 VSS N_5_M15_d 5.95439e-17
C_x_PM_CLKGATE_X2%5_c6 VSS N_5_M3_g 4.35539e-17
C_x_PM_CLKGATE_X2%5_c7 VSS x_PM_CLKGATE_X2%5_6 7.62595e-18
C_x_PM_CLKGATE_X2%5_c8 VSS x_PM_CLKGATE_X2%5_5 1.5248e-17
C_x_PM_CLKGATE_X2%5_c9 VSS N_5_M12_g 5.76102e-17
R_x_PM_CLKGATE_X2%5_r10 x_PM_CLKGATE_X2%5_30 x_PM_CLKGATE_X2%5_29 0.298571
R_x_PM_CLKGATE_X2%5_r11 x_PM_CLKGATE_X2%5_30 x_PM_CLKGATE_X2%5_20 0.095
R_x_PM_CLKGATE_X2%5_r12 N_5_M5_d x_PM_CLKGATE_X2%5_20 1.53357
R_x_PM_CLKGATE_X2%5_r13 x_PM_CLKGATE_X2%5_29 x_PM_CLKGATE_X2%5_19 0.095
R_x_PM_CLKGATE_X2%5_r14 x_PM_CLKGATE_X2%5_24 x_PM_CLKGATE_X2%5_18 0.095
R_x_PM_CLKGATE_X2%5_r15 x_PM_CLKGATE_X2%5_19 x_PM_CLKGATE_X2%5_18 1.52
R_x_PM_CLKGATE_X2%5_r16 x_PM_CLKGATE_X2%5_35 x_PM_CLKGATE_X2%5_16 4.7687
R_x_PM_CLKGATE_X2%5_r17 x_PM_CLKGATE_X2%5_16 x_PM_CLKGATE_X2%5_32 1.3
R_x_PM_CLKGATE_X2%5_r18 x_PM_CLKGATE_X2%5_16 x_PM_CLKGATE_X2%5_14 25.0012
R_x_PM_CLKGATE_X2%5_r19 x_PM_CLKGATE_X2%5_29 x_PM_CLKGATE_X2%5_13 0.19
R_x_PM_CLKGATE_X2%5_r20 x_PM_CLKGATE_X2%5_14 x_PM_CLKGATE_X2%5_13 1.995
R_x_PM_CLKGATE_X2%5_r21 N_5_M15_d x_PM_CLKGATE_X2%5_24 0.161852
R_x_PM_CLKGATE_X2%5_r22 N_5_M3_g x_PM_CLKGATE_X2%5_35 37.44
R_x_PM_CLKGATE_X2%5_r23 x_PM_CLKGATE_X2%5_32 x_PM_CLKGATE_X2%5_5 1.95
R_x_PM_CLKGATE_X2%5_r24 x_PM_CLKGATE_X2%5_6 x_PM_CLKGATE_X2%5_5 21.84
R_x_PM_CLKGATE_X2%5_r25 x_PM_CLKGATE_X2%5_6 x_PM_CLKGATE_X2%5_VSS 4.35808
R_x_PM_CLKGATE_X2%5_r26 N_5_M12_g x_PM_CLKGATE_X2%5_VSS 47.58
C_x_PM_CLKGATE_X2%E_c0 VSS x_PM_CLKGATE_X2%E_16 7.65971e-18
C_x_PM_CLKGATE_X2%E_c1 VSS x_PM_CLKGATE_X2%E_14 5.15641e-17
C_x_PM_CLKGATE_X2%E_c2 VSS x_PM_CLKGATE_X2%E_9 1.69188e-17
C_x_PM_CLKGATE_X2%E_c3 VSS N_E_M4_g 6.25421e-17
C_x_PM_CLKGATE_X2%E_c4 VSS N_E_M14_g 2.90842e-17
R_x_PM_CLKGATE_X2%E_r5 x_PM_CLKGATE_X2%E_20 x_PM_CLKGATE_X2%E_16 4.7687
R_x_PM_CLKGATE_X2%E_r6 x_PM_CLKGATE_X2%E_19 x_PM_CLKGATE_X2%E_16 4.7687
R_x_PM_CLKGATE_X2%E_r7 x_PM_CLKGATE_X2%E_16 x_PM_CLKGATE_X2%E_14 25.0012
R_x_PM_CLKGATE_X2%E_r8 x_PM_CLKGATE_X2%E_14 x_PM_CLKGATE_X2%E_12 0.168286
R_x_PM_CLKGATE_X2%E_r9 x_PM_CLKGATE_X2%E_12 x_PM_CLKGATE_X2%E_9 0.095
R_x_PM_CLKGATE_X2%E_r10 E x_PM_CLKGATE_X2%E_9 0.135714
R_x_PM_CLKGATE_X2%E_r11 N_E_M4_g x_PM_CLKGATE_X2%E_20 63.18
R_x_PM_CLKGATE_X2%E_r12 N_E_M14_g x_PM_CLKGATE_X2%E_19 21.84
C_x_PM_CLKGATE_X2%7_c0 VSS x_PM_CLKGATE_X2%7_38 4.25991e-17
C_x_PM_CLKGATE_X2%7_c1 VSS N_7_M6_s 7.593e-17
C_x_PM_CLKGATE_X2%7_c2 VSS N_7_M16_s 5.4826e-17
C_x_PM_CLKGATE_X2%7_c3 VSS x_PM_CLKGATE_X2%7_22 6.50506e-18
C_x_PM_CLKGATE_X2%7_c4 VSS x_PM_CLKGATE_X2%7_21 2.26233e-17
C_x_PM_CLKGATE_X2%7_c5 VSS N_7_M5_g 7.47363e-17
C_x_PM_CLKGATE_X2%7_c6 VSS N_7_M15_g 3.75743e-17
C_x_PM_CLKGATE_X2%7_c7 VSS x_PM_CLKGATE_X2%7_12 6.46392e-18
C_x_PM_CLKGATE_X2%7_c8 VSS x_PM_CLKGATE_X2%7_11 4.37439e-17
C_x_PM_CLKGATE_X2%7_c9 VSS N_7_M13_g 3.64166e-17
C_x_PM_CLKGATE_X2%7_c10 VSS x_PM_CLKGATE_X2%7_6 6.42829e-18
C_x_PM_CLKGATE_X2%7_c11 VSS x_PM_CLKGATE_X2%7_5 6.47163e-17
C_x_PM_CLKGATE_X2%7_c12 VSS N_7_M2_g 5.13203e-17
R_x_PM_CLKGATE_X2%7_r13 x_PM_CLKGATE_X2%7_38 x_PM_CLKGATE_X2%7_37 0.0140741
R_x_PM_CLKGATE_X2%7_r14 x_PM_CLKGATE_X2%7_35 x_PM_CLKGATE_X2%7_33 25.0012
R_x_PM_CLKGATE_X2%7_r15 x_PM_CLKGATE_X2%7_37 x_PM_CLKGATE_X2%7_33 0.246296
R_x_PM_CLKGATE_X2%7_r16 x_PM_CLKGATE_X2%7_38 x_PM_CLKGATE_X2%7_29 0.095
R_x_PM_CLKGATE_X2%7_r17 N_7_M6_s x_PM_CLKGATE_X2%7_29 2.185
R_x_PM_CLKGATE_X2%7_r18 x_PM_CLKGATE_X2%7_37 x_PM_CLKGATE_X2%7_25 0.095
R_x_PM_CLKGATE_X2%7_r19 N_7_M16_s x_PM_CLKGATE_X2%7_25 0.866875
R_x_PM_CLKGATE_X2%7_r20 x_PM_CLKGATE_X2%7_35 x_PM_CLKGATE_X2%7_21 11.4647
R_x_PM_CLKGATE_X2%7_r21 x_PM_CLKGATE_X2%7_22 x_PM_CLKGATE_X2%7_21 0.043368
R_x_PM_CLKGATE_X2%7_r22 N_7_M5_g x_PM_CLKGATE_X2%7_18 40.56
R_x_PM_CLKGATE_X2%7_r23 x_PM_CLKGATE_X2%7_22 x_PM_CLKGATE_X2%7_17 4.56151
R_x_PM_CLKGATE_X2%7_r24 N_7_M5_g x_PM_CLKGATE_X2%7_17 63.18
R_x_PM_CLKGATE_X2%7_r25 x_PM_CLKGATE_X2%7_22 x_PM_CLKGATE_X2%7_14 4.56151
R_x_PM_CLKGATE_X2%7_r26 N_7_M15_g x_PM_CLKGATE_X2%7_14 21.84
R_x_PM_CLKGATE_X2%7_r27 N_7_M15_g x_PM_CLKGATE_X2%7_13 33.54
R_x_PM_CLKGATE_X2%7_r28 x_PM_CLKGATE_X2%7_13 x_PM_CLKGATE_X2%7_11 4.35808
R_x_PM_CLKGATE_X2%7_r29 x_PM_CLKGATE_X2%7_12 x_PM_CLKGATE_X2%7_11 51.48
R_x_PM_CLKGATE_X2%7_r30 x_PM_CLKGATE_X2%7_12 x_PM_CLKGATE_X2%7_7 4.35808
R_x_PM_CLKGATE_X2%7_r31 N_7_M13_g x_PM_CLKGATE_X2%7_7 33.54
R_x_PM_CLKGATE_X2%7_r32 x_PM_CLKGATE_X2%7_18 x_PM_CLKGATE_X2%7_5 4.35808
R_x_PM_CLKGATE_X2%7_r33 x_PM_CLKGATE_X2%7_6 x_PM_CLKGATE_X2%7_5 81.12
R_x_PM_CLKGATE_X2%7_r34 x_PM_CLKGATE_X2%7_6 x_PM_CLKGATE_X2%7_VSS 4.35808
R_x_PM_CLKGATE_X2%7_r35 N_7_M2_g x_PM_CLKGATE_X2%7_VSS 40.56
C_x_PM_CLKGATE_X2%8_c0 VSS x_PM_CLKGATE_X2%8_28 1.15511e-17
C_x_PM_CLKGATE_X2%8_c1 VSS x_PM_CLKGATE_X2%8_25 2.80242e-17
C_x_PM_CLKGATE_X2%8_c2 VSS x_PM_CLKGATE_X2%8_23 7.48897e-17
C_x_PM_CLKGATE_X2%8_c3 VSS x_PM_CLKGATE_X2%8_20 1.46179e-17
C_x_PM_CLKGATE_X2%8_c4 VSS x_PM_CLKGATE_X2%8_18 1.41583e-17
C_x_PM_CLKGATE_X2%8_c5 VSS N_8_M7_d 4.50772e-17
C_x_PM_CLKGATE_X2%8_c6 VSS x_PM_CLKGATE_X2%8_13 4.71245e-18
C_x_PM_CLKGATE_X2%8_c7 VSS x_PM_CLKGATE_X2%8_12 7.12613e-17
C_x_PM_CLKGATE_X2%8_c8 VSS N_8_M9_g 5.95403e-17
C_x_PM_CLKGATE_X2%8_c9 VSS N_8_M19_g 4.92044e-17
R_x_PM_CLKGATE_X2%8_r10 x_PM_CLKGATE_X2%8_28 x_PM_CLKGATE_X2%8_26 3.38
R_x_PM_CLKGATE_X2%8_r11 x_PM_CLKGATE_X2%8_25 x_PM_CLKGATE_X2%8_23 0.0272847
R_x_PM_CLKGATE_X2%8_r12 x_PM_CLKGATE_X2%8_23 x_PM_CLKGATE_X2%8_21 0.516176
R_x_PM_CLKGATE_X2%8_r13 x_PM_CLKGATE_X2%8_26 x_PM_CLKGATE_X2%8_21 25.0012
R_x_PM_CLKGATE_X2%8_r14 x_PM_CLKGATE_X2%8_25 x_PM_CLKGATE_X2%8_19 0.266978
R_x_PM_CLKGATE_X2%8_r15 x_PM_CLKGATE_X2%8_20 x_PM_CLKGATE_X2%8_19 0.868571
R_x_PM_CLKGATE_X2%8_r16 x_PM_CLKGATE_X2%8_25 x_PM_CLKGATE_X2%8_18 0.266978
R_x_PM_CLKGATE_X2%8_r17 x_PM_CLKGATE_X2%8_18 x_PM_CLKGATE_X2%8_17 0.515714
R_x_PM_CLKGATE_X2%8_r18 x_PM_CLKGATE_X2%8_20 x_PM_CLKGATE_X2%8_13 0.20978
R_x_PM_CLKGATE_X2%8_r19 N_8_M7_d x_PM_CLKGATE_X2%8_13 0.686111
R_x_PM_CLKGATE_X2%8_r20 x_PM_CLKGATE_X2%8_17 x_PM_CLKGATE_X2%8_12 0.241334
R_x_PM_CLKGATE_X2%8_r21 x_PM_CLKGATE_X2%8_12 N_8_M17_s 0.431731
R_x_PM_CLKGATE_X2%8_r22 x_PM_CLKGATE_X2%8_28 x_PM_CLKGATE_X2%8_5 1.95
R_x_PM_CLKGATE_X2%8_r23 N_8_M9_g x_PM_CLKGATE_X2%8_5 62.4
R_x_PM_CLKGATE_X2%8_r24 x_PM_CLKGATE_X2%8_28 x_PM_CLKGATE_X2%8_VSS 1.95
R_x_PM_CLKGATE_X2%8_r25 N_8_M19_g x_PM_CLKGATE_X2%8_VSS 42.12
C_x_PM_CLKGATE_X2%CK_c0 VSS x_PM_CLKGATE_X2%CK_25 4.66706e-18
C_x_PM_CLKGATE_X2%CK_c1 VSS x_PM_CLKGATE_X2%CK_23 5.92029e-17
C_x_PM_CLKGATE_X2%CK_c2 VSS x_PM_CLKGATE_X2%CK_19 7.63948e-18
C_x_PM_CLKGATE_X2%CK_c3 VSS N_CK_M7_g 4.26575e-17
C_x_PM_CLKGATE_X2%CK_c4 VSS N_CK_M17_g 2.83389e-17
C_x_PM_CLKGATE_X2%CK_c5 VSS x_PM_CLKGATE_X2%CK_9 6.99052e-18
C_x_PM_CLKGATE_X2%CK_c6 VSS N_CK_M6_g 4.84885e-17
C_x_PM_CLKGATE_X2%CK_c7 VSS N_CK_M16_g 5.77566e-17
R_x_PM_CLKGATE_X2%CK_r8 x_PM_CLKGATE_X2%CK_25 x_PM_CLKGATE_X2%CK_23 25.0012
R_x_PM_CLKGATE_X2%CK_r9 x_PM_CLKGATE_X2%CK_23 CK 0.1425
R_x_PM_CLKGATE_X2%CK_r10 x_PM_CLKGATE_X2%CK_25 x_PM_CLKGATE_X2%CK_15 4.56151
R_x_PM_CLKGATE_X2%CK_r11 N_CK_M7_g x_PM_CLKGATE_X2%CK_15 60.06
R_x_PM_CLKGATE_X2%CK_r12 x_PM_CLKGATE_X2%CK_25 x_PM_CLKGATE_X2%CK_11 4.56151
R_x_PM_CLKGATE_X2%CK_r13 N_CK_M17_g x_PM_CLKGATE_X2%CK_11 23.4
R_x_PM_CLKGATE_X2%CK_r14 x_PM_CLKGATE_X2%CK_19 x_PM_CLKGATE_X2%CK_10 0.043368
R_x_PM_CLKGATE_X2%CK_r15 x_PM_CLKGATE_X2%CK_25 x_PM_CLKGATE_X2%CK_9 0.043368
R_x_PM_CLKGATE_X2%CK_r16 x_PM_CLKGATE_X2%CK_10 x_PM_CLKGATE_X2%CK_9 14.56
R_x_PM_CLKGATE_X2%CK_r17 x_PM_CLKGATE_X2%CK_19 x_PM_CLKGATE_X2%CK_5 4.56151
R_x_PM_CLKGATE_X2%CK_r18 N_CK_M6_g x_PM_CLKGATE_X2%CK_5 60.06
R_x_PM_CLKGATE_X2%CK_r19 x_PM_CLKGATE_X2%CK_19 x_PM_CLKGATE_X2%CK_VSS 4.56151
R_x_PM_CLKGATE_X2%CK_r20 N_CK_M16_g x_PM_CLKGATE_X2%CK_VSS 63.96
C_x_PM_CLKGATE_X2%GCK_c0 VSS x_PM_CLKGATE_X2%GCK_17 2.18523e-18
C_x_PM_CLKGATE_X2%GCK_c1 VSS x_PM_CLKGATE_X2%GCK_16 4.84086e-17
C_x_PM_CLKGATE_X2%GCK_c2 VSS N_GCK_M9_d 1.30471e-17
C_x_PM_CLKGATE_X2%GCK_c3 VSS x_PM_CLKGATE_X2%GCK_11 2.76458e-18
C_x_PM_CLKGATE_X2%GCK_c4 VSS N_GCK_M19_d 1.41694e-17
C_x_PM_CLKGATE_X2%GCK_c5 VSS x_PM_CLKGATE_X2%GCK_3 5.37786e-17
R_x_PM_CLKGATE_X2%GCK_r6 x_PM_CLKGATE_X2%GCK_17 x_PM_CLKGATE_X2%GCK_15 0.156262
R_x_PM_CLKGATE_X2%GCK_r7 x_PM_CLKGATE_X2%GCK_16 x_PM_CLKGATE_X2%GCK_15 2.44286
R_x_PM_CLKGATE_X2%GCK_r8 x_PM_CLKGATE_X2%GCK_16 x_PM_CLKGATE_X2%GCK_11 0.192227
R_x_PM_CLKGATE_X2%GCK_r9 N_GCK_M9_d x_PM_CLKGATE_X2%GCK_11 0.152
R_x_PM_CLKGATE_X2%GCK_r10 x_PM_CLKGATE_X2%GCK_17 x_PM_CLKGATE_X2%GCK_7 0.156262
R_x_PM_CLKGATE_X2%GCK_r11 N_GCK_M19_d x_PM_CLKGATE_X2%GCK_7 0.266
R_x_PM_CLKGATE_X2%GCK_r12 x_PM_CLKGATE_X2%GCK_17 x_PM_CLKGATE_X2%GCK_3 0.0457628
R_x_PM_CLKGATE_X2%GCK_r13 GCK x_PM_CLKGATE_X2%GCK_3 0.76
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X4.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X4 VSS VDD E CK GCK
*.PININFO VSS:B VDD:B E:I CK:I GCK:O
M_M10 N_VDD_M0_d N_4_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 11 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 N_4_M2_d N_7_M2_g 11 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M13 12 N_5_M3_g N_4_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VDD_M4_d N_E_M4_g 12 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_5_M5_d N_7_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_8_M7_d N_CK_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_VDD_M8_d N_3_M8_g N_8_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_GCK_M9_d N_8_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M0 N_VSS_M10_d N_4_M10_g N_3_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 13 N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_4_M12_d N_5_M12_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 14 N_7_M13_g N_4_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M14_d N_E_M14_g 14 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_5_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M16_d N_CK_M16_g N_7_M16_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 15 N_CK_M17_g N_8_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_VSS_M18_d N_3_M18_g 15 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 N_GCK_M19_d N_8_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_CLKGATE_X4%VSS_c0 VSS x_PM_CLKGATE_X4%VSS_36 3.55721e-17
C_x_PM_CLKGATE_X4%VSS_c1 VSS x_PM_CLKGATE_X4%VSS_35 2.69652e-18
C_x_PM_CLKGATE_X4%VSS_c2 VSS x_PM_CLKGATE_X4%VSS_34 4.6069e-18
C_x_PM_CLKGATE_X4%VSS_c3 VSS x_PM_CLKGATE_X4%VSS_33 2.83134e-17
C_x_PM_CLKGATE_X4%VSS_c4 VSS N_VSS_M18_d 5.19315e-17
C_x_PM_CLKGATE_X4%VSS_c5 VSS x_PM_CLKGATE_X4%VSS_25 2.50277e-17
C_x_PM_CLKGATE_X4%VSS_c6 VSS N_VSS_M16_d 1.1214e-17
C_x_PM_CLKGATE_X4%VSS_c7 VSS x_PM_CLKGATE_X4%VSS_17 5.15528e-17
C_x_PM_CLKGATE_X4%VSS_c8 VSS N_VSS_M14_d 2.76781e-17
C_x_PM_CLKGATE_X4%VSS_c9 VSS x_PM_CLKGATE_X4%VSS_11 5.99478e-17
C_x_PM_CLKGATE_X4%VSS_c10 VSS N_VSS_M10_d 2.82912e-17
R_x_PM_CLKGATE_X4%VSS_r11 x_PM_CLKGATE_X4%VSS_36 x_PM_CLKGATE_X4%VSS_27 0.145286
R_x_PM_CLKGATE_X4%VSS_r12 N_VSS_M18_d x_PM_CLKGATE_X4%VSS_27 1.64214
R_x_PM_CLKGATE_X4%VSS_r13 x_PM_CLKGATE_X4%VSS_35 x_PM_CLKGATE_X4%VSS_26 0.0731438
R_x_PM_CLKGATE_X4%VSS_r14 x_PM_CLKGATE_X4%VSS_36 x_PM_CLKGATE_X4%VSS_25 0.0731438
R_x_PM_CLKGATE_X4%VSS_r15 x_PM_CLKGATE_X4%VSS_26 x_PM_CLKGATE_X4%VSS_25 0.726471
R_x_PM_CLKGATE_X4%VSS_r16 x_PM_CLKGATE_X4%VSS_35 x_PM_CLKGATE_X4%VSS_21 0.145286
R_x_PM_CLKGATE_X4%VSS_r17 N_VSS_M16_d x_PM_CLKGATE_X4%VSS_21 0.230714
R_x_PM_CLKGATE_X4%VSS_r18 x_PM_CLKGATE_X4%VSS_34 x_PM_CLKGATE_X4%VSS_18 0.0731438
R_x_PM_CLKGATE_X4%VSS_r19 VSS x_PM_CLKGATE_X4%VSS_18 0.156471
R_x_PM_CLKGATE_X4%VSS_r20 x_PM_CLKGATE_X4%VSS_35 x_PM_CLKGATE_X4%VSS_17 0.0731438
R_x_PM_CLKGATE_X4%VSS_r21 VSS x_PM_CLKGATE_X4%VSS_17 0.871765
R_x_PM_CLKGATE_X4%VSS_r22 x_PM_CLKGATE_X4%VSS_34 x_PM_CLKGATE_X4%VSS_13 0.145286
R_x_PM_CLKGATE_X4%VSS_r23 N_VSS_M14_d x_PM_CLKGATE_X4%VSS_13 0.909286
R_x_PM_CLKGATE_X4%VSS_r24 x_PM_CLKGATE_X4%VSS_33 x_PM_CLKGATE_X4%VSS_12 0.0731438
R_x_PM_CLKGATE_X4%VSS_r25 x_PM_CLKGATE_X4%VSS_34 x_PM_CLKGATE_X4%VSS_11 0.0731438
R_x_PM_CLKGATE_X4%VSS_r26 x_PM_CLKGATE_X4%VSS_12 x_PM_CLKGATE_X4%VSS_11 1.54235
R_x_PM_CLKGATE_X4%VSS_r27 x_PM_CLKGATE_X4%VSS_33 x_PM_CLKGATE_X4%VSS_7 0.145286
R_x_PM_CLKGATE_X4%VSS_r28 N_VSS_M10_d x_PM_CLKGATE_X4%VSS_7 0.909286
C_x_PM_CLKGATE_X4%VDD_c0 VSS x_PM_CLKGATE_X4%VDD_36 3.01538e-17
C_x_PM_CLKGATE_X4%VDD_c1 VSS x_PM_CLKGATE_X4%VDD_35 4.6069e-18
C_x_PM_CLKGATE_X4%VDD_c2 VSS x_PM_CLKGATE_X4%VDD_34 4.64531e-18
C_x_PM_CLKGATE_X4%VDD_c3 VSS x_PM_CLKGATE_X4%VDD_33 2.8212e-18
C_x_PM_CLKGATE_X4%VDD_c4 VSS N_VDD_M8_d 2.44708e-17
C_x_PM_CLKGATE_X4%VDD_c5 VSS x_PM_CLKGATE_X4%VDD_25 2.88139e-17
C_x_PM_CLKGATE_X4%VDD_c6 VSS N_VDD_M6_d 2.04918e-17
C_x_PM_CLKGATE_X4%VDD_c7 VSS x_PM_CLKGATE_X4%VDD_19 4.91181e-17
C_x_PM_CLKGATE_X4%VDD_c8 VSS N_VDD_M4_d 3.90144e-17
C_x_PM_CLKGATE_X4%VDD_c9 VSS x_PM_CLKGATE_X4%VDD_13 7.23495e-17
C_x_PM_CLKGATE_X4%VDD_c10 VSS N_VDD_M0_d 3.26238e-17
C_x_PM_CLKGATE_X4%VDD_c11 VSS x_PM_CLKGATE_X4%VDD_5 2.26433e-17
R_x_PM_CLKGATE_X4%VDD_r12 x_PM_CLKGATE_X4%VDD_36 x_PM_CLKGATE_X4%VDD_27 0.145286
R_x_PM_CLKGATE_X4%VDD_r13 N_VDD_M8_d x_PM_CLKGATE_X4%VDD_27 0.909286
R_x_PM_CLKGATE_X4%VDD_r14 x_PM_CLKGATE_X4%VDD_35 x_PM_CLKGATE_X4%VDD_26 0.0731438
R_x_PM_CLKGATE_X4%VDD_r15 x_PM_CLKGATE_X4%VDD_36 x_PM_CLKGATE_X4%VDD_25 0.0731438
R_x_PM_CLKGATE_X4%VDD_r16 x_PM_CLKGATE_X4%VDD_26 x_PM_CLKGATE_X4%VDD_25 0.692941
R_x_PM_CLKGATE_X4%VDD_r17 x_PM_CLKGATE_X4%VDD_35 x_PM_CLKGATE_X4%VDD_21 0.145286
R_x_PM_CLKGATE_X4%VDD_r18 N_VDD_M6_d x_PM_CLKGATE_X4%VDD_21 0.909286
R_x_PM_CLKGATE_X4%VDD_r19 x_PM_CLKGATE_X4%VDD_34 x_PM_CLKGATE_X4%VDD_20 0.0731438
R_x_PM_CLKGATE_X4%VDD_r20 x_PM_CLKGATE_X4%VDD_35 x_PM_CLKGATE_X4%VDD_19 0.0731438
R_x_PM_CLKGATE_X4%VDD_r21 x_PM_CLKGATE_X4%VDD_20 x_PM_CLKGATE_X4%VDD_19 1.06176
R_x_PM_CLKGATE_X4%VDD_r22 x_PM_CLKGATE_X4%VDD_34 x_PM_CLKGATE_X4%VDD_15 0.145286
R_x_PM_CLKGATE_X4%VDD_r23 N_VDD_M4_d x_PM_CLKGATE_X4%VDD_15 1.58786
R_x_PM_CLKGATE_X4%VDD_r24 x_PM_CLKGATE_X4%VDD_33 x_PM_CLKGATE_X4%VDD_14 0.0731438
R_x_PM_CLKGATE_X4%VDD_r25 x_PM_CLKGATE_X4%VDD_34 x_PM_CLKGATE_X4%VDD_13 0.0731438
R_x_PM_CLKGATE_X4%VDD_r26 x_PM_CLKGATE_X4%VDD_14 x_PM_CLKGATE_X4%VDD_13 1.54235
R_x_PM_CLKGATE_X4%VDD_r27 x_PM_CLKGATE_X4%VDD_33 x_PM_CLKGATE_X4%VDD_9 0.145286
R_x_PM_CLKGATE_X4%VDD_r28 N_VDD_M0_d x_PM_CLKGATE_X4%VDD_9 1.58786
R_x_PM_CLKGATE_X4%VDD_r29 x_PM_CLKGATE_X4%VDD_33 x_PM_CLKGATE_X4%VDD_5 0.0731438
R_x_PM_CLKGATE_X4%VDD_r30 VDD x_PM_CLKGATE_X4%VDD_5 0.268235
C_x_PM_CLKGATE_X4%3_c0 VSS x_PM_CLKGATE_X4%3_36 8.31369e-18
C_x_PM_CLKGATE_X4%3_c1 VSS x_PM_CLKGATE_X4%3_34 2.72287e-18
C_x_PM_CLKGATE_X4%3_c2 VSS x_PM_CLKGATE_X4%3_31 6.37352e-17
C_x_PM_CLKGATE_X4%3_c3 VSS N_3_M0_s 9.69406e-18
C_x_PM_CLKGATE_X4%3_c4 VSS x_PM_CLKGATE_X4%3_25 2.68348e-18
C_x_PM_CLKGATE_X4%3_c5 VSS x_PM_CLKGATE_X4%3_24 2.58834e-17
C_x_PM_CLKGATE_X4%3_c6 VSS N_3_M10_s 1.86357e-17
C_x_PM_CLKGATE_X4%3_c7 VSS N_3_M18_g 1.07698e-16
C_x_PM_CLKGATE_X4%3_c8 VSS x_PM_CLKGATE_X4%3_10 6.00231e-18
C_x_PM_CLKGATE_X4%3_c9 VSS x_PM_CLKGATE_X4%3_9 1.94627e-16
C_x_PM_CLKGATE_X4%3_c10 VSS N_3_M1_g 8.20416e-17
C_x_PM_CLKGATE_X4%3_c11 VSS N_3_M11_g 2.87862e-17
R_x_PM_CLKGATE_X4%3_r12 x_PM_CLKGATE_X4%3_37 x_PM_CLKGATE_X4%3_36 4.7687
R_x_PM_CLKGATE_X4%3_r13 x_PM_CLKGATE_X4%3_36 x_PM_CLKGATE_X4%3_31 25.0012
R_x_PM_CLKGATE_X4%3_r14 x_PM_CLKGATE_X4%3_34 x_PM_CLKGATE_X4%3_29 0.0569232
R_x_PM_CLKGATE_X4%3_r15 x_PM_CLKGATE_X4%3_31 x_PM_CLKGATE_X4%3_29 1.28929
R_x_PM_CLKGATE_X4%3_r16 N_3_M0_s x_PM_CLKGATE_X4%3_25 0.152
R_x_PM_CLKGATE_X4%3_r17 x_PM_CLKGATE_X4%3_24 x_PM_CLKGATE_X4%3_25 0.192227
R_x_PM_CLKGATE_X4%3_r18 x_PM_CLKGATE_X4%3_34 x_PM_CLKGATE_X4%3_23 0.143785
R_x_PM_CLKGATE_X4%3_r19 x_PM_CLKGATE_X4%3_24 x_PM_CLKGATE_X4%3_23 1.33
R_x_PM_CLKGATE_X4%3_r20 x_PM_CLKGATE_X4%3_34 x_PM_CLKGATE_X4%3_19 0.143785
R_x_PM_CLKGATE_X4%3_r21 N_3_M10_s x_PM_CLKGATE_X4%3_19 0.369444
R_x_PM_CLKGATE_X4%3_r22 N_3_M8_g N_3_M18_g 95.16
R_x_PM_CLKGATE_X4%3_r23 N_3_M8_g x_PM_CLKGATE_X4%3_11 40.56
R_x_PM_CLKGATE_X4%3_r24 x_PM_CLKGATE_X4%3_11 x_PM_CLKGATE_X4%3_9 4.35808
R_x_PM_CLKGATE_X4%3_r25 x_PM_CLKGATE_X4%3_10 x_PM_CLKGATE_X4%3_9 225.42
R_x_PM_CLKGATE_X4%3_r26 x_PM_CLKGATE_X4%3_10 x_PM_CLKGATE_X4%3_6 4.35808
R_x_PM_CLKGATE_X4%3_r27 N_3_M1_g x_PM_CLKGATE_X4%3_6 60.06
R_x_PM_CLKGATE_X4%3_r28 x_PM_CLKGATE_X4%3_5 x_PM_CLKGATE_X4%3_36 4.7687
R_x_PM_CLKGATE_X4%3_r29 N_3_M1_g x_PM_CLKGATE_X4%3_5 63.18
R_x_PM_CLKGATE_X4%3_r30 N_3_M11_g x_PM_CLKGATE_X4%3_37 21.84
C_x_PM_CLKGATE_X4%4_c0 VSS N_4_M2_d 2.66863e-17
C_x_PM_CLKGATE_X4%4_c1 VSS x_PM_CLKGATE_X4%4_24 2.47475e-17
C_x_PM_CLKGATE_X4%4_c2 VSS x_PM_CLKGATE_X4%4_19 1.97966e-17
C_x_PM_CLKGATE_X4%4_c3 VSS x_PM_CLKGATE_X4%4_17 1.70017e-17
C_x_PM_CLKGATE_X4%4_c4 VSS x_PM_CLKGATE_X4%4_14 1.54597e-17
C_x_PM_CLKGATE_X4%4_c5 VSS x_PM_CLKGATE_X4%4_11 8.2027e-17
C_x_PM_CLKGATE_X4%4_c6 VSS N_4_M12_d 2.38958e-17
C_x_PM_CLKGATE_X4%4_c7 VSS N_4_M0_g 4.74783e-17
C_x_PM_CLKGATE_X4%4_c8 VSS N_4_M10_g 4.9065e-17
R_x_PM_CLKGATE_X4%4_r9 x_PM_CLKGATE_X4%4_19 N_4_M2_d 0.30478
R_x_PM_CLKGATE_X4%4_r10 x_PM_CLKGATE_X4%4_24 x_PM_CLKGATE_X4%4_18 0.160909
R_x_PM_CLKGATE_X4%4_r11 x_PM_CLKGATE_X4%4_19 x_PM_CLKGATE_X4%4_18 0.597143
R_x_PM_CLKGATE_X4%4_r12 x_PM_CLKGATE_X4%4_24 x_PM_CLKGATE_X4%4_17 0.160909
R_x_PM_CLKGATE_X4%4_r13 x_PM_CLKGATE_X4%4_17 x_PM_CLKGATE_X4%4_23 0.841429
R_x_PM_CLKGATE_X4%4_r14 x_PM_CLKGATE_X4%4_14 x_PM_CLKGATE_X4%4_29 5.46
R_x_PM_CLKGATE_X4%4_r15 x_PM_CLKGATE_X4%4_14 x_PM_CLKGATE_X4%4_12 25.0012
R_x_PM_CLKGATE_X4%4_r16 x_PM_CLKGATE_X4%4_24 x_PM_CLKGATE_X4%4_11 0.0418175
R_x_PM_CLKGATE_X4%4_r17 x_PM_CLKGATE_X4%4_12 x_PM_CLKGATE_X4%4_11 1.96786
R_x_PM_CLKGATE_X4%4_r18 x_PM_CLKGATE_X4%4_23 N_4_M12_d 0.30478
R_x_PM_CLKGATE_X4%4_r19 x_PM_CLKGATE_X4%4_29 x_PM_CLKGATE_X4%4_5 1.95
R_x_PM_CLKGATE_X4%4_r20 N_4_M0_g x_PM_CLKGATE_X4%4_5 42.12
R_x_PM_CLKGATE_X4%4_r21 x_PM_CLKGATE_X4%4_29 x_PM_CLKGATE_X4%4_VSS 1.95
R_x_PM_CLKGATE_X4%4_r22 N_4_M10_g x_PM_CLKGATE_X4%4_VSS 42.9
C_x_PM_CLKGATE_X4%5_c0 VSS x_PM_CLKGATE_X4%5_39 1.09717e-17
C_x_PM_CLKGATE_X4%5_c1 VSS x_PM_CLKGATE_X4%5_37 3.1219e-17
C_x_PM_CLKGATE_X4%5_c2 VSS x_PM_CLKGATE_X4%5_34 4.38108e-17
C_x_PM_CLKGATE_X4%5_c3 VSS x_PM_CLKGATE_X4%5_27 2.89873e-17
C_x_PM_CLKGATE_X4%5_c4 VSS N_5_M5_d 3.75298e-17
C_x_PM_CLKGATE_X4%5_c5 VSS x_PM_CLKGATE_X4%5_18 5.12152e-17
C_x_PM_CLKGATE_X4%5_c6 VSS x_PM_CLKGATE_X4%5_16 2.0329e-17
C_x_PM_CLKGATE_X4%5_c7 VSS x_PM_CLKGATE_X4%5_15 2.19219e-17
C_x_PM_CLKGATE_X4%5_c8 VSS x_PM_CLKGATE_X4%5_14 6.83511e-18
C_x_PM_CLKGATE_X4%5_c9 VSS N_5_M15_d 2.01502e-17
C_x_PM_CLKGATE_X4%5_c10 VSS N_5_M3_g 4.30013e-17
C_x_PM_CLKGATE_X4%5_c11 VSS x_PM_CLKGATE_X4%5_6 5.90856e-18
C_x_PM_CLKGATE_X4%5_c12 VSS x_PM_CLKGATE_X4%5_5 1.53889e-17
C_x_PM_CLKGATE_X4%5_c13 VSS N_5_M12_g 4.75436e-17
R_x_PM_CLKGATE_X4%5_r14 x_PM_CLKGATE_X4%5_37 x_PM_CLKGATE_X4%5_36 0.732857
R_x_PM_CLKGATE_X4%5_r15 x_PM_CLKGATE_X4%5_34 x_PM_CLKGATE_X4%5_32 0.732857
R_x_PM_CLKGATE_X4%5_r16 x_PM_CLKGATE_X4%5_42 x_PM_CLKGATE_X4%5_29 4.7687
R_x_PM_CLKGATE_X4%5_r17 x_PM_CLKGATE_X4%5_29 x_PM_CLKGATE_X4%5_39 3.38
R_x_PM_CLKGATE_X4%5_r18 x_PM_CLKGATE_X4%5_29 x_PM_CLKGATE_X4%5_27 25.0012
R_x_PM_CLKGATE_X4%5_r19 x_PM_CLKGATE_X4%5_37 x_PM_CLKGATE_X4%5_23 0.095
R_x_PM_CLKGATE_X4%5_r20 N_5_M5_d x_PM_CLKGATE_X4%5_23 0.746429
R_x_PM_CLKGATE_X4%5_r21 x_PM_CLKGATE_X4%5_34 x_PM_CLKGATE_X4%5_19 0.095
R_x_PM_CLKGATE_X4%5_r22 x_PM_CLKGATE_X4%5_36 x_PM_CLKGATE_X4%5_18 0.095
R_x_PM_CLKGATE_X4%5_r23 x_PM_CLKGATE_X4%5_32 x_PM_CLKGATE_X4%5_17 0.095
R_x_PM_CLKGATE_X4%5_r24 x_PM_CLKGATE_X4%5_18 x_PM_CLKGATE_X4%5_17 1.68286
R_x_PM_CLKGATE_X4%5_r25 x_PM_CLKGATE_X4%5_36 x_PM_CLKGATE_X4%5_15 0.19
R_x_PM_CLKGATE_X4%5_r26 x_PM_CLKGATE_X4%5_16 x_PM_CLKGATE_X4%5_15 1.24857
R_x_PM_CLKGATE_X4%5_r27 x_PM_CLKGATE_X4%5_16 x_PM_CLKGATE_X4%5_14 0.212317
R_x_PM_CLKGATE_X4%5_r28 x_PM_CLKGATE_X4%5_13 x_PM_CLKGATE_X4%5_27 0.30478
R_x_PM_CLKGATE_X4%5_r29 x_PM_CLKGATE_X4%5_14 x_PM_CLKGATE_X4%5_13 0.298571
R_x_PM_CLKGATE_X4%5_r30 N_5_M15_d x_PM_CLKGATE_X4%5_19 0.149286
R_x_PM_CLKGATE_X4%5_r31 N_5_M3_g x_PM_CLKGATE_X4%5_42 38.22
R_x_PM_CLKGATE_X4%5_r32 x_PM_CLKGATE_X4%5_39 x_PM_CLKGATE_X4%5_5 1.95
R_x_PM_CLKGATE_X4%5_r33 x_PM_CLKGATE_X4%5_6 x_PM_CLKGATE_X4%5_5 21.84
R_x_PM_CLKGATE_X4%5_r34 x_PM_CLKGATE_X4%5_6 x_PM_CLKGATE_X4%5_VSS 4.35808
R_x_PM_CLKGATE_X4%5_r35 N_5_M12_g x_PM_CLKGATE_X4%5_VSS 43.68
C_x_PM_CLKGATE_X4%E_c0 VSS x_PM_CLKGATE_X4%E_15 7.42586e-18
C_x_PM_CLKGATE_X4%E_c1 VSS x_PM_CLKGATE_X4%E_12 3.79078e-17
C_x_PM_CLKGATE_X4%E_c2 VSS x_PM_CLKGATE_X4%E_9 1.6739e-17
C_x_PM_CLKGATE_X4%E_c3 VSS N_E_M4_g 6.21279e-17
C_x_PM_CLKGATE_X4%E_c4 VSS N_E_M14_g 2.90272e-17
R_x_PM_CLKGATE_X4%E_r5 x_PM_CLKGATE_X4%E_18 x_PM_CLKGATE_X4%E_15 4.7687
R_x_PM_CLKGATE_X4%E_r6 x_PM_CLKGATE_X4%E_17 x_PM_CLKGATE_X4%E_15 4.7687
R_x_PM_CLKGATE_X4%E_r7 x_PM_CLKGATE_X4%E_15 x_PM_CLKGATE_X4%E_13 25.0012
R_x_PM_CLKGATE_X4%E_r8 x_PM_CLKGATE_X4%E_13 x_PM_CLKGATE_X4%E_12 0.194133
R_x_PM_CLKGATE_X4%E_r9 x_PM_CLKGATE_X4%E_12 x_PM_CLKGATE_X4%E_9 0.109591
R_x_PM_CLKGATE_X4%E_r10 E x_PM_CLKGATE_X4%E_9 0.135714
R_x_PM_CLKGATE_X4%E_r11 N_E_M4_g x_PM_CLKGATE_X4%E_18 63.18
R_x_PM_CLKGATE_X4%E_r12 N_E_M14_g x_PM_CLKGATE_X4%E_17 21.84
C_x_PM_CLKGATE_X4%7_c0 VSS x_PM_CLKGATE_X4%7_38 1.17913e-17
C_x_PM_CLKGATE_X4%7_c1 VSS N_7_M6_s 6.90021e-17
C_x_PM_CLKGATE_X4%7_c2 VSS x_PM_CLKGATE_X4%7_28 1.16362e-17
C_x_PM_CLKGATE_X4%7_c3 VSS x_PM_CLKGATE_X4%7_25 5.4441e-17
C_x_PM_CLKGATE_X4%7_c4 VSS N_7_M16_s 6.80399e-17
C_x_PM_CLKGATE_X4%7_c5 VSS x_PM_CLKGATE_X4%7_22 6.19898e-18
C_x_PM_CLKGATE_X4%7_c6 VSS N_7_M5_g 5.69405e-17
C_x_PM_CLKGATE_X4%7_c7 VSS N_7_M15_g 4.76797e-17
C_x_PM_CLKGATE_X4%7_c8 VSS x_PM_CLKGATE_X4%7_12 6.46944e-18
C_x_PM_CLKGATE_X4%7_c9 VSS x_PM_CLKGATE_X4%7_11 4.33568e-17
C_x_PM_CLKGATE_X4%7_c10 VSS N_7_M13_g 3.64711e-17
C_x_PM_CLKGATE_X4%7_c11 VSS x_PM_CLKGATE_X4%7_6 6.42268e-18
C_x_PM_CLKGATE_X4%7_c12 VSS x_PM_CLKGATE_X4%7_5 6.528e-17
C_x_PM_CLKGATE_X4%7_c13 VSS N_7_M2_g 4.41637e-17
R_x_PM_CLKGATE_X4%7_r14 x_PM_CLKGATE_X4%7_38 x_PM_CLKGATE_X4%7_34 0.254216
R_x_PM_CLKGATE_X4%7_r15 N_7_M6_s x_PM_CLKGATE_X4%7_34 2.29357
R_x_PM_CLKGATE_X4%7_r16 x_PM_CLKGATE_X4%7_38 x_PM_CLKGATE_X4%7_30 0.254216
R_x_PM_CLKGATE_X4%7_r17 x_PM_CLKGATE_X4%7_28 x_PM_CLKGATE_X4%7_26 25.0012
R_x_PM_CLKGATE_X4%7_r18 x_PM_CLKGATE_X4%7_38 x_PM_CLKGATE_X4%7_25 0.0205666
R_x_PM_CLKGATE_X4%7_r19 x_PM_CLKGATE_X4%7_26 x_PM_CLKGATE_X4%7_25 0.358889
R_x_PM_CLKGATE_X4%7_r20 N_7_M16_s x_PM_CLKGATE_X4%7_30 1.43687
R_x_PM_CLKGATE_X4%7_r21 x_PM_CLKGATE_X4%7_28 x_PM_CLKGATE_X4%7_21 6.5
R_x_PM_CLKGATE_X4%7_r22 x_PM_CLKGATE_X4%7_22 x_PM_CLKGATE_X4%7_21 0.043368
R_x_PM_CLKGATE_X4%7_r23 N_7_M5_g x_PM_CLKGATE_X4%7_18 40.56
R_x_PM_CLKGATE_X4%7_r24 x_PM_CLKGATE_X4%7_22 x_PM_CLKGATE_X4%7_17 4.56151
R_x_PM_CLKGATE_X4%7_r25 N_7_M5_g x_PM_CLKGATE_X4%7_17 44.46
R_x_PM_CLKGATE_X4%7_r26 x_PM_CLKGATE_X4%7_22 x_PM_CLKGATE_X4%7_14 4.56151
R_x_PM_CLKGATE_X4%7_r27 N_7_M15_g x_PM_CLKGATE_X4%7_14 40.56
R_x_PM_CLKGATE_X4%7_r28 N_7_M15_g x_PM_CLKGATE_X4%7_13 33.54
R_x_PM_CLKGATE_X4%7_r29 x_PM_CLKGATE_X4%7_13 x_PM_CLKGATE_X4%7_11 4.35808
R_x_PM_CLKGATE_X4%7_r30 x_PM_CLKGATE_X4%7_12 x_PM_CLKGATE_X4%7_11 51.48
R_x_PM_CLKGATE_X4%7_r31 x_PM_CLKGATE_X4%7_12 x_PM_CLKGATE_X4%7_7 4.35808
R_x_PM_CLKGATE_X4%7_r32 N_7_M13_g x_PM_CLKGATE_X4%7_7 33.54
R_x_PM_CLKGATE_X4%7_r33 x_PM_CLKGATE_X4%7_18 x_PM_CLKGATE_X4%7_5 4.35808
R_x_PM_CLKGATE_X4%7_r34 x_PM_CLKGATE_X4%7_6 x_PM_CLKGATE_X4%7_5 81.12
R_x_PM_CLKGATE_X4%7_r35 x_PM_CLKGATE_X4%7_6 x_PM_CLKGATE_X4%7_VSS 4.35808
R_x_PM_CLKGATE_X4%7_r36 N_7_M2_g x_PM_CLKGATE_X4%7_VSS 40.56
C_x_PM_CLKGATE_X4%8_c0 VSS x_PM_CLKGATE_X4%8_27 1.21863e-17
C_x_PM_CLKGATE_X4%8_c1 VSS x_PM_CLKGATE_X4%8_24 1.86442e-17
C_x_PM_CLKGATE_X4%8_c2 VSS x_PM_CLKGATE_X4%8_23 5.95403e-17
C_x_PM_CLKGATE_X4%8_c3 VSS N_8_M7_d 3.83759e-17
C_x_PM_CLKGATE_X4%8_c4 VSS x_PM_CLKGATE_X4%8_16 4.83153e-18
C_x_PM_CLKGATE_X4%8_c5 VSS x_PM_CLKGATE_X4%8_11 4.80035e-17
C_x_PM_CLKGATE_X4%8_c6 VSS N_8_M9_g 6.63453e-17
C_x_PM_CLKGATE_X4%8_c7 VSS N_8_M19_g 6.47109e-17
R_x_PM_CLKGATE_X4%8_r8 x_PM_CLKGATE_X4%8_27 x_PM_CLKGATE_X4%8_25 3.9
R_x_PM_CLKGATE_X4%8_r9 x_PM_CLKGATE_X4%8_24 x_PM_CLKGATE_X4%8_23 0.0272847
R_x_PM_CLKGATE_X4%8_r10 x_PM_CLKGATE_X4%8_23 x_PM_CLKGATE_X4%8_21 0.516176
R_x_PM_CLKGATE_X4%8_r11 x_PM_CLKGATE_X4%8_25 x_PM_CLKGATE_X4%8_21 25.0012
R_x_PM_CLKGATE_X4%8_r12 x_PM_CLKGATE_X4%8_24 x_PM_CLKGATE_X4%8_17 0.266978
R_x_PM_CLKGATE_X4%8_r13 N_8_M7_d x_PM_CLKGATE_X4%8_17 1.45214
R_x_PM_CLKGATE_X4%8_r14 x_PM_CLKGATE_X4%8_24 x_PM_CLKGATE_X4%8_16 0.266978
R_x_PM_CLKGATE_X4%8_r15 x_PM_CLKGATE_X4%8_16 x_PM_CLKGATE_X4%8_15 0.298571
R_x_PM_CLKGATE_X4%8_r16 x_PM_CLKGATE_X4%8_15 x_PM_CLKGATE_X4%8_11 0.212317
R_x_PM_CLKGATE_X4%8_r17 N_8_M17_s x_PM_CLKGATE_X4%8_11 0.855
R_x_PM_CLKGATE_X4%8_r18 x_PM_CLKGATE_X4%8_27 x_PM_CLKGATE_X4%8_5 1.95
R_x_PM_CLKGATE_X4%8_r19 N_8_M9_g x_PM_CLKGATE_X4%8_5 54.6
R_x_PM_CLKGATE_X4%8_r20 x_PM_CLKGATE_X4%8_27 x_PM_CLKGATE_X4%8_VSS 1.95
R_x_PM_CLKGATE_X4%8_r21 N_8_M19_g x_PM_CLKGATE_X4%8_VSS 48.36
C_x_PM_CLKGATE_X4%CK_c0 VSS x_PM_CLKGATE_X4%CK_21 3.63768e-17
C_x_PM_CLKGATE_X4%CK_c1 VSS x_PM_CLKGATE_X4%CK_20 4.7085e-18
C_x_PM_CLKGATE_X4%CK_c2 VSS x_PM_CLKGATE_X4%CK_19 7.06035e-18
C_x_PM_CLKGATE_X4%CK_c3 VSS x_PM_CLKGATE_X4%CK_18 6.12688e-18
C_x_PM_CLKGATE_X4%CK_c4 VSS N_CK_M7_g 4.20306e-17
C_x_PM_CLKGATE_X4%CK_c5 VSS N_CK_M17_g 2.72272e-17
C_x_PM_CLKGATE_X4%CK_c6 VSS N_CK_M6_g 5.09422e-17
C_x_PM_CLKGATE_X4%CK_c7 VSS N_CK_M16_g 5.83176e-17
R_x_PM_CLKGATE_X4%CK_r8 x_PM_CLKGATE_X4%CK_23 x_PM_CLKGATE_X4%CK_21 25.0012
R_x_PM_CLKGATE_X4%CK_r9 CK x_PM_CLKGATE_X4%CK_21 0.0135714
R_x_PM_CLKGATE_X4%CK_r10 x_PM_CLKGATE_X4%CK_23 x_PM_CLKGATE_X4%CK_19 4.42
R_x_PM_CLKGATE_X4%CK_r11 x_PM_CLKGATE_X4%CK_20 x_PM_CLKGATE_X4%CK_19 0.043368
R_x_PM_CLKGATE_X4%CK_r12 x_PM_CLKGATE_X4%CK_23 x_PM_CLKGATE_X4%CK_17 10.14
R_x_PM_CLKGATE_X4%CK_r13 x_PM_CLKGATE_X4%CK_18 x_PM_CLKGATE_X4%CK_17 0.043368
R_x_PM_CLKGATE_X4%CK_r14 x_PM_CLKGATE_X4%CK_20 x_PM_CLKGATE_X4%CK_13 4.56151
R_x_PM_CLKGATE_X4%CK_r15 N_CK_M7_g x_PM_CLKGATE_X4%CK_13 60.06
R_x_PM_CLKGATE_X4%CK_r16 x_PM_CLKGATE_X4%CK_20 x_PM_CLKGATE_X4%CK_9 4.56151
R_x_PM_CLKGATE_X4%CK_r17 N_CK_M17_g x_PM_CLKGATE_X4%CK_9 23.4
R_x_PM_CLKGATE_X4%CK_r18 x_PM_CLKGATE_X4%CK_18 x_PM_CLKGATE_X4%CK_5 4.56151
R_x_PM_CLKGATE_X4%CK_r19 N_CK_M6_g x_PM_CLKGATE_X4%CK_5 60.06
R_x_PM_CLKGATE_X4%CK_r20 x_PM_CLKGATE_X4%CK_18 x_PM_CLKGATE_X4%CK_VSS 4.56151
R_x_PM_CLKGATE_X4%CK_r21 N_CK_M16_g x_PM_CLKGATE_X4%CK_VSS 63.96
C_x_PM_CLKGATE_X4%GCK_c0 VSS x_PM_CLKGATE_X4%GCK_15 2.06972e-18
C_x_PM_CLKGATE_X4%GCK_c1 VSS N_GCK_M9_d 1.35197e-17
C_x_PM_CLKGATE_X4%GCK_c2 VSS N_GCK_M19_d 8.39706e-17
C_x_PM_CLKGATE_X4%GCK_c3 VSS x_PM_CLKGATE_X4%GCK_3 2.92473e-17
R_x_PM_CLKGATE_X4%GCK_r4 x_PM_CLKGATE_X4%GCK_15 x_PM_CLKGATE_X4%GCK_11 0.160909
R_x_PM_CLKGATE_X4%GCK_r5 N_GCK_M9_d x_PM_CLKGATE_X4%GCK_11 0.312143
R_x_PM_CLKGATE_X4%GCK_r6 x_PM_CLKGATE_X4%GCK_15 x_PM_CLKGATE_X4%GCK_7 0.160909
R_x_PM_CLKGATE_X4%GCK_r7 N_GCK_M19_d x_PM_CLKGATE_X4%GCK_7 2.51071
R_x_PM_CLKGATE_X4%GCK_r8 x_PM_CLKGATE_X4%GCK_15 x_PM_CLKGATE_X4%GCK_3 0.0418175
R_x_PM_CLKGATE_X4%GCK_r9 GCK x_PM_CLKGATE_X4%GCK_3 0.678571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   CLKGATE_X8.                                                      *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT CLKGATE_X8 VSS VDD E CK GCK
*.PININFO VSS:B VDD:B E:I CK:I GCK:O
M_M11 N_VDD_M0_d N_4_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 11 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M13 N_4_M2_d N_7_M2_g 11 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M14 12 N_5_M3_g N_4_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_VDD_M4_d N_E_M4_g 12 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M16 N_5_M5_d N_7_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_8_M7_d N_CK_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VDD_M8_d N_3_M8_g N_8_M7_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_GCK_M9_d N_8_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M21 N_VDD_M10_d N_8_M10_g N_GCK_M9_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M0 N_VSS_M11_d N_4_M11_g N_3_M11_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 13 N_3_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_4_M13_d N_5_M13_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 14 N_7_M14_g N_4_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M15_d N_E_M15_g 14 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_5_M16_d N_7_M16_g N_VSS_M15_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M17_d N_CK_M17_g N_7_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 15 N_CK_M18_g N_8_M18_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_VSS_M19_d N_3_M19_g 15 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 N_GCK_M20_d N_8_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M10 N_VSS_M21_d N_8_M21_g N_GCK_M20_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_CLKGATE_X8%VSS_c0 VSS x_PM_CLKGATE_X8%VSS_41 2.80787e-18
C_x_PM_CLKGATE_X8%VSS_c1 VSS x_PM_CLKGATE_X8%VSS_40 2.69652e-18
C_x_PM_CLKGATE_X8%VSS_c2 VSS x_PM_CLKGATE_X8%VSS_39 4.6069e-18
C_x_PM_CLKGATE_X8%VSS_c3 VSS x_PM_CLKGATE_X8%VSS_38 2.90054e-17
C_x_PM_CLKGATE_X8%VSS_c4 VSS N_VSS_M21_d 2.44691e-17
C_x_PM_CLKGATE_X8%VSS_c5 VSS x_PM_CLKGATE_X8%VSS_32 4.01249e-17
C_x_PM_CLKGATE_X8%VSS_c6 VSS N_VSS_M19_d 4.67022e-17
C_x_PM_CLKGATE_X8%VSS_c7 VSS x_PM_CLKGATE_X8%VSS_26 2.71536e-17
C_x_PM_CLKGATE_X8%VSS_c8 VSS N_VSS_M17_d 1.15917e-17
C_x_PM_CLKGATE_X8%VSS_c9 VSS x_PM_CLKGATE_X8%VSS_18 5.10716e-17
C_x_PM_CLKGATE_X8%VSS_c10 VSS N_VSS_M15_d 2.32722e-17
C_x_PM_CLKGATE_X8%VSS_c11 VSS x_PM_CLKGATE_X8%VSS_12 5.92859e-17
C_x_PM_CLKGATE_X8%VSS_c12 VSS N_VSS_M11_d 2.81398e-17
R_x_PM_CLKGATE_X8%VSS_r13 N_VSS_M21_d x_PM_CLKGATE_X8%VSS_34 0.990714
R_x_PM_CLKGATE_X8%VSS_r14 x_PM_CLKGATE_X8%VSS_41 x_PM_CLKGATE_X8%VSS_33 0.0731438
R_x_PM_CLKGATE_X8%VSS_r15 x_PM_CLKGATE_X8%VSS_34 x_PM_CLKGATE_X8%VSS_32 0.264221
R_x_PM_CLKGATE_X8%VSS_r16 x_PM_CLKGATE_X8%VSS_33 x_PM_CLKGATE_X8%VSS_32 0.681765
R_x_PM_CLKGATE_X8%VSS_r17 x_PM_CLKGATE_X8%VSS_41 x_PM_CLKGATE_X8%VSS_28 0.145286
R_x_PM_CLKGATE_X8%VSS_r18 N_VSS_M19_d x_PM_CLKGATE_X8%VSS_28 1.66929
R_x_PM_CLKGATE_X8%VSS_r19 x_PM_CLKGATE_X8%VSS_40 x_PM_CLKGATE_X8%VSS_27 0.0731438
R_x_PM_CLKGATE_X8%VSS_r20 x_PM_CLKGATE_X8%VSS_41 x_PM_CLKGATE_X8%VSS_26 0.0731438
R_x_PM_CLKGATE_X8%VSS_r21 x_PM_CLKGATE_X8%VSS_27 x_PM_CLKGATE_X8%VSS_26 0.771176
R_x_PM_CLKGATE_X8%VSS_r22 x_PM_CLKGATE_X8%VSS_40 x_PM_CLKGATE_X8%VSS_22 0.145286
R_x_PM_CLKGATE_X8%VSS_r23 N_VSS_M17_d x_PM_CLKGATE_X8%VSS_22 0.230714
R_x_PM_CLKGATE_X8%VSS_r24 x_PM_CLKGATE_X8%VSS_39 x_PM_CLKGATE_X8%VSS_19 0.0731438
R_x_PM_CLKGATE_X8%VSS_r25 VSS x_PM_CLKGATE_X8%VSS_19 0.346471
R_x_PM_CLKGATE_X8%VSS_r26 x_PM_CLKGATE_X8%VSS_40 x_PM_CLKGATE_X8%VSS_18 0.0731438
R_x_PM_CLKGATE_X8%VSS_r27 VSS x_PM_CLKGATE_X8%VSS_18 0.681765
R_x_PM_CLKGATE_X8%VSS_r28 x_PM_CLKGATE_X8%VSS_39 x_PM_CLKGATE_X8%VSS_14 0.145286
R_x_PM_CLKGATE_X8%VSS_r29 N_VSS_M15_d x_PM_CLKGATE_X8%VSS_14 0.909286
R_x_PM_CLKGATE_X8%VSS_r30 x_PM_CLKGATE_X8%VSS_38 x_PM_CLKGATE_X8%VSS_13 0.0731438
R_x_PM_CLKGATE_X8%VSS_r31 x_PM_CLKGATE_X8%VSS_39 x_PM_CLKGATE_X8%VSS_12 0.0731438
R_x_PM_CLKGATE_X8%VSS_r32 x_PM_CLKGATE_X8%VSS_13 x_PM_CLKGATE_X8%VSS_12 1.54235
R_x_PM_CLKGATE_X8%VSS_r33 x_PM_CLKGATE_X8%VSS_38 x_PM_CLKGATE_X8%VSS_8 0.145286
R_x_PM_CLKGATE_X8%VSS_r34 N_VSS_M11_d x_PM_CLKGATE_X8%VSS_8 0.909286
C_x_PM_CLKGATE_X8%VDD_c0 VSS x_PM_CLKGATE_X8%VDD_41 2.74807e-18
C_x_PM_CLKGATE_X8%VDD_c1 VSS x_PM_CLKGATE_X8%VDD_40 4.6069e-18
C_x_PM_CLKGATE_X8%VDD_c2 VSS x_PM_CLKGATE_X8%VDD_39 4.64531e-18
C_x_PM_CLKGATE_X8%VDD_c3 VSS x_PM_CLKGATE_X8%VDD_38 2.8212e-18
C_x_PM_CLKGATE_X8%VDD_c4 VSS N_VDD_M10_d 3.10734e-17
C_x_PM_CLKGATE_X8%VDD_c5 VSS x_PM_CLKGATE_X8%VDD_32 3.47006e-17
C_x_PM_CLKGATE_X8%VDD_c6 VSS N_VDD_M8_d 1.40741e-17
C_x_PM_CLKGATE_X8%VDD_c7 VSS x_PM_CLKGATE_X8%VDD_26 2.88055e-17
C_x_PM_CLKGATE_X8%VDD_c8 VSS N_VDD_M6_d 1.59966e-17
C_x_PM_CLKGATE_X8%VDD_c9 VSS x_PM_CLKGATE_X8%VDD_20 4.71102e-17
C_x_PM_CLKGATE_X8%VDD_c10 VSS N_VDD_M4_d 3.02819e-17
C_x_PM_CLKGATE_X8%VDD_c11 VSS x_PM_CLKGATE_X8%VDD_14 7.21767e-17
C_x_PM_CLKGATE_X8%VDD_c12 VSS N_VDD_M0_d 3.36385e-17
C_x_PM_CLKGATE_X8%VDD_c13 VSS x_PM_CLKGATE_X8%VDD_6 2.32779e-17
R_x_PM_CLKGATE_X8%VDD_r14 N_VDD_M10_d x_PM_CLKGATE_X8%VDD_34 0.909286
R_x_PM_CLKGATE_X8%VDD_r15 x_PM_CLKGATE_X8%VDD_41 x_PM_CLKGATE_X8%VDD_33 0.0731438
R_x_PM_CLKGATE_X8%VDD_r16 x_PM_CLKGATE_X8%VDD_34 x_PM_CLKGATE_X8%VDD_32 0.264221
R_x_PM_CLKGATE_X8%VDD_r17 x_PM_CLKGATE_X8%VDD_33 x_PM_CLKGATE_X8%VDD_32 0.726471
R_x_PM_CLKGATE_X8%VDD_r18 x_PM_CLKGATE_X8%VDD_41 x_PM_CLKGATE_X8%VDD_28 0.145286
R_x_PM_CLKGATE_X8%VDD_r19 N_VDD_M8_d x_PM_CLKGATE_X8%VDD_28 0.909286
R_x_PM_CLKGATE_X8%VDD_r20 x_PM_CLKGATE_X8%VDD_40 x_PM_CLKGATE_X8%VDD_27 0.0731438
R_x_PM_CLKGATE_X8%VDD_r21 x_PM_CLKGATE_X8%VDD_41 x_PM_CLKGATE_X8%VDD_26 0.0731438
R_x_PM_CLKGATE_X8%VDD_r22 x_PM_CLKGATE_X8%VDD_27 x_PM_CLKGATE_X8%VDD_26 0.692941
R_x_PM_CLKGATE_X8%VDD_r23 x_PM_CLKGATE_X8%VDD_40 x_PM_CLKGATE_X8%VDD_22 0.145286
R_x_PM_CLKGATE_X8%VDD_r24 N_VDD_M6_d x_PM_CLKGATE_X8%VDD_22 0.909286
R_x_PM_CLKGATE_X8%VDD_r25 x_PM_CLKGATE_X8%VDD_39 x_PM_CLKGATE_X8%VDD_21 0.0731438
R_x_PM_CLKGATE_X8%VDD_r26 x_PM_CLKGATE_X8%VDD_40 x_PM_CLKGATE_X8%VDD_20 0.0731438
R_x_PM_CLKGATE_X8%VDD_r27 x_PM_CLKGATE_X8%VDD_21 x_PM_CLKGATE_X8%VDD_20 1.06176
R_x_PM_CLKGATE_X8%VDD_r28 x_PM_CLKGATE_X8%VDD_39 x_PM_CLKGATE_X8%VDD_16 0.145286
R_x_PM_CLKGATE_X8%VDD_r29 N_VDD_M4_d x_PM_CLKGATE_X8%VDD_16 1.58786
R_x_PM_CLKGATE_X8%VDD_r30 x_PM_CLKGATE_X8%VDD_38 x_PM_CLKGATE_X8%VDD_15 0.0731438
R_x_PM_CLKGATE_X8%VDD_r31 x_PM_CLKGATE_X8%VDD_39 x_PM_CLKGATE_X8%VDD_14 0.0731438
R_x_PM_CLKGATE_X8%VDD_r32 x_PM_CLKGATE_X8%VDD_15 x_PM_CLKGATE_X8%VDD_14 1.54235
R_x_PM_CLKGATE_X8%VDD_r33 x_PM_CLKGATE_X8%VDD_38 x_PM_CLKGATE_X8%VDD_10 0.145286
R_x_PM_CLKGATE_X8%VDD_r34 N_VDD_M0_d x_PM_CLKGATE_X8%VDD_10 1.58786
R_x_PM_CLKGATE_X8%VDD_r35 x_PM_CLKGATE_X8%VDD_38 x_PM_CLKGATE_X8%VDD_6 0.0731438
R_x_PM_CLKGATE_X8%VDD_r36 VDD x_PM_CLKGATE_X8%VDD_6 0.279412
C_x_PM_CLKGATE_X8%3_c0 VSS x_PM_CLKGATE_X8%3_33 7.97122e-18
C_x_PM_CLKGATE_X8%3_c1 VSS x_PM_CLKGATE_X8%3_32 2.81515e-18
C_x_PM_CLKGATE_X8%3_c2 VSS x_PM_CLKGATE_X8%3_29 4.4492e-17
C_x_PM_CLKGATE_X8%3_c3 VSS N_3_M0_s 3.78036e-17
C_x_PM_CLKGATE_X8%3_c4 VSS N_3_M11_s 1.86404e-17
C_x_PM_CLKGATE_X8%3_c5 VSS N_3_M19_g 1.06233e-16
C_x_PM_CLKGATE_X8%3_c6 VSS x_PM_CLKGATE_X8%3_10 5.98347e-18
C_x_PM_CLKGATE_X8%3_c7 VSS x_PM_CLKGATE_X8%3_9 1.94313e-16
C_x_PM_CLKGATE_X8%3_c8 VSS N_3_M1_g 8.0586e-17
C_x_PM_CLKGATE_X8%3_c9 VSS N_3_M12_g 2.83722e-17
R_x_PM_CLKGATE_X8%3_r10 x_PM_CLKGATE_X8%3_34 x_PM_CLKGATE_X8%3_33 4.7687
R_x_PM_CLKGATE_X8%3_r11 x_PM_CLKGATE_X8%3_33 x_PM_CLKGATE_X8%3_29 25.0012
R_x_PM_CLKGATE_X8%3_r12 x_PM_CLKGATE_X8%3_32 x_PM_CLKGATE_X8%3_27 0.0569232
R_x_PM_CLKGATE_X8%3_r13 x_PM_CLKGATE_X8%3_29 x_PM_CLKGATE_X8%3_27 1.425
R_x_PM_CLKGATE_X8%3_r14 x_PM_CLKGATE_X8%3_32 x_PM_CLKGATE_X8%3_23 0.143785
R_x_PM_CLKGATE_X8%3_r15 N_3_M0_s x_PM_CLKGATE_X8%3_23 1.69643
R_x_PM_CLKGATE_X8%3_r16 x_PM_CLKGATE_X8%3_32 x_PM_CLKGATE_X8%3_19 0.143785
R_x_PM_CLKGATE_X8%3_r17 N_3_M11_s x_PM_CLKGATE_X8%3_19 0.369444
R_x_PM_CLKGATE_X8%3_r18 N_3_M8_g N_3_M19_g 95.16
R_x_PM_CLKGATE_X8%3_r19 N_3_M8_g x_PM_CLKGATE_X8%3_11 40.56
R_x_PM_CLKGATE_X8%3_r20 x_PM_CLKGATE_X8%3_11 x_PM_CLKGATE_X8%3_9 4.35808
R_x_PM_CLKGATE_X8%3_r21 x_PM_CLKGATE_X8%3_10 x_PM_CLKGATE_X8%3_9 225.42
R_x_PM_CLKGATE_X8%3_r22 x_PM_CLKGATE_X8%3_10 x_PM_CLKGATE_X8%3_6 4.35808
R_x_PM_CLKGATE_X8%3_r23 N_3_M1_g x_PM_CLKGATE_X8%3_6 60.06
R_x_PM_CLKGATE_X8%3_r24 x_PM_CLKGATE_X8%3_5 x_PM_CLKGATE_X8%3_33 4.7687
R_x_PM_CLKGATE_X8%3_r25 N_3_M1_g x_PM_CLKGATE_X8%3_5 63.18
R_x_PM_CLKGATE_X8%3_r26 N_3_M12_g x_PM_CLKGATE_X8%3_34 21.84
C_x_PM_CLKGATE_X8%4_c0 VSS x_PM_CLKGATE_X8%4_28 8.82223e-18
C_x_PM_CLKGATE_X8%4_c1 VSS N_4_M2_d 1.3596e-17
C_x_PM_CLKGATE_X8%4_c2 VSS x_PM_CLKGATE_X8%4_24 8.99067e-18
C_x_PM_CLKGATE_X8%4_c3 VSS x_PM_CLKGATE_X8%4_20 1.04247e-17
C_x_PM_CLKGATE_X8%4_c4 VSS x_PM_CLKGATE_X8%4_19 6.20031e-18
C_x_PM_CLKGATE_X8%4_c5 VSS x_PM_CLKGATE_X8%4_17 5.61833e-17
C_x_PM_CLKGATE_X8%4_c6 VSS x_PM_CLKGATE_X8%4_14 1.54683e-17
C_x_PM_CLKGATE_X8%4_c7 VSS x_PM_CLKGATE_X8%4_11 4.86258e-17
C_x_PM_CLKGATE_X8%4_c8 VSS N_4_M13_d 1.26146e-17
C_x_PM_CLKGATE_X8%4_c9 VSS N_4_M0_g 3.80885e-17
C_x_PM_CLKGATE_X8%4_c10 VSS N_4_M11_g 5.8273e-17
R_x_PM_CLKGATE_X8%4_r11 N_4_M2_d x_PM_CLKGATE_X8%4_24 0.257857
R_x_PM_CLKGATE_X8%4_r12 x_PM_CLKGATE_X8%4_24 x_PM_CLKGATE_X8%4_19 0.212317
R_x_PM_CLKGATE_X8%4_r13 x_PM_CLKGATE_X8%4_28 x_PM_CLKGATE_X8%4_18 0.160909
R_x_PM_CLKGATE_X8%4_r14 x_PM_CLKGATE_X8%4_19 x_PM_CLKGATE_X8%4_18 0.298571
R_x_PM_CLKGATE_X8%4_r15 x_PM_CLKGATE_X8%4_28 x_PM_CLKGATE_X8%4_17 0.160909
R_x_PM_CLKGATE_X8%4_r16 x_PM_CLKGATE_X8%4_20 x_PM_CLKGATE_X8%4_16 0.212317
R_x_PM_CLKGATE_X8%4_r17 x_PM_CLKGATE_X8%4_17 x_PM_CLKGATE_X8%4_16 1.49286
R_x_PM_CLKGATE_X8%4_r18 x_PM_CLKGATE_X8%4_14 x_PM_CLKGATE_X8%4_29 5.46
R_x_PM_CLKGATE_X8%4_r19 x_PM_CLKGATE_X8%4_14 x_PM_CLKGATE_X8%4_12 25.0012
R_x_PM_CLKGATE_X8%4_r20 x_PM_CLKGATE_X8%4_28 x_PM_CLKGATE_X8%4_11 0.0418175
R_x_PM_CLKGATE_X8%4_r21 x_PM_CLKGATE_X8%4_12 x_PM_CLKGATE_X8%4_11 1.64214
R_x_PM_CLKGATE_X8%4_r22 N_4_M13_d x_PM_CLKGATE_X8%4_20 0.257857
R_x_PM_CLKGATE_X8%4_r23 x_PM_CLKGATE_X8%4_29 x_PM_CLKGATE_X8%4_5 1.95
R_x_PM_CLKGATE_X8%4_r24 N_4_M0_g x_PM_CLKGATE_X8%4_5 28.86
R_x_PM_CLKGATE_X8%4_r25 x_PM_CLKGATE_X8%4_29 x_PM_CLKGATE_X8%4_VSS 1.95
R_x_PM_CLKGATE_X8%4_r26 N_4_M11_g x_PM_CLKGATE_X8%4_VSS 56.16
C_x_PM_CLKGATE_X8%5_c0 VSS N_5_M5_d 4.03874e-17
C_x_PM_CLKGATE_X8%5_c1 VSS x_PM_CLKGATE_X8%5_33 2.23132e-17
C_x_PM_CLKGATE_X8%5_c2 VSS x_PM_CLKGATE_X8%5_31 2.98179e-17
C_x_PM_CLKGATE_X8%5_c3 VSS x_PM_CLKGATE_X8%5_23 3.9487e-17
C_x_PM_CLKGATE_X8%5_c4 VSS x_PM_CLKGATE_X8%5_18 7.86818e-18
C_x_PM_CLKGATE_X8%5_c5 VSS x_PM_CLKGATE_X8%5_16 2.43666e-17
C_x_PM_CLKGATE_X8%5_c6 VSS x_PM_CLKGATE_X8%5_13 4.51532e-17
C_x_PM_CLKGATE_X8%5_c7 VSS N_5_M16_d 2.64012e-17
C_x_PM_CLKGATE_X8%5_c8 VSS x_PM_CLKGATE_X8%5_10 2.18253e-17
C_x_PM_CLKGATE_X8%5_c9 VSS x_PM_CLKGATE_X8%5_9 9.35485e-18
C_x_PM_CLKGATE_X8%5_c10 VSS N_5_M3_g 4.42688e-17
C_x_PM_CLKGATE_X8%5_c11 VSS N_5_M13_g 5.32422e-17
R_x_PM_CLKGATE_X8%5_r12 N_5_M5_d x_PM_CLKGATE_X8%5_34 0.274444
R_x_PM_CLKGATE_X8%5_r13 x_PM_CLKGATE_X8%5_31 x_PM_CLKGATE_X8%5_29 0.515714
R_x_PM_CLKGATE_X8%5_r14 x_PM_CLKGATE_X8%5_25 x_PM_CLKGATE_X8%5_23 25.0012
R_x_PM_CLKGATE_X8%5_r15 x_PM_CLKGATE_X8%5_27 x_PM_CLKGATE_X8%5_23 0.176429
R_x_PM_CLKGATE_X8%5_r16 x_PM_CLKGATE_X8%5_31 x_PM_CLKGATE_X8%5_19 0.095
R_x_PM_CLKGATE_X8%5_r17 x_PM_CLKGATE_X8%5_34 x_PM_CLKGATE_X8%5_18 0.095
R_x_PM_CLKGATE_X8%5_r18 x_PM_CLKGATE_X8%5_33 x_PM_CLKGATE_X8%5_17 0.160909
R_x_PM_CLKGATE_X8%5_r19 x_PM_CLKGATE_X8%5_18 x_PM_CLKGATE_X8%5_17 0.352857
R_x_PM_CLKGATE_X8%5_r20 x_PM_CLKGATE_X8%5_33 x_PM_CLKGATE_X8%5_16 0.160909
R_x_PM_CLKGATE_X8%5_r21 x_PM_CLKGATE_X8%5_29 x_PM_CLKGATE_X8%5_15 0.095
R_x_PM_CLKGATE_X8%5_r22 x_PM_CLKGATE_X8%5_16 x_PM_CLKGATE_X8%5_15 0.705714
R_x_PM_CLKGATE_X8%5_r23 x_PM_CLKGATE_X8%5_27 x_PM_CLKGATE_X8%5_14 0.095
R_x_PM_CLKGATE_X8%5_r24 x_PM_CLKGATE_X8%5_33 x_PM_CLKGATE_X8%5_13 0.0418175
R_x_PM_CLKGATE_X8%5_r25 x_PM_CLKGATE_X8%5_14 x_PM_CLKGATE_X8%5_13 1.9
R_x_PM_CLKGATE_X8%5_r26 N_5_M16_d x_PM_CLKGATE_X8%5_19 0.366429
R_x_PM_CLKGATE_X8%5_r27 x_PM_CLKGATE_X8%5_25 x_PM_CLKGATE_X8%5_10 1.82
R_x_PM_CLKGATE_X8%5_r28 x_PM_CLKGATE_X8%5_25 x_PM_CLKGATE_X8%5_9 12.74
R_x_PM_CLKGATE_X8%5_r29 x_PM_CLKGATE_X8%5_10 x_PM_CLKGATE_X8%5_5 4.58872
R_x_PM_CLKGATE_X8%5_r30 N_5_M3_g x_PM_CLKGATE_X8%5_5 40.56
R_x_PM_CLKGATE_X8%5_r31 x_PM_CLKGATE_X8%5_9 x_PM_CLKGATE_X8%5_VSS 4.58872
R_x_PM_CLKGATE_X8%5_r32 N_5_M13_g x_PM_CLKGATE_X8%5_VSS 44.46
C_x_PM_CLKGATE_X8%E_c0 VSS x_PM_CLKGATE_X8%E_14 7.4151e-18
C_x_PM_CLKGATE_X8%E_c1 VSS x_PM_CLKGATE_X8%E_12 5.13272e-17
C_x_PM_CLKGATE_X8%E_c2 VSS N_E_M4_g 6.10007e-17
C_x_PM_CLKGATE_X8%E_c3 VSS N_E_M15_g 2.98678e-17
R_x_PM_CLKGATE_X8%E_r4 x_PM_CLKGATE_X8%E_18 x_PM_CLKGATE_X8%E_14 4.7687
R_x_PM_CLKGATE_X8%E_r5 x_PM_CLKGATE_X8%E_17 x_PM_CLKGATE_X8%E_14 4.7687
R_x_PM_CLKGATE_X8%E_r6 x_PM_CLKGATE_X8%E_14 x_PM_CLKGATE_X8%E_12 25.0012
R_x_PM_CLKGATE_X8%E_r7 x_PM_CLKGATE_X8%E_12 E 0.2375
R_x_PM_CLKGATE_X8%E_r8 N_E_M4_g x_PM_CLKGATE_X8%E_18 62.4
R_x_PM_CLKGATE_X8%E_r9 N_E_M15_g x_PM_CLKGATE_X8%E_17 22.62
C_x_PM_CLKGATE_X8%7_c0 VSS x_PM_CLKGATE_X8%7_38 5.80328e-17
C_x_PM_CLKGATE_X8%7_c1 VSS x_PM_CLKGATE_X8%7_35 1.84141e-17
C_x_PM_CLKGATE_X8%7_c2 VSS N_7_M6_s 3.97158e-17
C_x_PM_CLKGATE_X8%7_c3 VSS N_7_M17_s 7.47981e-17
C_x_PM_CLKGATE_X8%7_c4 VSS x_PM_CLKGATE_X8%7_22 4.98395e-18
C_x_PM_CLKGATE_X8%7_c5 VSS N_7_M5_g 4.89363e-17
C_x_PM_CLKGATE_X8%7_c6 VSS N_7_M16_g 4.98043e-17
C_x_PM_CLKGATE_X8%7_c7 VSS x_PM_CLKGATE_X8%7_12 6.45939e-18
C_x_PM_CLKGATE_X8%7_c8 VSS x_PM_CLKGATE_X8%7_11 4.37356e-17
C_x_PM_CLKGATE_X8%7_c9 VSS N_7_M14_g 3.58243e-17
C_x_PM_CLKGATE_X8%7_c10 VSS x_PM_CLKGATE_X8%7_6 6.42268e-18
C_x_PM_CLKGATE_X8%7_c11 VSS x_PM_CLKGATE_X8%7_5 6.49336e-17
C_x_PM_CLKGATE_X8%7_c12 VSS N_7_M2_g 4.94349e-17
R_x_PM_CLKGATE_X8%7_r13 x_PM_CLKGATE_X8%7_38 x_PM_CLKGATE_X8%7_37 0.0140741
R_x_PM_CLKGATE_X8%7_r14 x_PM_CLKGATE_X8%7_35 x_PM_CLKGATE_X8%7_33 25.0012
R_x_PM_CLKGATE_X8%7_r15 x_PM_CLKGATE_X8%7_37 x_PM_CLKGATE_X8%7_33 0.358889
R_x_PM_CLKGATE_X8%7_r16 x_PM_CLKGATE_X8%7_38 x_PM_CLKGATE_X8%7_29 0.095
R_x_PM_CLKGATE_X8%7_r17 N_7_M6_s x_PM_CLKGATE_X8%7_29 1.39786
R_x_PM_CLKGATE_X8%7_r18 x_PM_CLKGATE_X8%7_37 x_PM_CLKGATE_X8%7_25 0.095
R_x_PM_CLKGATE_X8%7_r19 N_7_M17_s x_PM_CLKGATE_X8%7_25 1.55562
R_x_PM_CLKGATE_X8%7_r20 x_PM_CLKGATE_X8%7_35 x_PM_CLKGATE_X8%7_21 10.66
R_x_PM_CLKGATE_X8%7_r21 x_PM_CLKGATE_X8%7_22 x_PM_CLKGATE_X8%7_21 0.043368
R_x_PM_CLKGATE_X8%7_r22 N_7_M5_g x_PM_CLKGATE_X8%7_18 40.56
R_x_PM_CLKGATE_X8%7_r23 x_PM_CLKGATE_X8%7_22 x_PM_CLKGATE_X8%7_17 4.56151
R_x_PM_CLKGATE_X8%7_r24 N_7_M5_g x_PM_CLKGATE_X8%7_17 40.56
R_x_PM_CLKGATE_X8%7_r25 x_PM_CLKGATE_X8%7_22 x_PM_CLKGATE_X8%7_14 4.56151
R_x_PM_CLKGATE_X8%7_r26 N_7_M16_g x_PM_CLKGATE_X8%7_14 44.46
R_x_PM_CLKGATE_X8%7_r27 N_7_M16_g x_PM_CLKGATE_X8%7_13 33.54
R_x_PM_CLKGATE_X8%7_r28 x_PM_CLKGATE_X8%7_13 x_PM_CLKGATE_X8%7_11 4.35808
R_x_PM_CLKGATE_X8%7_r29 x_PM_CLKGATE_X8%7_12 x_PM_CLKGATE_X8%7_11 51.48
R_x_PM_CLKGATE_X8%7_r30 x_PM_CLKGATE_X8%7_12 x_PM_CLKGATE_X8%7_7 4.35808
R_x_PM_CLKGATE_X8%7_r31 N_7_M14_g x_PM_CLKGATE_X8%7_7 33.54
R_x_PM_CLKGATE_X8%7_r32 x_PM_CLKGATE_X8%7_18 x_PM_CLKGATE_X8%7_5 4.35808
R_x_PM_CLKGATE_X8%7_r33 x_PM_CLKGATE_X8%7_6 x_PM_CLKGATE_X8%7_5 81.12
R_x_PM_CLKGATE_X8%7_r34 x_PM_CLKGATE_X8%7_6 x_PM_CLKGATE_X8%7_VSS 4.35808
R_x_PM_CLKGATE_X8%7_r35 N_7_M2_g x_PM_CLKGATE_X8%7_VSS 40.56
C_x_PM_CLKGATE_X8%8_c0 VSS x_PM_CLKGATE_X8%8_33 1.83565e-17
C_x_PM_CLKGATE_X8%8_c1 VSS x_PM_CLKGATE_X8%8_32 5.71681e-17
C_x_PM_CLKGATE_X8%8_c2 VSS N_8_M7_d 3.09457e-17
C_x_PM_CLKGATE_X8%8_c3 VSS x_PM_CLKGATE_X8%8_25 9.3477e-18
C_x_PM_CLKGATE_X8%8_c4 VSS x_PM_CLKGATE_X8%8_23 5.88099e-17
C_x_PM_CLKGATE_X8%8_c5 VSS x_PM_CLKGATE_X8%8_19 3.30952e-18
C_x_PM_CLKGATE_X8%8_c6 VSS N_8_M10_g 4.25134e-17
C_x_PM_CLKGATE_X8%8_c7 VSS N_8_M21_g 4.43073e-17
C_x_PM_CLKGATE_X8%8_c8 VSS x_PM_CLKGATE_X8%8_10 5.82162e-18
C_x_PM_CLKGATE_X8%8_c9 VSS x_PM_CLKGATE_X8%8_9 1.21427e-17
C_x_PM_CLKGATE_X8%8_c10 VSS N_8_M9_g 3.85511e-17
C_x_PM_CLKGATE_X8%8_c11 VSS N_8_M20_g 4.59143e-17
R_x_PM_CLKGATE_X8%8_r12 x_PM_CLKGATE_X8%8_36 x_PM_CLKGATE_X8%8_34 3.38
R_x_PM_CLKGATE_X8%8_r13 x_PM_CLKGATE_X8%8_33 x_PM_CLKGATE_X8%8_32 0.0272847
R_x_PM_CLKGATE_X8%8_r14 x_PM_CLKGATE_X8%8_32 x_PM_CLKGATE_X8%8_30 0.60062
R_x_PM_CLKGATE_X8%8_r15 x_PM_CLKGATE_X8%8_34 x_PM_CLKGATE_X8%8_30 25.0012
R_x_PM_CLKGATE_X8%8_r16 x_PM_CLKGATE_X8%8_33 x_PM_CLKGATE_X8%8_26 0.266978
R_x_PM_CLKGATE_X8%8_r17 N_8_M7_d x_PM_CLKGATE_X8%8_26 1.26214
R_x_PM_CLKGATE_X8%8_r18 x_PM_CLKGATE_X8%8_33 x_PM_CLKGATE_X8%8_25 0.266978
R_x_PM_CLKGATE_X8%8_r19 x_PM_CLKGATE_X8%8_25 x_PM_CLKGATE_X8%8_24 0.488571
R_x_PM_CLKGATE_X8%8_r20 x_PM_CLKGATE_X8%8_24 x_PM_CLKGATE_X8%8_23 0.241334
R_x_PM_CLKGATE_X8%8_r21 x_PM_CLKGATE_X8%8_23 N_8_M18_s 0.347287
R_x_PM_CLKGATE_X8%8_r22 x_PM_CLKGATE_X8%8_19 x_PM_CLKGATE_X8%8_15 4.56151
R_x_PM_CLKGATE_X8%8_r23 N_8_M10_g x_PM_CLKGATE_X8%8_15 49.14
R_x_PM_CLKGATE_X8%8_r24 x_PM_CLKGATE_X8%8_19 x_PM_CLKGATE_X8%8_11 4.56151
R_x_PM_CLKGATE_X8%8_r25 N_8_M21_g x_PM_CLKGATE_X8%8_11 53.82
R_x_PM_CLKGATE_X8%8_r26 x_PM_CLKGATE_X8%8_36 x_PM_CLKGATE_X8%8_10 2.6
R_x_PM_CLKGATE_X8%8_r27 x_PM_CLKGATE_X8%8_19 x_PM_CLKGATE_X8%8_9 0.043368
R_x_PM_CLKGATE_X8%8_r28 x_PM_CLKGATE_X8%8_10 x_PM_CLKGATE_X8%8_9 14.56
R_x_PM_CLKGATE_X8%8_r29 x_PM_CLKGATE_X8%8_36 x_PM_CLKGATE_X8%8_5 1.95
R_x_PM_CLKGATE_X8%8_r30 N_8_M9_g x_PM_CLKGATE_X8%8_5 49.14
R_x_PM_CLKGATE_X8%8_r31 x_PM_CLKGATE_X8%8_36 x_PM_CLKGATE_X8%8_VSS 1.95
R_x_PM_CLKGATE_X8%8_r32 N_8_M20_g x_PM_CLKGATE_X8%8_VSS 53.82
C_x_PM_CLKGATE_X8%CK_c0 VSS x_PM_CLKGATE_X8%CK_21 3.70469e-17
C_x_PM_CLKGATE_X8%CK_c1 VSS x_PM_CLKGATE_X8%CK_20 4.73094e-18
C_x_PM_CLKGATE_X8%CK_c2 VSS x_PM_CLKGATE_X8%CK_19 6.33095e-18
C_x_PM_CLKGATE_X8%CK_c3 VSS x_PM_CLKGATE_X8%CK_18 5.5242e-18
C_x_PM_CLKGATE_X8%CK_c4 VSS N_CK_M7_g 4.20248e-17
C_x_PM_CLKGATE_X8%CK_c5 VSS N_CK_M18_g 2.87066e-17
C_x_PM_CLKGATE_X8%CK_c6 VSS N_CK_M6_g 4.79958e-17
C_x_PM_CLKGATE_X8%CK_c7 VSS N_CK_M17_g 5.9021e-17
R_x_PM_CLKGATE_X8%CK_r8 x_PM_CLKGATE_X8%CK_23 x_PM_CLKGATE_X8%CK_21 25.0012
R_x_PM_CLKGATE_X8%CK_r9 CK x_PM_CLKGATE_X8%CK_21 0.0135714
R_x_PM_CLKGATE_X8%CK_r10 x_PM_CLKGATE_X8%CK_23 x_PM_CLKGATE_X8%CK_19 5.46
R_x_PM_CLKGATE_X8%CK_r11 x_PM_CLKGATE_X8%CK_20 x_PM_CLKGATE_X8%CK_19 0.043368
R_x_PM_CLKGATE_X8%CK_r12 x_PM_CLKGATE_X8%CK_23 x_PM_CLKGATE_X8%CK_17 9.1
R_x_PM_CLKGATE_X8%CK_r13 x_PM_CLKGATE_X8%CK_18 x_PM_CLKGATE_X8%CK_17 0.043368
R_x_PM_CLKGATE_X8%CK_r14 x_PM_CLKGATE_X8%CK_20 x_PM_CLKGATE_X8%CK_13 4.56151
R_x_PM_CLKGATE_X8%CK_r15 N_CK_M7_g x_PM_CLKGATE_X8%CK_13 60.06
R_x_PM_CLKGATE_X8%CK_r16 x_PM_CLKGATE_X8%CK_20 x_PM_CLKGATE_X8%CK_9 4.56151
R_x_PM_CLKGATE_X8%CK_r17 N_CK_M18_g x_PM_CLKGATE_X8%CK_9 23.4
R_x_PM_CLKGATE_X8%CK_r18 x_PM_CLKGATE_X8%CK_18 x_PM_CLKGATE_X8%CK_5 4.56151
R_x_PM_CLKGATE_X8%CK_r19 N_CK_M6_g x_PM_CLKGATE_X8%CK_5 60.06
R_x_PM_CLKGATE_X8%CK_r20 x_PM_CLKGATE_X8%CK_18 x_PM_CLKGATE_X8%CK_VSS 4.56151
R_x_PM_CLKGATE_X8%CK_r21 N_CK_M17_g x_PM_CLKGATE_X8%CK_VSS 63.96
C_x_PM_CLKGATE_X8%GCK_c0 VSS N_GCK_M20_d 1.41062e-16
R_x_PM_CLKGATE_X8%GCK_r1 N_GCK_M9_d GCK 2.02214
R_x_PM_CLKGATE_X8%GCK_r2 GCK N_GCK_M20_d 1.18071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X1 VSS VDD Q QN SN CK RN D
*.PININFO VSS:B VDD:B Q:O QN:O SN:I CK:I RN:I D:I
M_M20 N_VDD_M0_d N_10_M0_g N_Q_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M21 N_QN_M1_d N_5_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M22 N_5_M2_d N_SN_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M23 N_VDD_M3_d N_10_M3_g N_5_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M24 N_VDD_M4_d N_CK_M4_g N_7_M4_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 16 N_SN_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_9_M6_d N_11_M6_g 16 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 17 N_10_M7_g N_VDD_M7_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 N_9_M8_d N_11_M8_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 18 N_12_M9_g N_9_M8_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_VDD_M10_d N_7_M10_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M31 N_10_M11_d N_9_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M32 N_VDD_M12_d N_RN_M12_g N_10_M11_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M33 N_11_M13_d N_7_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M34 19 N_7_M14_g N_12_M14_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 N_VDD_M15_d N_14_M15_g 19 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M36 20 N_RN_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.315000U L=0.050000U
M_M37 N_12_M17_d N_7_M17_g 20 VDD PMOS_VTL W=0.315000U L=0.050000U
M_M38 21 N_D_M18_g N_12_M17_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M39 N_VDD_M19_d N_11_M19_g 21 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M40 N_14_M20_d N_12_M20_g N_VDD_M19_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M41 N_VDD_M21_d N_SN_M21_g N_14_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M22_d N_10_M22_g N_Q_M22_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_QN_M23_d N_5_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 22 N_SN_M24_g N_5_M24_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_VSS_M25_d N_10_M25_g 22 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_VSS_M26_d N_CK_M26_g N_7_M26_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 23 N_SN_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 24 N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_9_M29_d N_7_M29_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 25 N_11_M30_g N_9_M29_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_VSS_M31_d N_12_M31_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_11_M32_d N_7_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M11 26 N_9_M33_g N_10_M33_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M12 N_VSS_M34_d N_RN_M34_g 26 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M13 27 N_RN_M35_g N_VSS_M34_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 28 N_14_M36_g 27 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_12_M37_d N_11_M37_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 29 N_7_M38_g N_12_M37_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_VSS_M39_d N_D_M39_g 29 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 30 N_12_M40_g N_14_M40_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M19 N_VSS_M41_d N_SN_M41_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DFFRS_X1%VSS_c0 VSS x_PM_DFFRS_X1%VSS_53 8.86015e-18
C_x_PM_DFFRS_X1%VSS_c1 VSS x_PM_DFFRS_X1%VSS_52 4.63549e-18
C_x_PM_DFFRS_X1%VSS_c2 VSS x_PM_DFFRS_X1%VSS_51 8.94265e-18
C_x_PM_DFFRS_X1%VSS_c3 VSS x_PM_DFFRS_X1%VSS_50 4.64531e-18
C_x_PM_DFFRS_X1%VSS_c4 VSS x_PM_DFFRS_X1%VSS_49 4.62343e-18
C_x_PM_DFFRS_X1%VSS_c5 VSS x_PM_DFFRS_X1%VSS_48 3.96768e-17
C_x_PM_DFFRS_X1%VSS_c6 VSS N_VSS_M41_d 2.01177e-17
C_x_PM_DFFRS_X1%VSS_c7 VSS x_PM_DFFRS_X1%VSS_44 1.14915e-17
C_x_PM_DFFRS_X1%VSS_c8 VSS x_PM_DFFRS_X1%VSS_42 5.03833e-17
C_x_PM_DFFRS_X1%VSS_c9 VSS x_PM_DFFRS_X1%VSS_41 6.2913e-17
C_x_PM_DFFRS_X1%VSS_c10 VSS x_PM_DFFRS_X1%VSS_38 1.9734e-16
C_x_PM_DFFRS_X1%VSS_c11 VSS N_VSS_M34_d 5.91528e-17
C_x_PM_DFFRS_X1%VSS_c12 VSS x_PM_DFFRS_X1%VSS_32 1.03644e-16
C_x_PM_DFFRS_X1%VSS_c13 VSS N_VSS_M31_d 6.56635e-17
C_x_PM_DFFRS_X1%VSS_c14 VSS x_PM_DFFRS_X1%VSS_26 1.41436e-16
C_x_PM_DFFRS_X1%VSS_c15 VSS N_VSS_M26_d 5.82306e-17
C_x_PM_DFFRS_X1%VSS_c16 VSS x_PM_DFFRS_X1%VSS_20 3.40043e-17
C_x_PM_DFFRS_X1%VSS_c17 VSS N_VSS_M25_d 2.30537e-17
C_x_PM_DFFRS_X1%VSS_c18 VSS x_PM_DFFRS_X1%VSS_14 7.36993e-17
C_x_PM_DFFRS_X1%VSS_c19 VSS N_VSS_M22_d 3.11924e-17
R_x_PM_DFFRS_X1%VSS_r20 VSS x_PM_DFFRS_X1%VSS_44 0.155702
R_x_PM_DFFRS_X1%VSS_r21 N_VSS_M41_d x_PM_DFFRS_X1%VSS_44 0.909286
R_x_PM_DFFRS_X1%VSS_r22 x_PM_DFFRS_X1%VSS_53 x_PM_DFFRS_X1%VSS_43 0.132285
R_x_PM_DFFRS_X1%VSS_r23 VSS x_PM_DFFRS_X1%VSS_42 0.10852
R_x_PM_DFFRS_X1%VSS_r24 x_PM_DFFRS_X1%VSS_43 x_PM_DFFRS_X1%VSS_42 1.03941
R_x_PM_DFFRS_X1%VSS_r25 x_PM_DFFRS_X1%VSS_53 x_PM_DFFRS_X1%VSS_41 0.0680382
R_x_PM_DFFRS_X1%VSS_r26 x_PM_DFFRS_X1%VSS_41 N_VSS_M39_d 0.403583
R_x_PM_DFFRS_X1%VSS_r27 x_PM_DFFRS_X1%VSS_52 x_PM_DFFRS_X1%VSS_39 0.0731438
R_x_PM_DFFRS_X1%VSS_r28 x_PM_DFFRS_X1%VSS_53 x_PM_DFFRS_X1%VSS_38 0.132285
R_x_PM_DFFRS_X1%VSS_r29 x_PM_DFFRS_X1%VSS_39 x_PM_DFFRS_X1%VSS_38 2.16824
R_x_PM_DFFRS_X1%VSS_r30 x_PM_DFFRS_X1%VSS_52 x_PM_DFFRS_X1%VSS_34 0.145286
R_x_PM_DFFRS_X1%VSS_r31 N_VSS_M34_d x_PM_DFFRS_X1%VSS_34 1.39786
R_x_PM_DFFRS_X1%VSS_r32 x_PM_DFFRS_X1%VSS_51 x_PM_DFFRS_X1%VSS_33 0.132285
R_x_PM_DFFRS_X1%VSS_r33 x_PM_DFFRS_X1%VSS_52 x_PM_DFFRS_X1%VSS_32 0.0731438
R_x_PM_DFFRS_X1%VSS_r34 x_PM_DFFRS_X1%VSS_33 x_PM_DFFRS_X1%VSS_32 1.93353
R_x_PM_DFFRS_X1%VSS_r35 x_PM_DFFRS_X1%VSS_51 x_PM_DFFRS_X1%VSS_28 0.0680382
R_x_PM_DFFRS_X1%VSS_r36 N_VSS_M31_d x_PM_DFFRS_X1%VSS_28 0.837407
R_x_PM_DFFRS_X1%VSS_r37 x_PM_DFFRS_X1%VSS_50 x_PM_DFFRS_X1%VSS_27 0.0731438
R_x_PM_DFFRS_X1%VSS_r38 x_PM_DFFRS_X1%VSS_51 x_PM_DFFRS_X1%VSS_26 0.132285
R_x_PM_DFFRS_X1%VSS_r39 x_PM_DFFRS_X1%VSS_27 x_PM_DFFRS_X1%VSS_26 2.09
R_x_PM_DFFRS_X1%VSS_r40 x_PM_DFFRS_X1%VSS_50 x_PM_DFFRS_X1%VSS_22 0.145286
R_x_PM_DFFRS_X1%VSS_r41 N_VSS_M26_d x_PM_DFFRS_X1%VSS_22 1.58786
R_x_PM_DFFRS_X1%VSS_r42 x_PM_DFFRS_X1%VSS_49 x_PM_DFFRS_X1%VSS_21 0.0731438
R_x_PM_DFFRS_X1%VSS_r43 x_PM_DFFRS_X1%VSS_50 x_PM_DFFRS_X1%VSS_20 0.0731438
R_x_PM_DFFRS_X1%VSS_r44 x_PM_DFFRS_X1%VSS_21 x_PM_DFFRS_X1%VSS_20 0.771176
R_x_PM_DFFRS_X1%VSS_r45 x_PM_DFFRS_X1%VSS_49 x_PM_DFFRS_X1%VSS_16 0.145286
R_x_PM_DFFRS_X1%VSS_r46 N_VSS_M25_d x_PM_DFFRS_X1%VSS_16 1.18071
R_x_PM_DFFRS_X1%VSS_r47 x_PM_DFFRS_X1%VSS_48 x_PM_DFFRS_X1%VSS_15 0.0731438
R_x_PM_DFFRS_X1%VSS_r48 x_PM_DFFRS_X1%VSS_49 x_PM_DFFRS_X1%VSS_14 0.0731438
R_x_PM_DFFRS_X1%VSS_r49 x_PM_DFFRS_X1%VSS_15 x_PM_DFFRS_X1%VSS_14 1.44176
R_x_PM_DFFRS_X1%VSS_r50 x_PM_DFFRS_X1%VSS_48 x_PM_DFFRS_X1%VSS_10 0.145286
R_x_PM_DFFRS_X1%VSS_r51 N_VSS_M22_d x_PM_DFFRS_X1%VSS_10 0.637857
C_x_PM_DFFRS_X1%VDD_c0 VSS x_PM_DFFRS_X1%VDD_79 2.76616e-18
C_x_PM_DFFRS_X1%VDD_c1 VSS x_PM_DFFRS_X1%VDD_78 8.89791e-18
C_x_PM_DFFRS_X1%VDD_c2 VSS x_PM_DFFRS_X1%VDD_77 4.6069e-18
C_x_PM_DFFRS_X1%VDD_c3 VSS x_PM_DFFRS_X1%VDD_76 4.6069e-18
C_x_PM_DFFRS_X1%VDD_c4 VSS x_PM_DFFRS_X1%VDD_75 4.64667e-18
C_x_PM_DFFRS_X1%VDD_c5 VSS x_PM_DFFRS_X1%VDD_74 2.91027e-18
C_x_PM_DFFRS_X1%VDD_c6 VSS x_PM_DFFRS_X1%VDD_73 2.74807e-18
C_x_PM_DFFRS_X1%VDD_c7 VSS x_PM_DFFRS_X1%VDD_72 4.6069e-18
C_x_PM_DFFRS_X1%VDD_c8 VSS x_PM_DFFRS_X1%VDD_71 4.6069e-18
C_x_PM_DFFRS_X1%VDD_c9 VSS N_VDD_M21_d 9.13352e-18
C_x_PM_DFFRS_X1%VDD_c10 VSS x_PM_DFFRS_X1%VDD_65 4.20088e-17
C_x_PM_DFFRS_X1%VDD_c11 VSS N_VDD_M19_d 5.13887e-17
C_x_PM_DFFRS_X1%VDD_c12 VSS x_PM_DFFRS_X1%VDD_59 8.47289e-17
C_x_PM_DFFRS_X1%VDD_c13 VSS x_PM_DFFRS_X1%VDD_58 9.45781e-17
C_x_PM_DFFRS_X1%VDD_c14 VSS x_PM_DFFRS_X1%VDD_55 1.3485e-16
C_x_PM_DFFRS_X1%VDD_c15 VSS N_VDD_M12_d 3.96796e-17
C_x_PM_DFFRS_X1%VDD_c16 VSS x_PM_DFFRS_X1%VDD_49 5.52519e-17
C_x_PM_DFFRS_X1%VDD_c17 VSS N_VDD_M10_d 4.64502e-17
C_x_PM_DFFRS_X1%VDD_c18 VSS x_PM_DFFRS_X1%VDD_43 7.26192e-17
C_x_PM_DFFRS_X1%VDD_c19 VSS N_VDD_M7_s 6.75929e-17
C_x_PM_DFFRS_X1%VDD_c20 VSS x_PM_DFFRS_X1%VDD_37 4.8443e-17
C_x_PM_DFFRS_X1%VDD_c21 VSS N_VDD_M4_d 2.34754e-17
C_x_PM_DFFRS_X1%VDD_c22 VSS x_PM_DFFRS_X1%VDD_31 1.9059e-17
C_x_PM_DFFRS_X1%VDD_c23 VSS N_VDD_M3_d 1.94737e-17
C_x_PM_DFFRS_X1%VDD_c24 VSS x_PM_DFFRS_X1%VDD_25 2.97756e-17
C_x_PM_DFFRS_X1%VDD_c25 VSS N_VDD_M2_s 2.8785e-17
C_x_PM_DFFRS_X1%VDD_c26 VSS x_PM_DFFRS_X1%VDD_19 2.69771e-17
C_x_PM_DFFRS_X1%VDD_c27 VSS N_VDD_M0_d 3.10405e-17
C_x_PM_DFFRS_X1%VDD_c28 VSS x_PM_DFFRS_X1%VDD_11 2.7733e-17
R_x_PM_DFFRS_X1%VDD_r29 N_VDD_M21_d x_PM_DFFRS_X1%VDD_67 0.230714
R_x_PM_DFFRS_X1%VDD_r30 x_PM_DFFRS_X1%VDD_79 x_PM_DFFRS_X1%VDD_66 0.0731438
R_x_PM_DFFRS_X1%VDD_r31 x_PM_DFFRS_X1%VDD_67 x_PM_DFFRS_X1%VDD_65 0.264221
R_x_PM_DFFRS_X1%VDD_r32 x_PM_DFFRS_X1%VDD_66 x_PM_DFFRS_X1%VDD_65 0.692941
R_x_PM_DFFRS_X1%VDD_r33 x_PM_DFFRS_X1%VDD_79 x_PM_DFFRS_X1%VDD_61 0.145286
R_x_PM_DFFRS_X1%VDD_r34 N_VDD_M19_d x_PM_DFFRS_X1%VDD_61 1.20786
R_x_PM_DFFRS_X1%VDD_r35 x_PM_DFFRS_X1%VDD_78 x_PM_DFFRS_X1%VDD_60 0.132285
R_x_PM_DFFRS_X1%VDD_r36 x_PM_DFFRS_X1%VDD_79 x_PM_DFFRS_X1%VDD_59 0.0731438
R_x_PM_DFFRS_X1%VDD_r37 x_PM_DFFRS_X1%VDD_60 x_PM_DFFRS_X1%VDD_59 1.46412
R_x_PM_DFFRS_X1%VDD_r38 x_PM_DFFRS_X1%VDD_78 x_PM_DFFRS_X1%VDD_58 0.0680382
R_x_PM_DFFRS_X1%VDD_r39 x_PM_DFFRS_X1%VDD_58 N_VDD_M15_d 0.558398
R_x_PM_DFFRS_X1%VDD_r40 x_PM_DFFRS_X1%VDD_77 x_PM_DFFRS_X1%VDD_56 0.0731438
R_x_PM_DFFRS_X1%VDD_r41 x_PM_DFFRS_X1%VDD_78 x_PM_DFFRS_X1%VDD_55 0.132285
R_x_PM_DFFRS_X1%VDD_r42 x_PM_DFFRS_X1%VDD_56 x_PM_DFFRS_X1%VDD_55 1.38588
R_x_PM_DFFRS_X1%VDD_r43 x_PM_DFFRS_X1%VDD_77 x_PM_DFFRS_X1%VDD_51 0.145286
R_x_PM_DFFRS_X1%VDD_r44 N_VDD_M12_d x_PM_DFFRS_X1%VDD_51 0.909286
R_x_PM_DFFRS_X1%VDD_r45 x_PM_DFFRS_X1%VDD_76 x_PM_DFFRS_X1%VDD_50 0.0731438
R_x_PM_DFFRS_X1%VDD_r46 x_PM_DFFRS_X1%VDD_77 x_PM_DFFRS_X1%VDD_49 0.0731438
R_x_PM_DFFRS_X1%VDD_r47 x_PM_DFFRS_X1%VDD_50 x_PM_DFFRS_X1%VDD_49 1.05059
R_x_PM_DFFRS_X1%VDD_r48 x_PM_DFFRS_X1%VDD_76 x_PM_DFFRS_X1%VDD_45 0.145286
R_x_PM_DFFRS_X1%VDD_r49 N_VDD_M10_d x_PM_DFFRS_X1%VDD_45 0.909286
R_x_PM_DFFRS_X1%VDD_r50 x_PM_DFFRS_X1%VDD_75 x_PM_DFFRS_X1%VDD_44 0.0731438
R_x_PM_DFFRS_X1%VDD_r51 x_PM_DFFRS_X1%VDD_76 x_PM_DFFRS_X1%VDD_43 0.0731438
R_x_PM_DFFRS_X1%VDD_r52 x_PM_DFFRS_X1%VDD_44 x_PM_DFFRS_X1%VDD_43 1.57588
R_x_PM_DFFRS_X1%VDD_r53 x_PM_DFFRS_X1%VDD_75 x_PM_DFFRS_X1%VDD_39 0.145286
R_x_PM_DFFRS_X1%VDD_r54 N_VDD_M7_s x_PM_DFFRS_X1%VDD_39 1.615
R_x_PM_DFFRS_X1%VDD_r55 x_PM_DFFRS_X1%VDD_74 x_PM_DFFRS_X1%VDD_38 0.0731438
R_x_PM_DFFRS_X1%VDD_r56 x_PM_DFFRS_X1%VDD_75 x_PM_DFFRS_X1%VDD_37 0.0731438
R_x_PM_DFFRS_X1%VDD_r57 x_PM_DFFRS_X1%VDD_38 x_PM_DFFRS_X1%VDD_37 1.03941
R_x_PM_DFFRS_X1%VDD_r58 x_PM_DFFRS_X1%VDD_74 x_PM_DFFRS_X1%VDD_33 0.145286
R_x_PM_DFFRS_X1%VDD_r59 N_VDD_M4_d x_PM_DFFRS_X1%VDD_33 0.502143
R_x_PM_DFFRS_X1%VDD_r60 x_PM_DFFRS_X1%VDD_73 x_PM_DFFRS_X1%VDD_32 0.0731438
R_x_PM_DFFRS_X1%VDD_r61 x_PM_DFFRS_X1%VDD_74 x_PM_DFFRS_X1%VDD_31 0.0731438
R_x_PM_DFFRS_X1%VDD_r62 x_PM_DFFRS_X1%VDD_32 x_PM_DFFRS_X1%VDD_31 0.625882
R_x_PM_DFFRS_X1%VDD_r63 x_PM_DFFRS_X1%VDD_73 x_PM_DFFRS_X1%VDD_27 0.145286
R_x_PM_DFFRS_X1%VDD_r64 N_VDD_M3_d x_PM_DFFRS_X1%VDD_27 0.909286
R_x_PM_DFFRS_X1%VDD_r65 x_PM_DFFRS_X1%VDD_72 x_PM_DFFRS_X1%VDD_26 0.0731438
R_x_PM_DFFRS_X1%VDD_r66 x_PM_DFFRS_X1%VDD_73 x_PM_DFFRS_X1%VDD_25 0.0731438
R_x_PM_DFFRS_X1%VDD_r67 x_PM_DFFRS_X1%VDD_26 x_PM_DFFRS_X1%VDD_25 0.681765
R_x_PM_DFFRS_X1%VDD_r68 x_PM_DFFRS_X1%VDD_72 x_PM_DFFRS_X1%VDD_21 0.145286
R_x_PM_DFFRS_X1%VDD_r69 N_VDD_M2_s x_PM_DFFRS_X1%VDD_21 0.909286
R_x_PM_DFFRS_X1%VDD_r70 x_PM_DFFRS_X1%VDD_71 x_PM_DFFRS_X1%VDD_20 0.0731438
R_x_PM_DFFRS_X1%VDD_r71 x_PM_DFFRS_X1%VDD_72 x_PM_DFFRS_X1%VDD_19 0.0731438
R_x_PM_DFFRS_X1%VDD_r72 x_PM_DFFRS_X1%VDD_20 x_PM_DFFRS_X1%VDD_19 0.603529
R_x_PM_DFFRS_X1%VDD_r73 x_PM_DFFRS_X1%VDD_71 x_PM_DFFRS_X1%VDD_15 0.145286
R_x_PM_DFFRS_X1%VDD_r74 N_VDD_M0_d x_PM_DFFRS_X1%VDD_15 0.909286
R_x_PM_DFFRS_X1%VDD_r75 x_PM_DFFRS_X1%VDD_71 x_PM_DFFRS_X1%VDD_11 0.0731438
R_x_PM_DFFRS_X1%VDD_r76 VDD x_PM_DFFRS_X1%VDD_11 0.262647
C_x_PM_DFFRS_X1%Q_c0 VSS N_Q_M22_s 1.17026e-16
R_x_PM_DFFRS_X1%Q_r1 N_Q_M0_s Q 2.17313
R_x_PM_DFFRS_X1%Q_r2 Q N_Q_M22_s 1.95938
C_x_PM_DFFRS_X1%QN_c0 VSS N_QN_M1_d 3.4063e-17
C_x_PM_DFFRS_X1%QN_c1 VSS x_PM_DFFRS_X1%QN_11 1.55551e-17
C_x_PM_DFFRS_X1%QN_c2 VSS x_PM_DFFRS_X1%QN_10 9.04779e-17
C_x_PM_DFFRS_X1%QN_c3 VSS N_QN_M23_d 7.0871e-17
R_x_PM_DFFRS_X1%QN_r4 x_PM_DFFRS_X1%QN_10 N_QN_M1_d 0.297071
R_x_PM_DFFRS_X1%QN_r5 x_PM_DFFRS_X1%QN_10 x_PM_DFFRS_X1%QN_11 3.25714
R_x_PM_DFFRS_X1%QN_r6 QN N_QN_M23_d 0.437826
R_x_PM_DFFRS_X1%QN_r7 x_PM_DFFRS_X1%QN_11 x_PM_DFFRS_X1%QN_3 0.247769
R_x_PM_DFFRS_X1%QN_r8 QN x_PM_DFFRS_X1%QN_3 0.0413043
C_x_PM_DFFRS_X1%5_c0 VSS x_PM_DFFRS_X1%5_27 2.69759e-17
C_x_PM_DFFRS_X1%5_c1 VSS x_PM_DFFRS_X1%5_25 4.59206e-17
C_x_PM_DFFRS_X1%5_c2 VSS N_5_M2_d 3.49822e-17
C_x_PM_DFFRS_X1%5_c3 VSS x_PM_DFFRS_X1%5_20 1.35711e-17
C_x_PM_DFFRS_X1%5_c4 VSS x_PM_DFFRS_X1%5_19 3.77791e-17
C_x_PM_DFFRS_X1%5_c5 VSS x_PM_DFFRS_X1%5_18 2.15111e-17
C_x_PM_DFFRS_X1%5_c6 VSS N_5_M24_s 5.48815e-17
C_x_PM_DFFRS_X1%5_c7 VSS x_PM_DFFRS_X1%5_10 4.36208e-18
C_x_PM_DFFRS_X1%5_c8 VSS N_5_M1_g 6.61218e-17
C_x_PM_DFFRS_X1%5_c9 VSS N_5_M23_g 6.04332e-17
R_x_PM_DFFRS_X1%5_r10 x_PM_DFFRS_X1%5_27 x_PM_DFFRS_X1%5_25 25.0012
R_x_PM_DFFRS_X1%5_r11 x_PM_DFFRS_X1%5_29 x_PM_DFFRS_X1%5_25 0.280813
R_x_PM_DFFRS_X1%5_r12 N_5_M2_d x_PM_DFFRS_X1%5_21 0.990714
R_x_PM_DFFRS_X1%5_r13 x_PM_DFFRS_X1%5_21 x_PM_DFFRS_X1%5_19 0.212317
R_x_PM_DFFRS_X1%5_r14 x_PM_DFFRS_X1%5_20 x_PM_DFFRS_X1%5_19 0.624286
R_x_PM_DFFRS_X1%5_r15 x_PM_DFFRS_X1%5_20 x_PM_DFFRS_X1%5_18 0.212317
R_x_PM_DFFRS_X1%5_r16 x_PM_DFFRS_X1%5_18 x_PM_DFFRS_X1%5_29 0.624286
R_x_PM_DFFRS_X1%5_r17 x_PM_DFFRS_X1%5_13 x_PM_DFFRS_X1%5_25 0.280813
R_x_PM_DFFRS_X1%5_r18 N_5_M24_s x_PM_DFFRS_X1%5_13 1.235
R_x_PM_DFFRS_X1%5_r19 x_PM_DFFRS_X1%5_27 x_PM_DFFRS_X1%5_9 17.94
R_x_PM_DFFRS_X1%5_r20 x_PM_DFFRS_X1%5_10 x_PM_DFFRS_X1%5_9 0.043368
R_x_PM_DFFRS_X1%5_r21 x_PM_DFFRS_X1%5_10 x_PM_DFFRS_X1%5_5 4.56151
R_x_PM_DFFRS_X1%5_r22 N_5_M1_g x_PM_DFFRS_X1%5_5 66.69
R_x_PM_DFFRS_X1%5_r23 x_PM_DFFRS_X1%5_10 x_PM_DFFRS_X1%5_VSS 4.56151
R_x_PM_DFFRS_X1%5_r24 N_5_M23_g x_PM_DFFRS_X1%5_VSS 63.18
C_x_PM_DFFRS_X1%SN_c0 VSS x_PM_DFFRS_X1%SN_48 1.61322e-17
C_x_PM_DFFRS_X1%SN_c1 VSS x_PM_DFFRS_X1%SN_33 4.81163e-17
C_x_PM_DFFRS_X1%SN_c2 VSS x_PM_DFFRS_X1%SN_29 1.22238e-17
C_x_PM_DFFRS_X1%SN_c3 VSS x_PM_DFFRS_X1%SN_27 4.78733e-17
C_x_PM_DFFRS_X1%SN_c4 VSS x_PM_DFFRS_X1%SN_25 7.29302e-17
C_x_PM_DFFRS_X1%SN_c5 VSS N_SN_M41_g 1.4714e-16
C_x_PM_DFFRS_X1%SN_c6 VSS N_SN_M27_g 4.64677e-17
C_x_PM_DFFRS_X1%SN_c7 VSS N_SN_M5_g 5.72756e-17
C_x_PM_DFFRS_X1%SN_c8 VSS x_PM_DFFRS_X1%SN_10 6.68762e-18
C_x_PM_DFFRS_X1%SN_c9 VSS x_PM_DFFRS_X1%SN_9 5.37847e-16
C_x_PM_DFFRS_X1%SN_c10 VSS N_SN_M2_g 6.06649e-17
C_x_PM_DFFRS_X1%SN_c11 VSS N_SN_M24_g 6.18202e-17
R_x_PM_DFFRS_X1%SN_r12 x_PM_DFFRS_X1%SN_48 x_PM_DFFRS_X1%SN_37 5.46
R_x_PM_DFFRS_X1%SN_r13 x_PM_DFFRS_X1%SN_37 x_PM_DFFRS_X1%SN_45 1.3
R_x_PM_DFFRS_X1%SN_r14 x_PM_DFFRS_X1%SN_37 x_PM_DFFRS_X1%SN_35 25.0012
R_x_PM_DFFRS_X1%SN_r15 SN x_PM_DFFRS_X1%SN_35 0.0105556
R_x_PM_DFFRS_X1%SN_r16 x_PM_DFFRS_X1%SN_35 x_PM_DFFRS_X1%SN_33 0.137222
R_x_PM_DFFRS_X1%SN_r17 x_PM_DFFRS_X1%SN_29 x_PM_DFFRS_X1%SN_41 3.9
R_x_PM_DFFRS_X1%SN_r18 x_PM_DFFRS_X1%SN_29 x_PM_DFFRS_X1%SN_27 25.0012
R_x_PM_DFFRS_X1%SN_r19 x_PM_DFFRS_X1%SN_31 x_PM_DFFRS_X1%SN_27 0.176429
R_x_PM_DFFRS_X1%SN_r20 x_PM_DFFRS_X1%SN_31 x_PM_DFFRS_X1%SN_26 0.095
R_x_PM_DFFRS_X1%SN_r21 x_PM_DFFRS_X1%SN_33 x_PM_DFFRS_X1%SN_25 0.095
R_x_PM_DFFRS_X1%SN_r22 x_PM_DFFRS_X1%SN_26 x_PM_DFFRS_X1%SN_25 3.31143
R_x_PM_DFFRS_X1%SN_r23 N_SN_M21_g N_SN_M41_g 142.74
R_x_PM_DFFRS_X1%SN_r24 N_SN_M41_g x_PM_DFFRS_X1%SN_19 26.52
R_x_PM_DFFRS_X1%SN_r25 x_PM_DFFRS_X1%SN_48 x_PM_DFFRS_X1%SN_15 1.95
R_x_PM_DFFRS_X1%SN_r26 N_SN_M27_g x_PM_DFFRS_X1%SN_15 53.04
R_x_PM_DFFRS_X1%SN_r27 x_PM_DFFRS_X1%SN_45 x_PM_DFFRS_X1%SN_11 1.95
R_x_PM_DFFRS_X1%SN_r28 N_SN_M5_g x_PM_DFFRS_X1%SN_11 49.92
R_x_PM_DFFRS_X1%SN_r29 x_PM_DFFRS_X1%SN_19 x_PM_DFFRS_X1%SN_9 4.35808
R_x_PM_DFFRS_X1%SN_r30 x_PM_DFFRS_X1%SN_10 x_PM_DFFRS_X1%SN_9 655.2
R_x_PM_DFFRS_X1%SN_r31 x_PM_DFFRS_X1%SN_41 x_PM_DFFRS_X1%SN_5 1.95
R_x_PM_DFFRS_X1%SN_r32 N_SN_M2_g x_PM_DFFRS_X1%SN_5 58.89
R_x_PM_DFFRS_X1%SN_r33 x_PM_DFFRS_X1%SN_41 x_PM_DFFRS_X1%SN_2 1.95
R_x_PM_DFFRS_X1%SN_r34 N_SN_M24_g x_PM_DFFRS_X1%SN_2 52.26
R_x_PM_DFFRS_X1%SN_r35 x_PM_DFFRS_X1%SN_10 x_PM_DFFRS_X1%SN_VSS 4.35808
R_x_PM_DFFRS_X1%SN_r36 N_SN_M24_g x_PM_DFFRS_X1%SN_VSS 37.44
C_x_PM_DFFRS_X1%7_c0 VSS x_PM_DFFRS_X1%7_57 1.02559e-17
C_x_PM_DFFRS_X1%7_c1 VSS x_PM_DFFRS_X1%7_56 1.56786e-17
C_x_PM_DFFRS_X1%7_c2 VSS x_PM_DFFRS_X1%7_53 7.96514e-17
C_x_PM_DFFRS_X1%7_c3 VSS x_PM_DFFRS_X1%7_51 2.67991e-17
C_x_PM_DFFRS_X1%7_c4 VSS x_PM_DFFRS_X1%7_50 1.18851e-16
C_x_PM_DFFRS_X1%7_c5 VSS x_PM_DFFRS_X1%7_48 4.71654e-17
C_x_PM_DFFRS_X1%7_c6 VSS x_PM_DFFRS_X1%7_46 9.54538e-18
C_x_PM_DFFRS_X1%7_c7 VSS x_PM_DFFRS_X1%7_45 4.57051e-17
C_x_PM_DFFRS_X1%7_c8 VSS N_7_M26_s 1.04993e-17
C_x_PM_DFFRS_X1%7_c9 VSS x_PM_DFFRS_X1%7_37 9.77027e-17
C_x_PM_DFFRS_X1%7_c10 VSS x_PM_DFFRS_X1%7_34 4.23878e-18
C_x_PM_DFFRS_X1%7_c11 VSS x_PM_DFFRS_X1%7_33 3.47289e-18
C_x_PM_DFFRS_X1%7_c12 VSS N_7_M38_g 1.28203e-16
C_x_PM_DFFRS_X1%7_c13 VSS x_PM_DFFRS_X1%7_25 6.36667e-17
C_x_PM_DFFRS_X1%7_c14 VSS N_7_M14_g 3.95577e-17
C_x_PM_DFFRS_X1%7_c15 VSS x_PM_DFFRS_X1%7_19 3.44439e-17
C_x_PM_DFFRS_X1%7_c16 VSS N_7_M13_g 4.26403e-17
C_x_PM_DFFRS_X1%7_c17 VSS x_PM_DFFRS_X1%7_14 6.01595e-18
C_x_PM_DFFRS_X1%7_c18 VSS x_PM_DFFRS_X1%7_13 7.88931e-17
C_x_PM_DFFRS_X1%7_c19 VSS N_7_M32_g 1.24766e-16
C_x_PM_DFFRS_X1%7_c20 VSS x_PM_DFFRS_X1%7_5 6.68593e-17
C_x_PM_DFFRS_X1%7_c21 VSS N_7_M29_g 2.81476e-17
R_x_PM_DFFRS_X1%7_r22 x_PM_DFFRS_X1%7_60 x_PM_DFFRS_X1%7_59 4.7687
R_x_PM_DFFRS_X1%7_r23 x_PM_DFFRS_X1%7_59 x_PM_DFFRS_X1%7_57 1.82
R_x_PM_DFFRS_X1%7_r24 x_PM_DFFRS_X1%7_59 x_PM_DFFRS_X1%7_53 25.0012
R_x_PM_DFFRS_X1%7_r25 x_PM_DFFRS_X1%7_53 x_PM_DFFRS_X1%7_51 1.96786
R_x_PM_DFFRS_X1%7_r26 x_PM_DFFRS_X1%7_56 x_PM_DFFRS_X1%7_49 0.160909
R_x_PM_DFFRS_X1%7_r27 x_PM_DFFRS_X1%7_50 x_PM_DFFRS_X1%7_49 2.33429
R_x_PM_DFFRS_X1%7_r28 x_PM_DFFRS_X1%7_56 x_PM_DFFRS_X1%7_48 0.160909
R_x_PM_DFFRS_X1%7_r29 x_PM_DFFRS_X1%7_51 x_PM_DFFRS_X1%7_47 0.212317
R_x_PM_DFFRS_X1%7_r30 x_PM_DFFRS_X1%7_48 x_PM_DFFRS_X1%7_47 1.43857
R_x_PM_DFFRS_X1%7_r31 x_PM_DFFRS_X1%7_56 x_PM_DFFRS_X1%7_45 0.0418175
R_x_PM_DFFRS_X1%7_r32 x_PM_DFFRS_X1%7_46 x_PM_DFFRS_X1%7_45 1.57429
R_x_PM_DFFRS_X1%7_r33 x_PM_DFFRS_X1%7_46 x_PM_DFFRS_X1%7_41 0.212317
R_x_PM_DFFRS_X1%7_r34 N_7_M26_s x_PM_DFFRS_X1%7_41 0.149286
R_x_PM_DFFRS_X1%7_r35 x_PM_DFFRS_X1%7_50 x_PM_DFFRS_X1%7_37 0.212317
R_x_PM_DFFRS_X1%7_r36 N_7_M4_s x_PM_DFFRS_X1%7_37 2.13071
R_x_PM_DFFRS_X1%7_r37 N_7_M17_g N_7_M38_g 105.69
R_x_PM_DFFRS_X1%7_r38 N_7_M17_g x_PM_DFFRS_X1%7_27 51.09
R_x_PM_DFFRS_X1%7_r39 x_PM_DFFRS_X1%7_34 x_PM_DFFRS_X1%7_26 3.30287
R_x_PM_DFFRS_X1%7_r40 x_PM_DFFRS_X1%7_27 x_PM_DFFRS_X1%7_25 4.35808
R_x_PM_DFFRS_X1%7_r41 x_PM_DFFRS_X1%7_26 x_PM_DFFRS_X1%7_25 81.12
R_x_PM_DFFRS_X1%7_r42 x_PM_DFFRS_X1%7_34 x_PM_DFFRS_X1%7_21 0.858359
R_x_PM_DFFRS_X1%7_r43 N_7_M14_g x_PM_DFFRS_X1%7_21 35.1
R_x_PM_DFFRS_X1%7_r44 x_PM_DFFRS_X1%7_33 x_PM_DFFRS_X1%7_20 3.30287
R_x_PM_DFFRS_X1%7_r45 x_PM_DFFRS_X1%7_34 x_PM_DFFRS_X1%7_19 3.30287
R_x_PM_DFFRS_X1%7_r46 x_PM_DFFRS_X1%7_20 x_PM_DFFRS_X1%7_19 46.8
R_x_PM_DFFRS_X1%7_r47 x_PM_DFFRS_X1%7_33 x_PM_DFFRS_X1%7_15 0.858359
R_x_PM_DFFRS_X1%7_r48 N_7_M13_g x_PM_DFFRS_X1%7_15 33.54
R_x_PM_DFFRS_X1%7_r49 x_PM_DFFRS_X1%7_33 x_PM_DFFRS_X1%7_13 3.30287
R_x_PM_DFFRS_X1%7_r50 x_PM_DFFRS_X1%7_14 x_PM_DFFRS_X1%7_13 107.64
R_x_PM_DFFRS_X1%7_r51 N_7_M10_g N_7_M32_g 94.38
R_x_PM_DFFRS_X1%7_r52 x_PM_DFFRS_X1%7_14 x_PM_DFFRS_X1%7_8 4.35808
R_x_PM_DFFRS_X1%7_r53 N_7_M10_g x_PM_DFFRS_X1%7_8 54.6
R_x_PM_DFFRS_X1%7_r54 N_7_M32_g x_PM_DFFRS_X1%7_7 21.84
R_x_PM_DFFRS_X1%7_r55 x_PM_DFFRS_X1%7_57 x_PM_DFFRS_X1%7_6 1.95
R_x_PM_DFFRS_X1%7_r56 x_PM_DFFRS_X1%7_7 x_PM_DFFRS_X1%7_5 4.35808
R_x_PM_DFFRS_X1%7_r57 x_PM_DFFRS_X1%7_6 x_PM_DFFRS_X1%7_5 77.22
R_x_PM_DFFRS_X1%7_r58 N_7_M29_g x_PM_DFFRS_X1%7_60 22.62
C_x_PM_DFFRS_X1%CK_c0 VSS x_PM_DFFRS_X1%CK_19 1.5457e-17
C_x_PM_DFFRS_X1%CK_c1 VSS x_PM_DFFRS_X1%CK_12 4.59318e-17
C_x_PM_DFFRS_X1%CK_c2 VSS N_CK_M26_g 6.76501e-17
C_x_PM_DFFRS_X1%CK_c3 VSS N_CK_M4_g 4.26767e-17
R_x_PM_DFFRS_X1%CK_r4 x_PM_DFFRS_X1%CK_19 x_PM_DFFRS_X1%CK_14 5.46
R_x_PM_DFFRS_X1%CK_r5 x_PM_DFFRS_X1%CK_14 x_PM_DFFRS_X1%CK_16 1.3
R_x_PM_DFFRS_X1%CK_r6 x_PM_DFFRS_X1%CK_14 x_PM_DFFRS_X1%CK_12 25.0012
R_x_PM_DFFRS_X1%CK_r7 x_PM_DFFRS_X1%CK_12 CK 0.114
R_x_PM_DFFRS_X1%CK_r8 x_PM_DFFRS_X1%CK_19 x_PM_DFFRS_X1%CK_5 1.95
R_x_PM_DFFRS_X1%CK_r9 N_CK_M26_g x_PM_DFFRS_X1%CK_5 67.08
R_x_PM_DFFRS_X1%CK_r10 x_PM_DFFRS_X1%CK_16 x_PM_DFFRS_X1%CK_VSS 1.95
R_x_PM_DFFRS_X1%CK_r11 N_CK_M4_g x_PM_DFFRS_X1%CK_VSS 28.86
C_x_PM_DFFRS_X1%9_c0 VSS x_PM_DFFRS_X1%9_34 1.00272e-17
C_x_PM_DFFRS_X1%9_c1 VSS x_PM_DFFRS_X1%9_31 1.69441e-16
C_x_PM_DFFRS_X1%9_c2 VSS x_PM_DFFRS_X1%9_28 1.95652e-17
C_x_PM_DFFRS_X1%9_c3 VSS x_PM_DFFRS_X1%9_27 3.25237e-17
C_x_PM_DFFRS_X1%9_c4 VSS x_PM_DFFRS_X1%9_24 7.80883e-17
C_x_PM_DFFRS_X1%9_c5 VSS N_9_M29_d 5.12236e-17
C_x_PM_DFFRS_X1%9_c6 VSS x_PM_DFFRS_X1%9_20 2.59803e-17
C_x_PM_DFFRS_X1%9_c7 VSS N_9_M6_d 9.59873e-17
C_x_PM_DFFRS_X1%9_c8 VSS x_PM_DFFRS_X1%9_15 8.91587e-17
C_x_PM_DFFRS_X1%9_c9 VSS N_9_M33_g 7.67819e-17
C_x_PM_DFFRS_X1%9_c10 VSS x_PM_DFFRS_X1%9_5 2.16379e-17
C_x_PM_DFFRS_X1%9_c11 VSS N_9_M11_g 4.19395e-17
R_x_PM_DFFRS_X1%9_r12 x_PM_DFFRS_X1%9_37 x_PM_DFFRS_X1%9_36 4.7687
R_x_PM_DFFRS_X1%9_r13 x_PM_DFFRS_X1%9_36 x_PM_DFFRS_X1%9_34 1.3
R_x_PM_DFFRS_X1%9_r14 x_PM_DFFRS_X1%9_36 x_PM_DFFRS_X1%9_31 25.0012
R_x_PM_DFFRS_X1%9_r15 x_PM_DFFRS_X1%9_31 x_PM_DFFRS_X1%9_29 2.72786
R_x_PM_DFFRS_X1%9_r16 x_PM_DFFRS_X1%9_29 x_PM_DFFRS_X1%9_27 0.095
R_x_PM_DFFRS_X1%9_r17 x_PM_DFFRS_X1%9_27 N_9_M8_d 0.570339
R_x_PM_DFFRS_X1%9_r18 x_PM_DFFRS_X1%9_28 x_PM_DFFRS_X1%9_25 0.0418175
R_x_PM_DFFRS_X1%9_r19 x_PM_DFFRS_X1%9_29 x_PM_DFFRS_X1%9_24 0.19
R_x_PM_DFFRS_X1%9_r20 x_PM_DFFRS_X1%9_25 x_PM_DFFRS_X1%9_24 2.47
R_x_PM_DFFRS_X1%9_r21 N_9_M29_d x_PM_DFFRS_X1%9_20 1.64214
R_x_PM_DFFRS_X1%9_r22 x_PM_DFFRS_X1%9_28 x_PM_DFFRS_X1%9_16 0.160909
R_x_PM_DFFRS_X1%9_r23 N_9_M6_d x_PM_DFFRS_X1%9_16 1.64214
R_x_PM_DFFRS_X1%9_r24 x_PM_DFFRS_X1%9_28 x_PM_DFFRS_X1%9_15 0.160909
R_x_PM_DFFRS_X1%9_r25 x_PM_DFFRS_X1%9_20 x_PM_DFFRS_X1%9_14 0.212317
R_x_PM_DFFRS_X1%9_r26 x_PM_DFFRS_X1%9_15 x_PM_DFFRS_X1%9_14 1.95429
R_x_PM_DFFRS_X1%9_r27 N_9_M33_g x_PM_DFFRS_X1%9_7 65.52
R_x_PM_DFFRS_X1%9_r28 x_PM_DFFRS_X1%9_34 x_PM_DFFRS_X1%9_6 1.95
R_x_PM_DFFRS_X1%9_r29 x_PM_DFFRS_X1%9_7 x_PM_DFFRS_X1%9_5 4.35808
R_x_PM_DFFRS_X1%9_r30 x_PM_DFFRS_X1%9_6 x_PM_DFFRS_X1%9_5 19.5
R_x_PM_DFFRS_X1%9_r31 N_9_M11_g x_PM_DFFRS_X1%9_37 28.86
C_x_PM_DFFRS_X1%10_c0 VSS x_PM_DFFRS_X1%10_43 2.48777e-17
C_x_PM_DFFRS_X1%10_c1 VSS N_10_M11_d 9.48088e-17
C_x_PM_DFFRS_X1%10_c2 VSS x_PM_DFFRS_X1%10_29 2.43384e-16
C_x_PM_DFFRS_X1%10_c3 VSS N_10_M33_s 4.61694e-17
C_x_PM_DFFRS_X1%10_c4 VSS N_10_M7_g 4.64293e-17
C_x_PM_DFFRS_X1%10_c5 VSS x_PM_DFFRS_X1%10_23 5.49295e-18
C_x_PM_DFFRS_X1%10_c6 VSS x_PM_DFFRS_X1%10_22 9.47027e-18
C_x_PM_DFFRS_X1%10_c7 VSS x_PM_DFFRS_X1%10_21 1.59869e-17
C_x_PM_DFFRS_X1%10_c8 VSS N_10_M28_g 4.90942e-17
C_x_PM_DFFRS_X1%10_c9 VSS x_PM_DFFRS_X1%10_16 6.31397e-18
C_x_PM_DFFRS_X1%10_c10 VSS x_PM_DFFRS_X1%10_15 1.09157e-16
C_x_PM_DFFRS_X1%10_c11 VSS N_10_M25_g 1.1624e-16
C_x_PM_DFFRS_X1%10_c12 VSS x_PM_DFFRS_X1%10_8 6.39228e-18
C_x_PM_DFFRS_X1%10_c13 VSS x_PM_DFFRS_X1%10_7 8.2525e-17
C_x_PM_DFFRS_X1%10_c14 VSS N_10_M22_g 1.37499e-16
R_x_PM_DFFRS_X1%10_r15 x_PM_DFFRS_X1%10_43 x_PM_DFFRS_X1%10_42 0.407143
R_x_PM_DFFRS_X1%10_r16 x_PM_DFFRS_X1%10_43 x_PM_DFFRS_X1%10_38 0.095
R_x_PM_DFFRS_X1%10_r17 N_10_M11_d x_PM_DFFRS_X1%10_38 1.28929
R_x_PM_DFFRS_X1%10_r18 x_PM_DFFRS_X1%10_42 x_PM_DFFRS_X1%10_34 0.095
R_x_PM_DFFRS_X1%10_r19 x_PM_DFFRS_X1%10_32 x_PM_DFFRS_X1%10_30 25.0012
R_x_PM_DFFRS_X1%10_r20 x_PM_DFFRS_X1%10_42 x_PM_DFFRS_X1%10_29 0.19
R_x_PM_DFFRS_X1%10_r21 x_PM_DFFRS_X1%10_30 x_PM_DFFRS_X1%10_29 4.655
R_x_PM_DFFRS_X1%10_r22 N_10_M33_s x_PM_DFFRS_X1%10_34 0.963571
R_x_PM_DFFRS_X1%10_r23 x_PM_DFFRS_X1%10_32 x_PM_DFFRS_X1%10_23 4.03807
R_x_PM_DFFRS_X1%10_r24 N_10_M7_g x_PM_DFFRS_X1%10_23 46.02
R_x_PM_DFFRS_X1%10_r25 x_PM_DFFRS_X1%10_32 x_PM_DFFRS_X1%10_21 0.550646
R_x_PM_DFFRS_X1%10_r26 x_PM_DFFRS_X1%10_22 x_PM_DFFRS_X1%10_21 14.56
R_x_PM_DFFRS_X1%10_r27 x_PM_DFFRS_X1%10_22 x_PM_DFFRS_X1%10_18 4.58872
R_x_PM_DFFRS_X1%10_r28 N_10_M28_g x_PM_DFFRS_X1%10_18 39
R_x_PM_DFFRS_X1%10_r29 N_10_M28_g x_PM_DFFRS_X1%10_17 27.3
R_x_PM_DFFRS_X1%10_r30 x_PM_DFFRS_X1%10_17 x_PM_DFFRS_X1%10_15 4.35808
R_x_PM_DFFRS_X1%10_r31 x_PM_DFFRS_X1%10_16 x_PM_DFFRS_X1%10_15 129.48
R_x_PM_DFFRS_X1%10_r32 N_10_M3_g N_10_M25_g 122.85
R_x_PM_DFFRS_X1%10_r33 N_10_M3_g x_PM_DFFRS_X1%10_10 30.03
R_x_PM_DFFRS_X1%10_r34 x_PM_DFFRS_X1%10_16 x_PM_DFFRS_X1%10_9 4.35808
R_x_PM_DFFRS_X1%10_r35 N_10_M25_g x_PM_DFFRS_X1%10_9 17.94
R_x_PM_DFFRS_X1%10_r36 x_PM_DFFRS_X1%10_10 x_PM_DFFRS_X1%10_7 4.35808
R_x_PM_DFFRS_X1%10_r37 x_PM_DFFRS_X1%10_8 x_PM_DFFRS_X1%10_7 104.52
R_x_PM_DFFRS_X1%10_r38 N_10_M0_g N_10_M22_g 141.57
R_x_PM_DFFRS_X1%10_r39 x_PM_DFFRS_X1%10_8 x_PM_DFFRS_X1%10_VSS 4.35808
R_x_PM_DFFRS_X1%10_r40 N_10_M0_g x_PM_DFFRS_X1%10_VSS 30.03
C_x_PM_DFFRS_X1%11_c0 VSS x_PM_DFFRS_X1%11_72 1.04935e-17
C_x_PM_DFFRS_X1%11_c1 VSS x_PM_DFFRS_X1%11_67 1.24563e-17
C_x_PM_DFFRS_X1%11_c2 VSS x_PM_DFFRS_X1%11_65 2.84765e-17
C_x_PM_DFFRS_X1%11_c3 VSS x_PM_DFFRS_X1%11_62 1.79599e-17
C_x_PM_DFFRS_X1%11_c4 VSS x_PM_DFFRS_X1%11_60 3.71605e-17
C_x_PM_DFFRS_X1%11_c5 VSS x_PM_DFFRS_X1%11_56 2.65008e-17
C_x_PM_DFFRS_X1%11_c6 VSS x_PM_DFFRS_X1%11_54 2.5362e-17
C_x_PM_DFFRS_X1%11_c7 VSS x_PM_DFFRS_X1%11_53 8.54926e-17
C_x_PM_DFFRS_X1%11_c8 VSS x_PM_DFFRS_X1%11_52 1.85081e-17
C_x_PM_DFFRS_X1%11_c9 VSS x_PM_DFFRS_X1%11_48 1.25475e-16
C_x_PM_DFFRS_X1%11_c10 VSS x_PM_DFFRS_X1%11_45 2.40979e-17
C_x_PM_DFFRS_X1%11_c11 VSS x_PM_DFFRS_X1%11_44 4.74637e-17
C_x_PM_DFFRS_X1%11_c12 VSS x_PM_DFFRS_X1%11_43 3.56533e-17
C_x_PM_DFFRS_X1%11_c13 VSS x_PM_DFFRS_X1%11_41 3.07111e-17
C_x_PM_DFFRS_X1%11_c14 VSS x_PM_DFFRS_X1%11_40 1.36686e-16
C_x_PM_DFFRS_X1%11_c15 VSS N_11_M13_d 1.30527e-16
C_x_PM_DFFRS_X1%11_c16 VSS x_PM_DFFRS_X1%11_35 2.80933e-17
C_x_PM_DFFRS_X1%11_c17 VSS x_PM_DFFRS_X1%11_32 1.01038e-16
C_x_PM_DFFRS_X1%11_c18 VSS x_PM_DFFRS_X1%11_31 2.27643e-17
C_x_PM_DFFRS_X1%11_c19 VSS x_PM_DFFRS_X1%11_30 1.84463e-17
C_x_PM_DFFRS_X1%11_c20 VSS x_PM_DFFRS_X1%11_28 7.49745e-18
C_x_PM_DFFRS_X1%11_c21 VSS x_PM_DFFRS_X1%11_25 1.42499e-16
C_x_PM_DFFRS_X1%11_c22 VSS N_11_M19_g 4.6117e-17
C_x_PM_DFFRS_X1%11_c23 VSS N_11_M37_g 2.60146e-17
C_x_PM_DFFRS_X1%11_c24 VSS N_11_M8_g 7.54901e-17
C_x_PM_DFFRS_X1%11_c25 VSS N_11_M30_g 2.27196e-17
C_x_PM_DFFRS_X1%11_c26 VSS x_PM_DFFRS_X1%11_6 6.61724e-18
C_x_PM_DFFRS_X1%11_c27 VSS x_PM_DFFRS_X1%11_5 6.01292e-17
C_x_PM_DFFRS_X1%11_c28 VSS N_11_M6_g 4.54229e-17
R_x_PM_DFFRS_X1%11_r29 x_PM_DFFRS_X1%11_77 x_PM_DFFRS_X1%11_67 4.7687
R_x_PM_DFFRS_X1%11_r30 x_PM_DFFRS_X1%11_67 x_PM_DFFRS_X1%11_65 25.0012
R_x_PM_DFFRS_X1%11_r31 x_PM_DFFRS_X1%11_65 x_PM_DFFRS_X1%11_63 0.176429
R_x_PM_DFFRS_X1%11_r32 x_PM_DFFRS_X1%11_60 x_PM_DFFRS_X1%11_58 0.515714
R_x_PM_DFFRS_X1%11_r33 x_PM_DFFRS_X1%11_63 x_PM_DFFRS_X1%11_55 0.095
R_x_PM_DFFRS_X1%11_r34 x_PM_DFFRS_X1%11_56 x_PM_DFFRS_X1%11_55 1.19429
R_x_PM_DFFRS_X1%11_r35 x_PM_DFFRS_X1%11_56 x_PM_DFFRS_X1%11_53 0.212317
R_x_PM_DFFRS_X1%11_r36 x_PM_DFFRS_X1%11_54 x_PM_DFFRS_X1%11_53 2.06286
R_x_PM_DFFRS_X1%11_r37 x_PM_DFFRS_X1%11_54 x_PM_DFFRS_X1%11_52 0.212317
R_x_PM_DFFRS_X1%11_r38 x_PM_DFFRS_X1%11_62 x_PM_DFFRS_X1%11_51 0.115915
R_x_PM_DFFRS_X1%11_r39 x_PM_DFFRS_X1%11_52 x_PM_DFFRS_X1%11_51 0.76
R_x_PM_DFFRS_X1%11_r40 x_PM_DFFRS_X1%11_72 x_PM_DFFRS_X1%11_48 25.0012
R_x_PM_DFFRS_X1%11_r41 x_PM_DFFRS_X1%11_62 x_PM_DFFRS_X1%11_46 0.115915
R_x_PM_DFFRS_X1%11_r42 x_PM_DFFRS_X1%11_48 x_PM_DFFRS_X1%11_46 1.10481
R_x_PM_DFFRS_X1%11_r43 x_PM_DFFRS_X1%11_62 x_PM_DFFRS_X1%11_44 0.0855182
R_x_PM_DFFRS_X1%11_r44 x_PM_DFFRS_X1%11_45 x_PM_DFFRS_X1%11_44 0.895714
R_x_PM_DFFRS_X1%11_r45 x_PM_DFFRS_X1%11_45 x_PM_DFFRS_X1%11_42 0.212317
R_x_PM_DFFRS_X1%11_r46 x_PM_DFFRS_X1%11_43 x_PM_DFFRS_X1%11_42 1.08571
R_x_PM_DFFRS_X1%11_r47 x_PM_DFFRS_X1%11_43 x_PM_DFFRS_X1%11_40 0.212317
R_x_PM_DFFRS_X1%11_r48 x_PM_DFFRS_X1%11_41 x_PM_DFFRS_X1%11_40 1.65571
R_x_PM_DFFRS_X1%11_r49 x_PM_DFFRS_X1%11_41 x_PM_DFFRS_X1%11_37 0.212317
R_x_PM_DFFRS_X1%11_r50 N_11_M13_d x_PM_DFFRS_X1%11_37 0.746429
R_x_PM_DFFRS_X1%11_r51 x_PM_DFFRS_X1%11_60 x_PM_DFFRS_X1%11_36 0.095
R_x_PM_DFFRS_X1%11_r52 N_11_M13_d x_PM_DFFRS_X1%11_36 2.70071
R_x_PM_DFFRS_X1%11_r53 x_PM_DFFRS_X1%11_58 x_PM_DFFRS_X1%11_35 0.095
R_x_PM_DFFRS_X1%11_r54 x_PM_DFFRS_X1%11_35 x_PM_DFFRS_X1%11_34 0.76
R_x_PM_DFFRS_X1%11_r55 N_11_M32_d x_PM_DFFRS_X1%11_33 0.198162
R_x_PM_DFFRS_X1%11_r56 x_PM_DFFRS_X1%11_34 x_PM_DFFRS_X1%11_32 0.212317
R_x_PM_DFFRS_X1%11_r57 x_PM_DFFRS_X1%11_33 x_PM_DFFRS_X1%11_32 3.09429
R_x_PM_DFFRS_X1%11_r58 N_11_M32_d x_PM_DFFRS_X1%11_30 0.0141545
R_x_PM_DFFRS_X1%11_r59 x_PM_DFFRS_X1%11_31 x_PM_DFFRS_X1%11_30 0.95
R_x_PM_DFFRS_X1%11_r60 x_PM_DFFRS_X1%11_71 x_PM_DFFRS_X1%11_28 4.7687
R_x_PM_DFFRS_X1%11_r61 x_PM_DFFRS_X1%11_70 x_PM_DFFRS_X1%11_28 4.7687
R_x_PM_DFFRS_X1%11_r62 x_PM_DFFRS_X1%11_28 x_PM_DFFRS_X1%11_26 25.0012
R_x_PM_DFFRS_X1%11_r63 x_PM_DFFRS_X1%11_31 x_PM_DFFRS_X1%11_25 0.212317
R_x_PM_DFFRS_X1%11_r64 x_PM_DFFRS_X1%11_26 x_PM_DFFRS_X1%11_25 2.32071
R_x_PM_DFFRS_X1%11_r65 N_11_M19_g x_PM_DFFRS_X1%11_77 35.88
R_x_PM_DFFRS_X1%11_r66 x_PM_DFFRS_X1%11_15 x_PM_DFFRS_X1%11_72 4.7687
R_x_PM_DFFRS_X1%11_r67 N_11_M37_g x_PM_DFFRS_X1%11_15 20.28
R_x_PM_DFFRS_X1%11_r68 N_11_M8_g x_PM_DFFRS_X1%11_71 67.08
R_x_PM_DFFRS_X1%11_r69 N_11_M8_g x_PM_DFFRS_X1%11_12 46.8
R_x_PM_DFFRS_X1%11_r70 N_11_M30_g x_PM_DFFRS_X1%11_70 17.94
R_x_PM_DFFRS_X1%11_r71 x_PM_DFFRS_X1%11_12 x_PM_DFFRS_X1%11_5 4.35808
R_x_PM_DFFRS_X1%11_r72 x_PM_DFFRS_X1%11_6 x_PM_DFFRS_X1%11_5 74.88
R_x_PM_DFFRS_X1%11_r73 x_PM_DFFRS_X1%11_6 x_PM_DFFRS_X1%11_VSS 4.35808
R_x_PM_DFFRS_X1%11_r74 N_11_M6_g x_PM_DFFRS_X1%11_VSS 28.86
C_x_PM_DFFRS_X1%12_c0 VSS x_PM_DFFRS_X1%12_74 9.38788e-18
C_x_PM_DFFRS_X1%12_c1 VSS x_PM_DFFRS_X1%12_61 2.22963e-17
C_x_PM_DFFRS_X1%12_c2 VSS x_PM_DFFRS_X1%12_59 1.2334e-17
C_x_PM_DFFRS_X1%12_c3 VSS x_PM_DFFRS_X1%12_54 1.38588e-16
C_x_PM_DFFRS_X1%12_c4 VSS x_PM_DFFRS_X1%12_52 3.88331e-17
C_x_PM_DFFRS_X1%12_c5 VSS N_12_M17_d 7.93562e-17
C_x_PM_DFFRS_X1%12_c6 VSS x_PM_DFFRS_X1%12_47 2.51094e-17
C_x_PM_DFFRS_X1%12_c7 VSS x_PM_DFFRS_X1%12_43 1.75333e-17
C_x_PM_DFFRS_X1%12_c8 VSS x_PM_DFFRS_X1%12_42 1.305e-16
C_x_PM_DFFRS_X1%12_c9 VSS x_PM_DFFRS_X1%12_41 5.29951e-17
C_x_PM_DFFRS_X1%12_c10 VSS N_12_M14_s 1.19507e-16
C_x_PM_DFFRS_X1%12_c11 VSS x_PM_DFFRS_X1%12_36 5.75461e-17
C_x_PM_DFFRS_X1%12_c12 VSS x_PM_DFFRS_X1%12_33 2.34108e-17
C_x_PM_DFFRS_X1%12_c13 VSS x_PM_DFFRS_X1%12_30 3.28824e-17
C_x_PM_DFFRS_X1%12_c14 VSS x_PM_DFFRS_X1%12_28 2.65243e-17
C_x_PM_DFFRS_X1%12_c15 VSS x_PM_DFFRS_X1%12_27 4.58117e-17
C_x_PM_DFFRS_X1%12_c16 VSS x_PM_DFFRS_X1%12_25 2.39773e-17
C_x_PM_DFFRS_X1%12_c17 VSS x_PM_DFFRS_X1%12_24 5.66525e-17
C_x_PM_DFFRS_X1%12_c18 VSS x_PM_DFFRS_X1%12_23 5.90041e-18
C_x_PM_DFFRS_X1%12_c19 VSS x_PM_DFFRS_X1%12_21 2.62382e-17
C_x_PM_DFFRS_X1%12_c20 VSS x_PM_DFFRS_X1%12_20 1.07773e-16
C_x_PM_DFFRS_X1%12_c21 VSS x_PM_DFFRS_X1%12_19 1.30977e-17
C_x_PM_DFFRS_X1%12_c22 VSS N_12_M20_g 6.02784e-17
C_x_PM_DFFRS_X1%12_c23 VSS N_12_M40_g 4.30455e-17
C_x_PM_DFFRS_X1%12_c24 VSS N_12_M31_g 9.17368e-17
R_x_PM_DFFRS_X1%12_r25 x_PM_DFFRS_X1%12_76 x_PM_DFFRS_X1%12_74 4.77878
R_x_PM_DFFRS_X1%12_r26 x_PM_DFFRS_X1%12_66 x_PM_DFFRS_X1%12_64 0.597143
R_x_PM_DFFRS_X1%12_r27 x_PM_DFFRS_X1%12_72 x_PM_DFFRS_X1%12_59 4.7687
R_x_PM_DFFRS_X1%12_r28 x_PM_DFFRS_X1%12_59 x_PM_DFFRS_X1%12_57 25.0012
R_x_PM_DFFRS_X1%12_r29 x_PM_DFFRS_X1%12_61 x_PM_DFFRS_X1%12_57 0.19
R_x_PM_DFFRS_X1%12_r30 x_PM_DFFRS_X1%12_74 x_PM_DFFRS_X1%12_54 25.0012
R_x_PM_DFFRS_X1%12_r31 x_PM_DFFRS_X1%12_66 x_PM_DFFRS_X1%12_52 0.19
R_x_PM_DFFRS_X1%12_r32 x_PM_DFFRS_X1%12_54 x_PM_DFFRS_X1%12_52 2.34786
R_x_PM_DFFRS_X1%12_r33 x_PM_DFFRS_X1%12_66 x_PM_DFFRS_X1%12_48 0.095
R_x_PM_DFFRS_X1%12_r34 N_12_M17_d x_PM_DFFRS_X1%12_48 2.13071
R_x_PM_DFFRS_X1%12_r35 x_PM_DFFRS_X1%12_64 x_PM_DFFRS_X1%12_47 0.095
R_x_PM_DFFRS_X1%12_r36 x_PM_DFFRS_X1%12_47 x_PM_DFFRS_X1%12_46 0.732857
R_x_PM_DFFRS_X1%12_r37 N_12_M37_d x_PM_DFFRS_X1%12_43 2.72786
R_x_PM_DFFRS_X1%12_r38 x_PM_DFFRS_X1%12_46 x_PM_DFFRS_X1%12_42 0.212317
R_x_PM_DFFRS_X1%12_r39 N_12_M37_d x_PM_DFFRS_X1%12_42 0.203571
R_x_PM_DFFRS_X1%12_r40 x_PM_DFFRS_X1%12_43 x_PM_DFFRS_X1%12_40 0.212317
R_x_PM_DFFRS_X1%12_r41 x_PM_DFFRS_X1%12_41 x_PM_DFFRS_X1%12_40 1.87286
R_x_PM_DFFRS_X1%12_r42 x_PM_DFFRS_X1%12_36 x_PM_DFFRS_X1%12_67 23.4
R_x_PM_DFFRS_X1%12_r43 x_PM_DFFRS_X1%12_36 x_PM_DFFRS_X1%12_33 25.0012
R_x_PM_DFFRS_X1%12_r44 N_12_M14_s x_PM_DFFRS_X1%12_33 0.774074
R_x_PM_DFFRS_X1%12_r45 x_PM_DFFRS_X1%12_41 x_PM_DFFRS_X1%12_33 0.277749
R_x_PM_DFFRS_X1%12_r46 x_PM_DFFRS_X1%12_67 x_PM_DFFRS_X1%12_30 25.0012
R_x_PM_DFFRS_X1%12_r47 x_PM_DFFRS_X1%12_30 x_PM_DFFRS_X1%12_28 0.610714
R_x_PM_DFFRS_X1%12_r48 x_PM_DFFRS_X1%12_28 x_PM_DFFRS_X1%12_26 0.212317
R_x_PM_DFFRS_X1%12_r49 x_PM_DFFRS_X1%12_27 x_PM_DFFRS_X1%12_26 1.19429
R_x_PM_DFFRS_X1%12_r50 x_PM_DFFRS_X1%12_27 x_PM_DFFRS_X1%12_24 0.212317
R_x_PM_DFFRS_X1%12_r51 x_PM_DFFRS_X1%12_25 x_PM_DFFRS_X1%12_24 1.08571
R_x_PM_DFFRS_X1%12_r52 x_PM_DFFRS_X1%12_25 x_PM_DFFRS_X1%12_23 0.212317
R_x_PM_DFFRS_X1%12_r53 x_PM_DFFRS_X1%12_23 x_PM_DFFRS_X1%12_22 0.38
R_x_PM_DFFRS_X1%12_r54 x_PM_DFFRS_X1%12_22 x_PM_DFFRS_X1%12_20 0.212317
R_x_PM_DFFRS_X1%12_r55 x_PM_DFFRS_X1%12_21 x_PM_DFFRS_X1%12_20 1.73714
R_x_PM_DFFRS_X1%12_r56 x_PM_DFFRS_X1%12_61 x_PM_DFFRS_X1%12_19 0.095
R_x_PM_DFFRS_X1%12_r57 x_PM_DFFRS_X1%12_21 x_PM_DFFRS_X1%12_18 0.212317
R_x_PM_DFFRS_X1%12_r58 x_PM_DFFRS_X1%12_19 x_PM_DFFRS_X1%12_18 0.732857
R_x_PM_DFFRS_X1%12_r59 N_12_M20_g x_PM_DFFRS_X1%12_76 76.44
R_x_PM_DFFRS_X1%12_r60 x_PM_DFFRS_X1%12_7 x_PM_DFFRS_X1%12_74 4.77878
R_x_PM_DFFRS_X1%12_r61 N_12_M40_g x_PM_DFFRS_X1%12_7 40.56
R_x_PM_DFFRS_X1%12_r62 N_12_M9_g x_PM_DFFRS_X1%12_72 28.86
R_x_PM_DFFRS_X1%12_r63 N_12_M9_g N_12_M31_g 88.92
C_x_PM_DFFRS_X1%RN_c0 VSS RN 9.10082e-17
C_x_PM_DFFRS_X1%RN_c1 VSS x_PM_DFFRS_X1%RN_21 9.20004e-18
C_x_PM_DFFRS_X1%RN_c2 VSS N_RN_M16_g 5.53488e-17
C_x_PM_DFFRS_X1%RN_c3 VSS x_PM_DFFRS_X1%RN_15 6.0109e-17
C_x_PM_DFFRS_X1%RN_c4 VSS N_RN_M35_g 3.8052e-17
C_x_PM_DFFRS_X1%RN_c5 VSS x_PM_DFFRS_X1%RN_10 1.27238e-17
C_x_PM_DFFRS_X1%RN_c6 VSS x_PM_DFFRS_X1%RN_9 4.63262e-17
C_x_PM_DFFRS_X1%RN_c7 VSS N_RN_M34_g 4.24566e-17
C_x_PM_DFFRS_X1%RN_c8 VSS N_RN_M12_g 6.63212e-17
R_x_PM_DFFRS_X1%RN_r9 x_PM_DFFRS_X1%RN_32 x_PM_DFFRS_X1%RN_24 1.24091
R_x_PM_DFFRS_X1%RN_r10 x_PM_DFFRS_X1%RN_24 x_PM_DFFRS_X1%RN_29 3.36818
R_x_PM_DFFRS_X1%RN_r11 x_PM_DFFRS_X1%RN_24 x_PM_DFFRS_X1%RN_22 25.0012
R_x_PM_DFFRS_X1%RN_r12 RN x_PM_DFFRS_X1%RN_22 0.0366667
R_x_PM_DFFRS_X1%RN_r13 N_RN_M16_g x_PM_DFFRS_X1%RN_17 45.63
R_x_PM_DFFRS_X1%RN_r14 x_PM_DFFRS_X1%RN_21 x_PM_DFFRS_X1%RN_16 2.19884
R_x_PM_DFFRS_X1%RN_r15 x_PM_DFFRS_X1%RN_17 x_PM_DFFRS_X1%RN_15 4.35808
R_x_PM_DFFRS_X1%RN_r16 x_PM_DFFRS_X1%RN_16 x_PM_DFFRS_X1%RN_15 71.76
R_x_PM_DFFRS_X1%RN_r17 x_PM_DFFRS_X1%RN_21 x_PM_DFFRS_X1%RN_11 1.96807
R_x_PM_DFFRS_X1%RN_r18 N_RN_M35_g x_PM_DFFRS_X1%RN_11 35.88
R_x_PM_DFFRS_X1%RN_r19 x_PM_DFFRS_X1%RN_32 x_PM_DFFRS_X1%RN_10 1.77273
R_x_PM_DFFRS_X1%RN_r20 x_PM_DFFRS_X1%RN_21 x_PM_DFFRS_X1%RN_9 2.19884
R_x_PM_DFFRS_X1%RN_r21 x_PM_DFFRS_X1%RN_10 x_PM_DFFRS_X1%RN_9 22.6909
R_x_PM_DFFRS_X1%RN_r22 x_PM_DFFRS_X1%RN_32 x_PM_DFFRS_X1%RN_5 1.95
R_x_PM_DFFRS_X1%RN_r23 N_RN_M34_g x_PM_DFFRS_X1%RN_5 32.76
R_x_PM_DFFRS_X1%RN_r24 x_PM_DFFRS_X1%RN_29 x_PM_DFFRS_X1%RN_VSS 1.95
R_x_PM_DFFRS_X1%RN_r25 N_RN_M12_g x_PM_DFFRS_X1%RN_VSS 56.16
C_x_PM_DFFRS_X1%14_c0 VSS x_PM_DFFRS_X1%14_48 1.2878e-17
C_x_PM_DFFRS_X1%14_c1 VSS x_PM_DFFRS_X1%14_43 1.05401e-17
C_x_PM_DFFRS_X1%14_c2 VSS x_PM_DFFRS_X1%14_42 1.40979e-17
C_x_PM_DFFRS_X1%14_c3 VSS x_PM_DFFRS_X1%14_39 9.65483e-18
C_x_PM_DFFRS_X1%14_c4 VSS x_PM_DFFRS_X1%14_36 7.21941e-17
C_x_PM_DFFRS_X1%14_c5 VSS x_PM_DFFRS_X1%14_31 3.39931e-17
C_x_PM_DFFRS_X1%14_c6 VSS x_PM_DFFRS_X1%14_29 4.40991e-17
C_x_PM_DFFRS_X1%14_c7 VSS x_PM_DFFRS_X1%14_24 3.59159e-17
C_x_PM_DFFRS_X1%14_c8 VSS x_PM_DFFRS_X1%14_23 8.42106e-17
C_x_PM_DFFRS_X1%14_c9 VSS x_PM_DFFRS_X1%14_22 2.83909e-17
C_x_PM_DFFRS_X1%14_c10 VSS x_PM_DFFRS_X1%14_20 5.07134e-17
C_x_PM_DFFRS_X1%14_c11 VSS x_PM_DFFRS_X1%14_19 1.41239e-16
C_x_PM_DFFRS_X1%14_c12 VSS x_PM_DFFRS_X1%14_12 1.37767e-16
C_x_PM_DFFRS_X1%14_c13 VSS N_14_M40_s 2.86351e-17
C_x_PM_DFFRS_X1%14_c14 VSS N_14_M15_g 3.68295e-17
C_x_PM_DFFRS_X1%14_c15 VSS N_14_M36_g 2.35948e-17
R_x_PM_DFFRS_X1%14_r16 x_PM_DFFRS_X1%14_52 x_PM_DFFRS_X1%14_39 4.7687
R_x_PM_DFFRS_X1%14_r17 x_PM_DFFRS_X1%14_39 x_PM_DFFRS_X1%14_37 25.0012
R_x_PM_DFFRS_X1%14_r18 x_PM_DFFRS_X1%14_36 x_PM_DFFRS_X1%14_35 3.20286
R_x_PM_DFFRS_X1%14_r19 x_PM_DFFRS_X1%14_36 x_PM_DFFRS_X1%14_31 0.212317
R_x_PM_DFFRS_X1%14_r20 N_14_M20_d x_PM_DFFRS_X1%14_31 0.475
R_x_PM_DFFRS_X1%14_r21 x_PM_DFFRS_X1%14_42 x_PM_DFFRS_X1%14_30 0.160909
R_x_PM_DFFRS_X1%14_r22 x_PM_DFFRS_X1%14_35 x_PM_DFFRS_X1%14_29 0.212317
R_x_PM_DFFRS_X1%14_r23 x_PM_DFFRS_X1%14_30 x_PM_DFFRS_X1%14_29 1.33
R_x_PM_DFFRS_X1%14_r24 x_PM_DFFRS_X1%14_42 x_PM_DFFRS_X1%14_25 0.0418175
R_x_PM_DFFRS_X1%14_r25 x_PM_DFFRS_X1%14_42 x_PM_DFFRS_X1%14_23 0.160909
R_x_PM_DFFRS_X1%14_r26 x_PM_DFFRS_X1%14_24 x_PM_DFFRS_X1%14_23 1.57429
R_x_PM_DFFRS_X1%14_r27 x_PM_DFFRS_X1%14_24 x_PM_DFFRS_X1%14_22 0.212317
R_x_PM_DFFRS_X1%14_r28 x_PM_DFFRS_X1%14_22 x_PM_DFFRS_X1%14_21 0.895714
R_x_PM_DFFRS_X1%14_r29 x_PM_DFFRS_X1%14_20 x_PM_DFFRS_X1%14_37 0.29113
R_x_PM_DFFRS_X1%14_r30 x_PM_DFFRS_X1%14_21 x_PM_DFFRS_X1%14_19 0.212317
R_x_PM_DFFRS_X1%14_r31 x_PM_DFFRS_X1%14_20 x_PM_DFFRS_X1%14_19 2.17143
R_x_PM_DFFRS_X1%14_r32 x_PM_DFFRS_X1%14_48 x_PM_DFFRS_X1%14_17 3.38
R_x_PM_DFFRS_X1%14_r33 x_PM_DFFRS_X1%14_17 x_PM_DFFRS_X1%14_15 25.0012
R_x_PM_DFFRS_X1%14_r34 x_PM_DFFRS_X1%14_15 x_PM_DFFRS_X1%14_12 0.83037
R_x_PM_DFFRS_X1%14_r35 x_PM_DFFRS_X1%14_43 x_PM_DFFRS_X1%14_12 25.0012
R_x_PM_DFFRS_X1%14_r36 N_14_M40_s x_PM_DFFRS_X1%14_25 0.637857
R_x_PM_DFFRS_X1%14_r37 x_PM_DFFRS_X1%14_48 x_PM_DFFRS_X1%14_5 1.95
R_x_PM_DFFRS_X1%14_r38 N_14_M15_g x_PM_DFFRS_X1%14_5 36.66
R_x_PM_DFFRS_X1%14_r39 N_14_M36_g x_PM_DFFRS_X1%14_52 14.82
R_x_PM_DFFRS_X1%14_r40 x_PM_DFFRS_X1%14_2 x_PM_DFFRS_X1%14_43 4.7687
R_x_PM_DFFRS_X1%14_r41 N_14_M36_g x_PM_DFFRS_X1%14_2 20.28
C_x_PM_DFFRS_X1%D_c0 VSS x_PM_DFFRS_X1%D_14 4.69854e-17
C_x_PM_DFFRS_X1%D_c1 VSS x_PM_DFFRS_X1%D_12 1.43967e-17
C_x_PM_DFFRS_X1%D_c2 VSS x_PM_DFFRS_X1%D_9 9.06937e-17
C_x_PM_DFFRS_X1%D_c3 VSS N_D_M18_g 6.44746e-17
C_x_PM_DFFRS_X1%D_c4 VSS N_D_M39_g 5.94044e-17
R_x_PM_DFFRS_X1%D_r5 D x_PM_DFFRS_X1%D_14 0.245882
R_x_PM_DFFRS_X1%D_r6 x_PM_DFFRS_X1%D_12 x_PM_DFFRS_X1%D_19 7.54
R_x_PM_DFFRS_X1%D_r7 x_PM_DFFRS_X1%D_12 x_PM_DFFRS_X1%D_10 25.0012
R_x_PM_DFFRS_X1%D_r8 x_PM_DFFRS_X1%D_14 x_PM_DFFRS_X1%D_9 0.095
R_x_PM_DFFRS_X1%D_r9 x_PM_DFFRS_X1%D_10 x_PM_DFFRS_X1%D_9 1.83214
R_x_PM_DFFRS_X1%D_r10 x_PM_DFFRS_X1%D_19 x_PM_DFFRS_X1%D_5 1.95
R_x_PM_DFFRS_X1%D_r11 N_D_M18_g x_PM_DFFRS_X1%D_5 59.28
R_x_PM_DFFRS_X1%D_r12 x_PM_DFFRS_X1%D_19 x_PM_DFFRS_X1%D_VSS 1.95
R_x_PM_DFFRS_X1%D_r13 N_D_M39_g x_PM_DFFRS_X1%D_VSS 57.72
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFRS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFRS_X2 VSS VDD Q QN SN CK RN D
*.PININFO VSS:B VDD:B QN:O Q:O CK:I SN:I RN:I D:I
M_M20 N_VDD_M0_d N_4_M0_g N_QN_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_4_M1_d N_10_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M22 N_VDD_M2_d N_SN_M2_g N_4_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M23 N_Q_M3_d N_10_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M24 N_VDD_M4_d N_CK_M4_g N_6_M4_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 16 N_SN_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_9_M6_d N_11_M6_g 16 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 17 N_10_M7_g N_VDD_M7_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 N_9_M8_d N_11_M8_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 18 N_12_M9_g N_9_M8_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_VDD_M10_d N_6_M10_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M31 N_10_M11_d N_9_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M32 N_VDD_M12_d N_RN_M12_g N_10_M11_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M33 N_11_M13_d N_6_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M34 19 N_6_M14_g N_12_M14_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 N_VDD_M15_d N_14_M15_g 19 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M36 20 N_RN_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.315000U L=0.050000U
M_M37 N_12_M17_d N_6_M17_g 20 VDD PMOS_VTL W=0.315000U L=0.050000U
M_M38 21 N_D_M18_g N_12_M17_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M39 N_VDD_M19_d N_11_M19_g 21 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M40 N_14_M20_d N_SN_M20_g N_VDD_M19_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M41 N_VDD_M21_d N_12_M21_g N_14_M20_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M0 N_VSS_M22_d N_4_M22_g N_QN_M22_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 22 N_10_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_4_M24_d N_SN_M24_g 22 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_VSS_M25_d N_10_M25_g N_Q_M25_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M26_d N_CK_M26_g N_6_M26_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 23 N_SN_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 24 N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_9_M29_d N_6_M29_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 25 N_11_M30_g N_9_M29_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_VSS_M31_d N_12_M31_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_11_M32_d N_6_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M11 26 N_9_M33_g N_10_M33_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M12 N_VSS_M34_d N_RN_M34_g 26 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M13 27 N_RN_M35_g N_VSS_M34_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 28 N_14_M36_g 27 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_12_M37_d N_11_M37_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 29 N_6_M38_g N_12_M37_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_VSS_M39_d N_D_M39_g 29 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 30 N_SN_M40_g N_VSS_M39_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M19 N_14_M41_d N_12_M41_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DFFRS_X2%VSS_c0 VSS x_PM_DFFRS_X2%VSS_48 8.86015e-18
C_x_PM_DFFRS_X2%VSS_c1 VSS x_PM_DFFRS_X2%VSS_43 1.21607e-16
C_x_PM_DFFRS_X2%VSS_c2 VSS x_PM_DFFRS_X2%VSS_42 8.93987e-18
C_x_PM_DFFRS_X2%VSS_c3 VSS x_PM_DFFRS_X2%VSS_41 8.91086e-18
C_x_PM_DFFRS_X2%VSS_c4 VSS x_PM_DFFRS_X2%VSS_40 4.6069e-18
C_x_PM_DFFRS_X2%VSS_c5 VSS x_PM_DFFRS_X2%VSS_39 3.0466e-17
C_x_PM_DFFRS_X2%VSS_c6 VSS VSS 5.98246e-17
C_x_PM_DFFRS_X2%VSS_c7 VSS x_PM_DFFRS_X2%VSS_34 7.12832e-17
C_x_PM_DFFRS_X2%VSS_c8 VSS x_PM_DFFRS_X2%VSS_31 1.85722e-16
C_x_PM_DFFRS_X2%VSS_c9 VSS x_PM_DFFRS_X2%VSS_29 7.28624e-17
C_x_PM_DFFRS_X2%VSS_c10 VSS N_VSS_M31_d 7.41343e-17
C_x_PM_DFFRS_X2%VSS_c11 VSS x_PM_DFFRS_X2%VSS_23 1.26202e-16
C_x_PM_DFFRS_X2%VSS_c12 VSS x_PM_DFFRS_X2%VSS_22 7.26876e-17
C_x_PM_DFFRS_X2%VSS_c13 VSS x_PM_DFFRS_X2%VSS_19 2.19719e-17
C_x_PM_DFFRS_X2%VSS_c14 VSS N_VSS_M25_d 1.91628e-17
C_x_PM_DFFRS_X2%VSS_c15 VSS x_PM_DFFRS_X2%VSS_13 6.01132e-17
C_x_PM_DFFRS_X2%VSS_c16 VSS N_VSS_M22_d 3.79598e-17
R_x_PM_DFFRS_X2%VSS_r17 N_VSS_M34_d x_PM_DFFRS_X2%VSS_43 0.355571
R_x_PM_DFFRS_X2%VSS_r18 x_PM_DFFRS_X2%VSS_48 x_PM_DFFRS_X2%VSS_35 0.132285
R_x_PM_DFFRS_X2%VSS_r19 VSS x_PM_DFFRS_X2%VSS_35 1.18471
R_x_PM_DFFRS_X2%VSS_r20 x_PM_DFFRS_X2%VSS_48 x_PM_DFFRS_X2%VSS_34 0.0680382
R_x_PM_DFFRS_X2%VSS_r21 x_PM_DFFRS_X2%VSS_34 N_VSS_M39_d 0.403583
R_x_PM_DFFRS_X2%VSS_r22 x_PM_DFFRS_X2%VSS_43 x_PM_DFFRS_X2%VSS_32 0.095
R_x_PM_DFFRS_X2%VSS_r23 x_PM_DFFRS_X2%VSS_48 x_PM_DFFRS_X2%VSS_31 0.132285
R_x_PM_DFFRS_X2%VSS_r24 x_PM_DFFRS_X2%VSS_32 x_PM_DFFRS_X2%VSS_31 2.35824
R_x_PM_DFFRS_X2%VSS_r25 x_PM_DFFRS_X2%VSS_42 x_PM_DFFRS_X2%VSS_30 0.132285
R_x_PM_DFFRS_X2%VSS_r26 x_PM_DFFRS_X2%VSS_43 x_PM_DFFRS_X2%VSS_29 0.095
R_x_PM_DFFRS_X2%VSS_r27 x_PM_DFFRS_X2%VSS_30 x_PM_DFFRS_X2%VSS_29 1.47529
R_x_PM_DFFRS_X2%VSS_r28 x_PM_DFFRS_X2%VSS_42 x_PM_DFFRS_X2%VSS_25 0.0680382
R_x_PM_DFFRS_X2%VSS_r29 N_VSS_M31_d x_PM_DFFRS_X2%VSS_25 0.823333
R_x_PM_DFFRS_X2%VSS_r30 x_PM_DFFRS_X2%VSS_41 x_PM_DFFRS_X2%VSS_24 0.132285
R_x_PM_DFFRS_X2%VSS_r31 x_PM_DFFRS_X2%VSS_42 x_PM_DFFRS_X2%VSS_23 0.132285
R_x_PM_DFFRS_X2%VSS_r32 x_PM_DFFRS_X2%VSS_24 x_PM_DFFRS_X2%VSS_23 1.93353
R_x_PM_DFFRS_X2%VSS_r33 x_PM_DFFRS_X2%VSS_41 x_PM_DFFRS_X2%VSS_22 0.0680382
R_x_PM_DFFRS_X2%VSS_r34 x_PM_DFFRS_X2%VSS_22 N_VSS_M26_d 0.628768
R_x_PM_DFFRS_X2%VSS_r35 x_PM_DFFRS_X2%VSS_40 x_PM_DFFRS_X2%VSS_20 0.0731438
R_x_PM_DFFRS_X2%VSS_r36 x_PM_DFFRS_X2%VSS_41 x_PM_DFFRS_X2%VSS_19 0.132285
R_x_PM_DFFRS_X2%VSS_r37 x_PM_DFFRS_X2%VSS_20 x_PM_DFFRS_X2%VSS_19 0.547647
R_x_PM_DFFRS_X2%VSS_r38 x_PM_DFFRS_X2%VSS_40 x_PM_DFFRS_X2%VSS_15 0.145286
R_x_PM_DFFRS_X2%VSS_r39 N_VSS_M25_d x_PM_DFFRS_X2%VSS_15 0.909286
R_x_PM_DFFRS_X2%VSS_r40 x_PM_DFFRS_X2%VSS_39 x_PM_DFFRS_X2%VSS_14 0.0731438
R_x_PM_DFFRS_X2%VSS_r41 x_PM_DFFRS_X2%VSS_40 x_PM_DFFRS_X2%VSS_13 0.0731438
R_x_PM_DFFRS_X2%VSS_r42 x_PM_DFFRS_X2%VSS_14 x_PM_DFFRS_X2%VSS_13 1.45294
R_x_PM_DFFRS_X2%VSS_r43 x_PM_DFFRS_X2%VSS_39 x_PM_DFFRS_X2%VSS_9 0.145286
R_x_PM_DFFRS_X2%VSS_r44 N_VSS_M22_d x_PM_DFFRS_X2%VSS_9 1.31643
C_x_PM_DFFRS_X2%VDD_c0 VSS x_PM_DFFRS_X2%VDD_73 5.60857e-18
C_x_PM_DFFRS_X2%VDD_c1 VSS x_PM_DFFRS_X2%VDD_72 4.02659e-18
C_x_PM_DFFRS_X2%VDD_c2 VSS x_PM_DFFRS_X2%VDD_71 4.01887e-18
C_x_PM_DFFRS_X2%VDD_c3 VSS x_PM_DFFRS_X2%VDD_70 4.01887e-18
C_x_PM_DFFRS_X2%VDD_c4 VSS x_PM_DFFRS_X2%VDD_69 4.62499e-18
C_x_PM_DFFRS_X2%VDD_c5 VSS N_VDD_M4_d 2.08227e-17
C_x_PM_DFFRS_X2%VDD_c6 VSS x_PM_DFFRS_X2%VDD_63 2.66615e-18
C_x_PM_DFFRS_X2%VDD_c7 VSS x_PM_DFFRS_X2%VDD_62 2.96322e-18
C_x_PM_DFFRS_X2%VDD_c8 VSS N_VDD_M21_d 3.40483e-17
C_x_PM_DFFRS_X2%VDD_c9 VSS x_PM_DFFRS_X2%VDD_56 3.06189e-17
C_x_PM_DFFRS_X2%VDD_c10 VSS N_VDD_M19_d 2.50894e-17
C_x_PM_DFFRS_X2%VDD_c11 VSS x_PM_DFFRS_X2%VDD_50 1.18769e-16
C_x_PM_DFFRS_X2%VDD_c12 VSS N_VDD_M15_d 8.69431e-17
C_x_PM_DFFRS_X2%VDD_c13 VSS x_PM_DFFRS_X2%VDD_44 1.43083e-16
C_x_PM_DFFRS_X2%VDD_c14 VSS N_VDD_M12_d 4.59356e-17
C_x_PM_DFFRS_X2%VDD_c15 VSS x_PM_DFFRS_X2%VDD_38 5.8688e-17
C_x_PM_DFFRS_X2%VDD_c16 VSS N_VDD_M10_d 7.56551e-17
C_x_PM_DFFRS_X2%VDD_c17 VSS x_PM_DFFRS_X2%VDD_32 1.03296e-16
C_x_PM_DFFRS_X2%VDD_c18 VSS N_VDD_M7_s 4.32392e-17
C_x_PM_DFFRS_X2%VDD_c19 VSS x_PM_DFFRS_X2%VDD_26 4.31397e-17
C_x_PM_DFFRS_X2%VDD_c20 VSS x_PM_DFFRS_X2%VDD_24 4.29303e-17
C_x_PM_DFFRS_X2%VDD_c21 VSS N_VDD_M2_d 3.9949e-17
C_x_PM_DFFRS_X2%VDD_c22 VSS x_PM_DFFRS_X2%VDD_18 2.23728e-17
C_x_PM_DFFRS_X2%VDD_c23 VSS N_VDD_M0_d 3.04809e-17
C_x_PM_DFFRS_X2%VDD_c24 VSS x_PM_DFFRS_X2%VDD_10 2.24347e-17
R_x_PM_DFFRS_X2%VDD_r25 x_PM_DFFRS_X2%VDD_67 N_VDD_M4_d 0.49963
R_x_PM_DFFRS_X2%VDD_r26 N_VDD_M21_d x_PM_DFFRS_X2%VDD_58 1.64214
R_x_PM_DFFRS_X2%VDD_r27 x_PM_DFFRS_X2%VDD_73 x_PM_DFFRS_X2%VDD_57 0.132285
R_x_PM_DFFRS_X2%VDD_r28 x_PM_DFFRS_X2%VDD_58 x_PM_DFFRS_X2%VDD_56 0.264221
R_x_PM_DFFRS_X2%VDD_r29 x_PM_DFFRS_X2%VDD_57 x_PM_DFFRS_X2%VDD_56 0.603529
R_x_PM_DFFRS_X2%VDD_r30 x_PM_DFFRS_X2%VDD_73 x_PM_DFFRS_X2%VDD_52 0.0680382
R_x_PM_DFFRS_X2%VDD_r31 N_VDD_M19_d x_PM_DFFRS_X2%VDD_52 0.344815
R_x_PM_DFFRS_X2%VDD_r32 x_PM_DFFRS_X2%VDD_72 x_PM_DFFRS_X2%VDD_51 0.0731438
R_x_PM_DFFRS_X2%VDD_r33 x_PM_DFFRS_X2%VDD_73 x_PM_DFFRS_X2%VDD_50 0.132285
R_x_PM_DFFRS_X2%VDD_r34 x_PM_DFFRS_X2%VDD_51 x_PM_DFFRS_X2%VDD_50 1.50882
R_x_PM_DFFRS_X2%VDD_r35 x_PM_DFFRS_X2%VDD_72 x_PM_DFFRS_X2%VDD_46 0.145286
R_x_PM_DFFRS_X2%VDD_r36 N_VDD_M15_d x_PM_DFFRS_X2%VDD_46 1.28929
R_x_PM_DFFRS_X2%VDD_r37 x_PM_DFFRS_X2%VDD_71 x_PM_DFFRS_X2%VDD_45 0.0731438
R_x_PM_DFFRS_X2%VDD_r38 x_PM_DFFRS_X2%VDD_72 x_PM_DFFRS_X2%VDD_44 0.0731438
R_x_PM_DFFRS_X2%VDD_r39 x_PM_DFFRS_X2%VDD_45 x_PM_DFFRS_X2%VDD_44 1.50882
R_x_PM_DFFRS_X2%VDD_r40 x_PM_DFFRS_X2%VDD_71 x_PM_DFFRS_X2%VDD_40 0.145286
R_x_PM_DFFRS_X2%VDD_r41 N_VDD_M12_d x_PM_DFFRS_X2%VDD_40 1.15357
R_x_PM_DFFRS_X2%VDD_r42 x_PM_DFFRS_X2%VDD_70 x_PM_DFFRS_X2%VDD_39 0.0731438
R_x_PM_DFFRS_X2%VDD_r43 x_PM_DFFRS_X2%VDD_71 x_PM_DFFRS_X2%VDD_38 0.0731438
R_x_PM_DFFRS_X2%VDD_r44 x_PM_DFFRS_X2%VDD_39 x_PM_DFFRS_X2%VDD_38 1.20706
R_x_PM_DFFRS_X2%VDD_r45 x_PM_DFFRS_X2%VDD_70 x_PM_DFFRS_X2%VDD_34 0.145286
R_x_PM_DFFRS_X2%VDD_r46 N_VDD_M10_d x_PM_DFFRS_X2%VDD_34 1.15357
R_x_PM_DFFRS_X2%VDD_r47 x_PM_DFFRS_X2%VDD_69 x_PM_DFFRS_X2%VDD_33 0.0731438
R_x_PM_DFFRS_X2%VDD_r48 x_PM_DFFRS_X2%VDD_70 x_PM_DFFRS_X2%VDD_32 0.0731438
R_x_PM_DFFRS_X2%VDD_r49 x_PM_DFFRS_X2%VDD_33 x_PM_DFFRS_X2%VDD_32 1.52
R_x_PM_DFFRS_X2%VDD_r50 x_PM_DFFRS_X2%VDD_69 x_PM_DFFRS_X2%VDD_28 0.145286
R_x_PM_DFFRS_X2%VDD_r51 N_VDD_M7_s x_PM_DFFRS_X2%VDD_28 1.20786
R_x_PM_DFFRS_X2%VDD_r52 x_PM_DFFRS_X2%VDD_67 x_PM_DFFRS_X2%VDD_27 0.095
R_x_PM_DFFRS_X2%VDD_r53 x_PM_DFFRS_X2%VDD_69 x_PM_DFFRS_X2%VDD_26 0.0731438
R_x_PM_DFFRS_X2%VDD_r54 x_PM_DFFRS_X2%VDD_27 x_PM_DFFRS_X2%VDD_26 0.972353
R_x_PM_DFFRS_X2%VDD_r55 x_PM_DFFRS_X2%VDD_63 x_PM_DFFRS_X2%VDD_25 0.0731438
R_x_PM_DFFRS_X2%VDD_r56 x_PM_DFFRS_X2%VDD_67 x_PM_DFFRS_X2%VDD_24 0.095
R_x_PM_DFFRS_X2%VDD_r57 x_PM_DFFRS_X2%VDD_25 x_PM_DFFRS_X2%VDD_24 1.06176
R_x_PM_DFFRS_X2%VDD_r58 x_PM_DFFRS_X2%VDD_63 x_PM_DFFRS_X2%VDD_20 0.145286
R_x_PM_DFFRS_X2%VDD_r59 N_VDD_M2_d x_PM_DFFRS_X2%VDD_20 1.31643
R_x_PM_DFFRS_X2%VDD_r60 x_PM_DFFRS_X2%VDD_62 x_PM_DFFRS_X2%VDD_19 0.0731438
R_x_PM_DFFRS_X2%VDD_r61 x_PM_DFFRS_X2%VDD_63 x_PM_DFFRS_X2%VDD_18 0.0731438
R_x_PM_DFFRS_X2%VDD_r62 x_PM_DFFRS_X2%VDD_19 x_PM_DFFRS_X2%VDD_18 0.692941
R_x_PM_DFFRS_X2%VDD_r63 x_PM_DFFRS_X2%VDD_62 x_PM_DFFRS_X2%VDD_14 0.145286
R_x_PM_DFFRS_X2%VDD_r64 N_VDD_M0_d x_PM_DFFRS_X2%VDD_14 1.31643
R_x_PM_DFFRS_X2%VDD_r65 x_PM_DFFRS_X2%VDD_62 x_PM_DFFRS_X2%VDD_10 0.0731438
R_x_PM_DFFRS_X2%VDD_r66 VDD x_PM_DFFRS_X2%VDD_10 0.257059
C_x_PM_DFFRS_X2%QN_c0 VSS x_PM_DFFRS_X2%QN_13 4.2936e-18
C_x_PM_DFFRS_X2%QN_c1 VSS N_QN_M0_s 5.67543e-17
C_x_PM_DFFRS_X2%QN_c2 VSS N_QN_M22_s 3.85876e-17
R_x_PM_DFFRS_X2%QN_r3 N_QN_M0_s x_PM_DFFRS_X2%QN_13 2.166
R_x_PM_DFFRS_X2%QN_r4 QN N_QN_M22_s 0.29
R_x_PM_DFFRS_X2%QN_r5 x_PM_DFFRS_X2%QN_13 x_PM_DFFRS_X2%QN_3 0.207904
R_x_PM_DFFRS_X2%QN_r6 QN x_PM_DFFRS_X2%QN_3 0.21
C_x_PM_DFFRS_X2%4_c0 VSS x_PM_DFFRS_X2%4_24 5.83177e-18
C_x_PM_DFFRS_X2%4_c1 VSS x_PM_DFFRS_X2%4_18 2.63152e-17
C_x_PM_DFFRS_X2%4_c2 VSS N_4_M1_d 3.76058e-17
C_x_PM_DFFRS_X2%4_c3 VSS x_PM_DFFRS_X2%4_13 5.43397e-17
C_x_PM_DFFRS_X2%4_c4 VSS x_PM_DFFRS_X2%4_12 1.1917e-17
C_x_PM_DFFRS_X2%4_c5 VSS N_4_M24_d 5.72434e-17
C_x_PM_DFFRS_X2%4_c6 VSS N_4_M0_g 4.22331e-17
C_x_PM_DFFRS_X2%4_c7 VSS N_4_M22_g 5.96979e-17
R_x_PM_DFFRS_X2%4_r8 x_PM_DFFRS_X2%4_24 x_PM_DFFRS_X2%4_19 0.115915
R_x_PM_DFFRS_X2%4_r9 x_PM_DFFRS_X2%4_20 x_PM_DFFRS_X2%4_18 0.212317
R_x_PM_DFFRS_X2%4_r10 x_PM_DFFRS_X2%4_19 x_PM_DFFRS_X2%4_18 0.651429
R_x_PM_DFFRS_X2%4_r11 x_PM_DFFRS_X2%4_24 x_PM_DFFRS_X2%4_14 0.0855182
R_x_PM_DFFRS_X2%4_r12 N_4_M1_d x_PM_DFFRS_X2%4_14 1.235
R_x_PM_DFFRS_X2%4_r13 x_PM_DFFRS_X2%4_24 x_PM_DFFRS_X2%4_13 0.115915
R_x_PM_DFFRS_X2%4_r14 x_PM_DFFRS_X2%4_12 x_PM_DFFRS_X2%4_25 3.9
R_x_PM_DFFRS_X2%4_r15 x_PM_DFFRS_X2%4_13 x_PM_DFFRS_X2%4_11 0.516176
R_x_PM_DFFRS_X2%4_r16 x_PM_DFFRS_X2%4_12 x_PM_DFFRS_X2%4_11 25.0012
R_x_PM_DFFRS_X2%4_r17 N_4_M24_d x_PM_DFFRS_X2%4_20 1.45214
R_x_PM_DFFRS_X2%4_r18 x_PM_DFFRS_X2%4_25 x_PM_DFFRS_X2%4_5 1.95
R_x_PM_DFFRS_X2%4_r19 N_4_M0_g x_PM_DFFRS_X2%4_5 34.32
R_x_PM_DFFRS_X2%4_r20 x_PM_DFFRS_X2%4_25 x_PM_DFFRS_X2%4_VSS 1.95
R_x_PM_DFFRS_X2%4_r21 N_4_M22_g x_PM_DFFRS_X2%4_VSS 54.6
C_x_PM_DFFRS_X2%Q_c0 VSS Q 4.94689e-17
C_x_PM_DFFRS_X2%Q_c1 VSS x_PM_DFFRS_X2%Q_7 1.15843e-17
C_x_PM_DFFRS_X2%Q_c2 VSS N_Q_M25_s 9.95136e-17
R_x_PM_DFFRS_X2%Q_r3 N_Q_M3_d Q 0.0684
R_x_PM_DFFRS_X2%Q_r4 x_PM_DFFRS_X2%Q_13 x_PM_DFFRS_X2%Q_7 0.250328
R_x_PM_DFFRS_X2%Q_r5 Q x_PM_DFFRS_X2%Q_7 0.3724
R_x_PM_DFFRS_X2%Q_r6 N_Q_M25_s x_PM_DFFRS_X2%Q_13 2.59667
C_x_PM_DFFRS_X2%6_c0 VSS x_PM_DFFRS_X2%6_53 9.73089e-18
C_x_PM_DFFRS_X2%6_c1 VSS x_PM_DFFRS_X2%6_47 5.8344e-17
C_x_PM_DFFRS_X2%6_c2 VSS x_PM_DFFRS_X2%6_45 2.48188e-17
C_x_PM_DFFRS_X2%6_c3 VSS x_PM_DFFRS_X2%6_44 3.37605e-17
C_x_PM_DFFRS_X2%6_c4 VSS x_PM_DFFRS_X2%6_42 2.39288e-17
C_x_PM_DFFRS_X2%6_c5 VSS x_PM_DFFRS_X2%6_41 1.07734e-16
C_x_PM_DFFRS_X2%6_c6 VSS N_6_M4_s 1.05601e-16
C_x_PM_DFFRS_X2%6_c7 VSS x_PM_DFFRS_X2%6_34 3.63407e-18
C_x_PM_DFFRS_X2%6_c8 VSS x_PM_DFFRS_X2%6_33 2.86422e-18
C_x_PM_DFFRS_X2%6_c9 VSS N_6_M38_g 1.29166e-16
C_x_PM_DFFRS_X2%6_c10 VSS x_PM_DFFRS_X2%6_25 6.30585e-17
C_x_PM_DFFRS_X2%6_c11 VSS N_6_M14_g 3.65014e-17
C_x_PM_DFFRS_X2%6_c12 VSS x_PM_DFFRS_X2%6_19 3.54508e-17
C_x_PM_DFFRS_X2%6_c13 VSS N_6_M13_g 4.3571e-17
C_x_PM_DFFRS_X2%6_c14 VSS x_PM_DFFRS_X2%6_14 4.9388e-18
C_x_PM_DFFRS_X2%6_c15 VSS x_PM_DFFRS_X2%6_13 8.59356e-17
C_x_PM_DFFRS_X2%6_c16 VSS N_6_M32_g 1.26015e-16
C_x_PM_DFFRS_X2%6_c17 VSS x_PM_DFFRS_X2%6_5 7.30122e-17
C_x_PM_DFFRS_X2%6_c18 VSS N_6_M29_g 2.3681e-17
R_x_PM_DFFRS_X2%6_r19 x_PM_DFFRS_X2%6_56 x_PM_DFFRS_X2%6_55 4.7687
R_x_PM_DFFRS_X2%6_r20 x_PM_DFFRS_X2%6_55 x_PM_DFFRS_X2%6_53 1.82
R_x_PM_DFFRS_X2%6_r21 N_6_M26_s x_PM_DFFRS_X2%6_50 0.402792
R_x_PM_DFFRS_X2%6_r22 x_PM_DFFRS_X2%6_55 x_PM_DFFRS_X2%6_47 25.0012
R_x_PM_DFFRS_X2%6_r23 x_PM_DFFRS_X2%6_47 x_PM_DFFRS_X2%6_45 1.45214
R_x_PM_DFFRS_X2%6_r24 x_PM_DFFRS_X2%6_45 x_PM_DFFRS_X2%6_43 0.212317
R_x_PM_DFFRS_X2%6_r25 x_PM_DFFRS_X2%6_44 x_PM_DFFRS_X2%6_43 1.00429
R_x_PM_DFFRS_X2%6_r26 N_6_M26_s x_PM_DFFRS_X2%6_42 0.157333
R_x_PM_DFFRS_X2%6_r27 x_PM_DFFRS_X2%6_44 x_PM_DFFRS_X2%6_41 0.212317
R_x_PM_DFFRS_X2%6_r28 x_PM_DFFRS_X2%6_42 x_PM_DFFRS_X2%6_41 1.65571
R_x_PM_DFFRS_X2%6_r29 x_PM_DFFRS_X2%6_50 x_PM_DFFRS_X2%6_37 0.132627
R_x_PM_DFFRS_X2%6_r30 N_6_M4_s x_PM_DFFRS_X2%6_37 2.86357
R_x_PM_DFFRS_X2%6_r31 N_6_M17_g N_6_M38_g 101.79
R_x_PM_DFFRS_X2%6_r32 N_6_M17_g x_PM_DFFRS_X2%6_27 47.97
R_x_PM_DFFRS_X2%6_r33 x_PM_DFFRS_X2%6_34 x_PM_DFFRS_X2%6_26 3.30287
R_x_PM_DFFRS_X2%6_r34 x_PM_DFFRS_X2%6_27 x_PM_DFFRS_X2%6_25 4.35808
R_x_PM_DFFRS_X2%6_r35 x_PM_DFFRS_X2%6_26 x_PM_DFFRS_X2%6_25 81.12
R_x_PM_DFFRS_X2%6_r36 x_PM_DFFRS_X2%6_34 x_PM_DFFRS_X2%6_21 0.858359
R_x_PM_DFFRS_X2%6_r37 N_6_M14_g x_PM_DFFRS_X2%6_21 30.42
R_x_PM_DFFRS_X2%6_r38 x_PM_DFFRS_X2%6_33 x_PM_DFFRS_X2%6_20 3.30287
R_x_PM_DFFRS_X2%6_r39 x_PM_DFFRS_X2%6_34 x_PM_DFFRS_X2%6_19 3.30287
R_x_PM_DFFRS_X2%6_r40 x_PM_DFFRS_X2%6_20 x_PM_DFFRS_X2%6_19 50.7
R_x_PM_DFFRS_X2%6_r41 x_PM_DFFRS_X2%6_33 x_PM_DFFRS_X2%6_15 0.858359
R_x_PM_DFFRS_X2%6_r42 N_6_M13_g x_PM_DFFRS_X2%6_15 33.54
R_x_PM_DFFRS_X2%6_r43 x_PM_DFFRS_X2%6_33 x_PM_DFFRS_X2%6_13 3.30287
R_x_PM_DFFRS_X2%6_r44 x_PM_DFFRS_X2%6_14 x_PM_DFFRS_X2%6_13 115.44
R_x_PM_DFFRS_X2%6_r45 N_6_M10_g N_6_M32_g 92.82
R_x_PM_DFFRS_X2%6_r46 x_PM_DFFRS_X2%6_14 x_PM_DFFRS_X2%6_8 4.35808
R_x_PM_DFFRS_X2%6_r47 N_6_M10_g x_PM_DFFRS_X2%6_8 40.56
R_x_PM_DFFRS_X2%6_r48 N_6_M32_g x_PM_DFFRS_X2%6_7 30.42
R_x_PM_DFFRS_X2%6_r49 x_PM_DFFRS_X2%6_53 x_PM_DFFRS_X2%6_6 1.95
R_x_PM_DFFRS_X2%6_r50 x_PM_DFFRS_X2%6_7 x_PM_DFFRS_X2%6_5 4.35808
R_x_PM_DFFRS_X2%6_r51 x_PM_DFFRS_X2%6_6 x_PM_DFFRS_X2%6_5 85.02
R_x_PM_DFFRS_X2%6_r52 N_6_M29_g x_PM_DFFRS_X2%6_56 14.82
C_x_PM_DFFRS_X2%CK_c0 VSS x_PM_DFFRS_X2%CK_23 1.53167e-17
C_x_PM_DFFRS_X2%CK_c1 VSS x_PM_DFFRS_X2%CK_21 5.12834e-17
C_x_PM_DFFRS_X2%CK_c2 VSS x_PM_DFFRS_X2%CK_17 6.20919e-17
C_x_PM_DFFRS_X2%CK_c3 VSS x_PM_DFFRS_X2%CK_15 1.70223e-17
C_x_PM_DFFRS_X2%CK_c4 VSS CK 3.6739e-17
C_x_PM_DFFRS_X2%CK_c5 VSS N_CK_M26_g 3.86274e-17
C_x_PM_DFFRS_X2%CK_c6 VSS N_CK_M4_g 4.08957e-17
R_x_PM_DFFRS_X2%CK_r7 x_PM_DFFRS_X2%CK_23 x_PM_DFFRS_X2%CK_29 2.86
R_x_PM_DFFRS_X2%CK_r8 x_PM_DFFRS_X2%CK_23 x_PM_DFFRS_X2%CK_21 25.0012
R_x_PM_DFFRS_X2%CK_r9 x_PM_DFFRS_X2%CK_21 x_PM_DFFRS_X2%CK_19 0.149286
R_x_PM_DFFRS_X2%CK_r10 x_PM_DFFRS_X2%CK_15 x_PM_DFFRS_X2%CK_25 3.9
R_x_PM_DFFRS_X2%CK_r11 x_PM_DFFRS_X2%CK_15 x_PM_DFFRS_X2%CK_13 25.0012
R_x_PM_DFFRS_X2%CK_r12 x_PM_DFFRS_X2%CK_17 x_PM_DFFRS_X2%CK_13 0.163793
R_x_PM_DFFRS_X2%CK_r13 x_PM_DFFRS_X2%CK_17 x_PM_DFFRS_X2%CK_10 0.095
R_x_PM_DFFRS_X2%CK_r14 CK x_PM_DFFRS_X2%CK_10 0.30875
R_x_PM_DFFRS_X2%CK_r15 x_PM_DFFRS_X2%CK_19 x_PM_DFFRS_X2%CK_9 0.095
R_x_PM_DFFRS_X2%CK_r16 CK x_PM_DFFRS_X2%CK_9 0.64125
R_x_PM_DFFRS_X2%CK_r17 x_PM_DFFRS_X2%CK_29 x_PM_DFFRS_X2%CK_5 1.95
R_x_PM_DFFRS_X2%CK_r18 N_CK_M26_g x_PM_DFFRS_X2%CK_5 27.3
R_x_PM_DFFRS_X2%CK_r19 x_PM_DFFRS_X2%CK_25 x_PM_DFFRS_X2%CK_VSS 1.95
R_x_PM_DFFRS_X2%CK_r20 N_CK_M4_g x_PM_DFFRS_X2%CK_VSS 28.86
C_x_PM_DFFRS_X2%SN_c0 VSS x_PM_DFFRS_X2%SN_40 1.63513e-17
C_x_PM_DFFRS_X2%SN_c1 VSS x_PM_DFFRS_X2%SN_38 5.40014e-17
C_x_PM_DFFRS_X2%SN_c2 VSS x_PM_DFFRS_X2%SN_34 4.3854e-17
C_x_PM_DFFRS_X2%SN_c3 VSS x_PM_DFFRS_X2%SN_32 1.60346e-17
C_x_PM_DFFRS_X2%SN_c4 VSS SN 3.14627e-17
C_x_PM_DFFRS_X2%SN_c5 VSS x_PM_DFFRS_X2%SN_25 3.1724e-18
C_x_PM_DFFRS_X2%SN_c6 VSS N_SN_M40_g 1.22958e-16
C_x_PM_DFFRS_X2%SN_c7 VSS x_PM_DFFRS_X2%SN_17 4.10026e-16
C_x_PM_DFFRS_X2%SN_c8 VSS N_SN_M27_g 5.14823e-17
C_x_PM_DFFRS_X2%SN_c9 VSS N_SN_M5_g 3.86719e-17
C_x_PM_DFFRS_X2%SN_c10 VSS x_PM_DFFRS_X2%SN_8 6.6872e-18
C_x_PM_DFFRS_X2%SN_c11 VSS x_PM_DFFRS_X2%SN_7 9.45475e-17
C_x_PM_DFFRS_X2%SN_c12 VSS N_SN_M24_g 1.16913e-16
R_x_PM_DFFRS_X2%SN_r13 x_PM_DFFRS_X2%SN_40 x_PM_DFFRS_X2%SN_46 3.9
R_x_PM_DFFRS_X2%SN_r14 x_PM_DFFRS_X2%SN_40 x_PM_DFFRS_X2%SN_38 25.0012
R_x_PM_DFFRS_X2%SN_r15 x_PM_DFFRS_X2%SN_38 x_PM_DFFRS_X2%SN_36 0.176429
R_x_PM_DFFRS_X2%SN_r16 x_PM_DFFRS_X2%SN_32 x_PM_DFFRS_X2%SN_42 5.46
R_x_PM_DFFRS_X2%SN_r17 x_PM_DFFRS_X2%SN_32 x_PM_DFFRS_X2%SN_30 25.0012
R_x_PM_DFFRS_X2%SN_r18 x_PM_DFFRS_X2%SN_34 x_PM_DFFRS_X2%SN_30 0.137586
R_x_PM_DFFRS_X2%SN_r19 x_PM_DFFRS_X2%SN_34 x_PM_DFFRS_X2%SN_27 0.095
R_x_PM_DFFRS_X2%SN_r20 SN x_PM_DFFRS_X2%SN_27 0.352857
R_x_PM_DFFRS_X2%SN_r21 x_PM_DFFRS_X2%SN_36 x_PM_DFFRS_X2%SN_26 0.095
R_x_PM_DFFRS_X2%SN_r22 SN x_PM_DFFRS_X2%SN_26 0.732857
R_x_PM_DFFRS_X2%SN_r23 N_SN_M20_g N_SN_M40_g 130.26
R_x_PM_DFFRS_X2%SN_r24 N_SN_M40_g x_PM_DFFRS_X2%SN_19 26.52
R_x_PM_DFFRS_X2%SN_r25 x_PM_DFFRS_X2%SN_25 x_PM_DFFRS_X2%SN_18 3.30287
R_x_PM_DFFRS_X2%SN_r26 x_PM_DFFRS_X2%SN_19 x_PM_DFFRS_X2%SN_17 4.35808
R_x_PM_DFFRS_X2%SN_r27 x_PM_DFFRS_X2%SN_18 x_PM_DFFRS_X2%SN_17 509.34
R_x_PM_DFFRS_X2%SN_r28 x_PM_DFFRS_X2%SN_46 x_PM_DFFRS_X2%SN_14 1.95
R_x_PM_DFFRS_X2%SN_r29 N_SN_M27_g x_PM_DFFRS_X2%SN_14 34.32
R_x_PM_DFFRS_X2%SN_r30 x_PM_DFFRS_X2%SN_25 x_PM_DFFRS_X2%SN_13 0.858359
R_x_PM_DFFRS_X2%SN_r31 N_SN_M27_g x_PM_DFFRS_X2%SN_13 39
R_x_PM_DFFRS_X2%SN_r32 x_PM_DFFRS_X2%SN_42 x_PM_DFFRS_X2%SN_9 1.95
R_x_PM_DFFRS_X2%SN_r33 N_SN_M5_g x_PM_DFFRS_X2%SN_9 28.86
R_x_PM_DFFRS_X2%SN_r34 x_PM_DFFRS_X2%SN_25 x_PM_DFFRS_X2%SN_7 3.30287
R_x_PM_DFFRS_X2%SN_r35 x_PM_DFFRS_X2%SN_8 x_PM_DFFRS_X2%SN_7 127.92
R_x_PM_DFFRS_X2%SN_r36 N_SN_M2_g N_SN_M24_g 107.25
R_x_PM_DFFRS_X2%SN_r37 x_PM_DFFRS_X2%SN_8 x_PM_DFFRS_X2%SN_VSS 4.35808
R_x_PM_DFFRS_X2%SN_r38 N_SN_M24_g x_PM_DFFRS_X2%SN_VSS 41.34
C_x_PM_DFFRS_X2%9_c0 VSS x_PM_DFFRS_X2%9_39 1.57146e-17
C_x_PM_DFFRS_X2%9_c1 VSS x_PM_DFFRS_X2%9_36 6.60814e-18
C_x_PM_DFFRS_X2%9_c2 VSS x_PM_DFFRS_X2%9_35 1.28777e-17
C_x_PM_DFFRS_X2%9_c3 VSS x_PM_DFFRS_X2%9_32 1.64719e-16
C_x_PM_DFFRS_X2%9_c4 VSS x_PM_DFFRS_X2%9_30 2.07126e-17
C_x_PM_DFFRS_X2%9_c5 VSS x_PM_DFFRS_X2%9_29 4.95027e-18
C_x_PM_DFFRS_X2%9_c6 VSS N_9_M8_d 3.67231e-17
C_x_PM_DFFRS_X2%9_c7 VSS x_PM_DFFRS_X2%9_22 5.08231e-17
C_x_PM_DFFRS_X2%9_c8 VSS N_9_M29_d 4.11702e-17
C_x_PM_DFFRS_X2%9_c9 VSS x_PM_DFFRS_X2%9_18 2.95082e-17
C_x_PM_DFFRS_X2%9_c10 VSS x_PM_DFFRS_X2%9_17 8.93127e-17
C_x_PM_DFFRS_X2%9_c11 VSS N_9_M6_d 2.12751e-17
C_x_PM_DFFRS_X2%9_c12 VSS N_9_M11_g 4.456e-17
C_x_PM_DFFRS_X2%9_c13 VSS N_9_M33_g 6.70149e-17
R_x_PM_DFFRS_X2%9_r14 x_PM_DFFRS_X2%9_39 x_PM_DFFRS_X2%9_37 8.06
R_x_PM_DFFRS_X2%9_r15 x_PM_DFFRS_X2%9_37 x_PM_DFFRS_X2%9_32 25.0012
R_x_PM_DFFRS_X2%9_r16 x_PM_DFFRS_X2%9_32 x_PM_DFFRS_X2%9_30 2.59214
R_x_PM_DFFRS_X2%9_r17 x_PM_DFFRS_X2%9_36 x_PM_DFFRS_X2%9_29 0.115915
R_x_PM_DFFRS_X2%9_r18 x_PM_DFFRS_X2%9_30 x_PM_DFFRS_X2%9_28 0.212317
R_x_PM_DFFRS_X2%9_r19 x_PM_DFFRS_X2%9_29 x_PM_DFFRS_X2%9_28 0.352857
R_x_PM_DFFRS_X2%9_r20 x_PM_DFFRS_X2%9_36 x_PM_DFFRS_X2%9_24 0.115915
R_x_PM_DFFRS_X2%9_r21 N_9_M8_d x_PM_DFFRS_X2%9_24 0.344815
R_x_PM_DFFRS_X2%9_r22 x_PM_DFFRS_X2%9_35 x_PM_DFFRS_X2%9_23 0.0418175
R_x_PM_DFFRS_X2%9_r23 x_PM_DFFRS_X2%9_36 x_PM_DFFRS_X2%9_22 0.0855182
R_x_PM_DFFRS_X2%9_r24 x_PM_DFFRS_X2%9_23 x_PM_DFFRS_X2%9_22 2.11714
R_x_PM_DFFRS_X2%9_r25 N_9_M29_d x_PM_DFFRS_X2%9_18 1.26214
R_x_PM_DFFRS_X2%9_r26 x_PM_DFFRS_X2%9_35 x_PM_DFFRS_X2%9_17 0.160909
R_x_PM_DFFRS_X2%9_r27 x_PM_DFFRS_X2%9_18 x_PM_DFFRS_X2%9_16 0.212317
R_x_PM_DFFRS_X2%9_r28 x_PM_DFFRS_X2%9_17 x_PM_DFFRS_X2%9_16 2.47
R_x_PM_DFFRS_X2%9_r29 x_PM_DFFRS_X2%9_35 x_PM_DFFRS_X2%9_12 0.160909
R_x_PM_DFFRS_X2%9_r30 N_9_M6_d x_PM_DFFRS_X2%9_12 0.393571
R_x_PM_DFFRS_X2%9_r31 x_PM_DFFRS_X2%9_39 x_PM_DFFRS_X2%9_5 1.95
R_x_PM_DFFRS_X2%9_r32 N_9_M11_g x_PM_DFFRS_X2%9_5 28.86
R_x_PM_DFFRS_X2%9_r33 x_PM_DFFRS_X2%9_39 x_PM_DFFRS_X2%9_VSS 1.95
R_x_PM_DFFRS_X2%9_r34 N_9_M33_g x_PM_DFFRS_X2%9_VSS 55.38
C_x_PM_DFFRS_X2%10_c0 VSS x_PM_DFFRS_X2%10_53 1.62465e-17
C_x_PM_DFFRS_X2%10_c1 VSS x_PM_DFFRS_X2%10_47 5.11431e-17
C_x_PM_DFFRS_X2%10_c2 VSS N_10_M11_d 7.90175e-17
C_x_PM_DFFRS_X2%10_c3 VSS x_PM_DFFRS_X2%10_41 3.73052e-17
C_x_PM_DFFRS_X2%10_c4 VSS x_PM_DFFRS_X2%10_35 1.99818e-16
C_x_PM_DFFRS_X2%10_c5 VSS N_10_M33_s 5.38527e-17
C_x_PM_DFFRS_X2%10_c6 VSS x_PM_DFFRS_X2%10_32 6.1869e-18
C_x_PM_DFFRS_X2%10_c7 VSS x_PM_DFFRS_X2%10_31 3.66914e-18
C_x_PM_DFFRS_X2%10_c8 VSS N_10_M7_g 4.68478e-17
C_x_PM_DFFRS_X2%10_c9 VSS x_PM_DFFRS_X2%10_27 5.24645e-18
C_x_PM_DFFRS_X2%10_c10 VSS x_PM_DFFRS_X2%10_25 2.02988e-17
C_x_PM_DFFRS_X2%10_c11 VSS N_10_M28_g 5.56293e-17
C_x_PM_DFFRS_X2%10_c12 VSS x_PM_DFFRS_X2%10_19 8.93937e-17
C_x_PM_DFFRS_X2%10_c13 VSS N_10_M25_g 7.07147e-17
C_x_PM_DFFRS_X2%10_c14 VSS x_PM_DFFRS_X2%10_14 8.96697e-18
C_x_PM_DFFRS_X2%10_c15 VSS x_PM_DFFRS_X2%10_13 1.22474e-17
C_x_PM_DFFRS_X2%10_c16 VSS N_10_M3_g 4.9074e-17
C_x_PM_DFFRS_X2%10_c17 VSS x_PM_DFFRS_X2%10_8 7.06504e-18
C_x_PM_DFFRS_X2%10_c18 VSS x_PM_DFFRS_X2%10_7 4.3468e-17
C_x_PM_DFFRS_X2%10_c19 VSS N_10_M23_g 1.05054e-16
R_x_PM_DFFRS_X2%10_r20 x_PM_DFFRS_X2%10_51 x_PM_DFFRS_X2%10_49 25.0012
R_x_PM_DFFRS_X2%10_r21 x_PM_DFFRS_X2%10_49 x_PM_DFFRS_X2%10_47 0.274444
R_x_PM_DFFRS_X2%10_r22 N_10_M11_d x_PM_DFFRS_X2%10_43 1.20786
R_x_PM_DFFRS_X2%10_r23 x_PM_DFFRS_X2%10_53 x_PM_DFFRS_X2%10_42 0.160909
R_x_PM_DFFRS_X2%10_r24 x_PM_DFFRS_X2%10_43 x_PM_DFFRS_X2%10_41 0.212317
R_x_PM_DFFRS_X2%10_r25 x_PM_DFFRS_X2%10_42 x_PM_DFFRS_X2%10_41 0.624286
R_x_PM_DFFRS_X2%10_r26 x_PM_DFFRS_X2%10_53 x_PM_DFFRS_X2%10_37 0.0418175
R_x_PM_DFFRS_X2%10_r27 x_PM_DFFRS_X2%10_47 x_PM_DFFRS_X2%10_36 0.095
R_x_PM_DFFRS_X2%10_r28 x_PM_DFFRS_X2%10_53 x_PM_DFFRS_X2%10_35 0.160909
R_x_PM_DFFRS_X2%10_r29 x_PM_DFFRS_X2%10_36 x_PM_DFFRS_X2%10_35 3.96286
R_x_PM_DFFRS_X2%10_r30 N_10_M33_s x_PM_DFFRS_X2%10_37 0.692143
R_x_PM_DFFRS_X2%10_r31 x_PM_DFFRS_X2%10_51 x_PM_DFFRS_X2%10_27 4.00022
R_x_PM_DFFRS_X2%10_r32 N_10_M7_g x_PM_DFFRS_X2%10_27 46.02
R_x_PM_DFFRS_X2%10_r33 x_PM_DFFRS_X2%10_32 x_PM_DFFRS_X2%10_26 2.19884
R_x_PM_DFFRS_X2%10_r34 x_PM_DFFRS_X2%10_51 x_PM_DFFRS_X2%10_25 0.666704
R_x_PM_DFFRS_X2%10_r35 x_PM_DFFRS_X2%10_26 x_PM_DFFRS_X2%10_25 18.525
R_x_PM_DFFRS_X2%10_r36 x_PM_DFFRS_X2%10_32 x_PM_DFFRS_X2%10_21 1.96807
R_x_PM_DFFRS_X2%10_r37 N_10_M28_g x_PM_DFFRS_X2%10_21 57.72
R_x_PM_DFFRS_X2%10_r38 x_PM_DFFRS_X2%10_31 x_PM_DFFRS_X2%10_20 2.19884
R_x_PM_DFFRS_X2%10_r39 x_PM_DFFRS_X2%10_32 x_PM_DFFRS_X2%10_19 2.19884
R_x_PM_DFFRS_X2%10_r40 x_PM_DFFRS_X2%10_20 x_PM_DFFRS_X2%10_19 65.325
R_x_PM_DFFRS_X2%10_r41 x_PM_DFFRS_X2%10_31 x_PM_DFFRS_X2%10_15 1.96807
R_x_PM_DFFRS_X2%10_r42 N_10_M25_g x_PM_DFFRS_X2%10_15 63.18
R_x_PM_DFFRS_X2%10_r43 x_PM_DFFRS_X2%10_31 x_PM_DFFRS_X2%10_13 2.19884
R_x_PM_DFFRS_X2%10_r44 x_PM_DFFRS_X2%10_14 x_PM_DFFRS_X2%10_13 9.75
R_x_PM_DFFRS_X2%10_r45 N_10_M3_g x_PM_DFFRS_X2%10_10 40.56
R_x_PM_DFFRS_X2%10_r46 x_PM_DFFRS_X2%10_14 x_PM_DFFRS_X2%10_9 4.66692
R_x_PM_DFFRS_X2%10_r47 N_10_M3_g x_PM_DFFRS_X2%10_9 28.86
R_x_PM_DFFRS_X2%10_r48 x_PM_DFFRS_X2%10_10 x_PM_DFFRS_X2%10_7 4.35808
R_x_PM_DFFRS_X2%10_r49 x_PM_DFFRS_X2%10_8 x_PM_DFFRS_X2%10_7 51.48
R_x_PM_DFFRS_X2%10_r50 N_10_M1_g N_10_M23_g 107.25
R_x_PM_DFFRS_X2%10_r51 x_PM_DFFRS_X2%10_8 x_PM_DFFRS_X2%10_VSS 4.35808
R_x_PM_DFFRS_X2%10_r52 N_10_M1_g x_PM_DFFRS_X2%10_VSS 30.03
C_x_PM_DFFRS_X2%11_c0 VSS x_PM_DFFRS_X2%11_75 1.17359e-17
C_x_PM_DFFRS_X2%11_c1 VSS x_PM_DFFRS_X2%11_69 1.01738e-17
C_x_PM_DFFRS_X2%11_c2 VSS x_PM_DFFRS_X2%11_67 4.06703e-17
C_x_PM_DFFRS_X2%11_c3 VSS x_PM_DFFRS_X2%11_64 1.7794e-17
C_x_PM_DFFRS_X2%11_c4 VSS x_PM_DFFRS_X2%11_62 6.0969e-17
C_x_PM_DFFRS_X2%11_c5 VSS x_PM_DFFRS_X2%11_57 2.67461e-17
C_x_PM_DFFRS_X2%11_c6 VSS x_PM_DFFRS_X2%11_55 3.48182e-17
C_x_PM_DFFRS_X2%11_c7 VSS x_PM_DFFRS_X2%11_54 1.22483e-16
C_x_PM_DFFRS_X2%11_c8 VSS x_PM_DFFRS_X2%11_53 4.40231e-17
C_x_PM_DFFRS_X2%11_c9 VSS x_PM_DFFRS_X2%11_51 8.79261e-17
C_x_PM_DFFRS_X2%11_c10 VSS x_PM_DFFRS_X2%11_49 2.42802e-17
C_x_PM_DFFRS_X2%11_c11 VSS x_PM_DFFRS_X2%11_48 4.98818e-17
C_x_PM_DFFRS_X2%11_c12 VSS x_PM_DFFRS_X2%11_47 3.5873e-17
C_x_PM_DFFRS_X2%11_c13 VSS x_PM_DFFRS_X2%11_45 3.08994e-17
C_x_PM_DFFRS_X2%11_c14 VSS x_PM_DFFRS_X2%11_44 1.30484e-16
C_x_PM_DFFRS_X2%11_c15 VSS N_11_M13_d 1.07526e-16
C_x_PM_DFFRS_X2%11_c16 VSS x_PM_DFFRS_X2%11_39 2.91942e-17
C_x_PM_DFFRS_X2%11_c17 VSS x_PM_DFFRS_X2%11_38 9.68589e-17
C_x_PM_DFFRS_X2%11_c18 VSS x_PM_DFFRS_X2%11_37 9.48579e-18
C_x_PM_DFFRS_X2%11_c19 VSS x_PM_DFFRS_X2%11_35 1.76571e-17
C_x_PM_DFFRS_X2%11_c20 VSS x_PM_DFFRS_X2%11_34 3.95821e-17
C_x_PM_DFFRS_X2%11_c21 VSS N_11_M32_d 1.88781e-17
C_x_PM_DFFRS_X2%11_c22 VSS x_PM_DFFRS_X2%11_28 1.43028e-17
C_x_PM_DFFRS_X2%11_c23 VSS x_PM_DFFRS_X2%11_25 1.40573e-16
C_x_PM_DFFRS_X2%11_c24 VSS N_11_M19_g 4.40965e-17
C_x_PM_DFFRS_X2%11_c25 VSS N_11_M37_g 2.3209e-17
C_x_PM_DFFRS_X2%11_c26 VSS N_11_M8_g 7.78813e-17
C_x_PM_DFFRS_X2%11_c27 VSS N_11_M30_g 2.04808e-17
C_x_PM_DFFRS_X2%11_c28 VSS x_PM_DFFRS_X2%11_6 6.58621e-18
C_x_PM_DFFRS_X2%11_c29 VSS x_PM_DFFRS_X2%11_5 6.33477e-17
C_x_PM_DFFRS_X2%11_c30 VSS N_11_M6_g 4.15564e-17
R_x_PM_DFFRS_X2%11_r31 x_PM_DFFRS_X2%11_80 x_PM_DFFRS_X2%11_69 4.7687
R_x_PM_DFFRS_X2%11_r32 x_PM_DFFRS_X2%11_69 x_PM_DFFRS_X2%11_67 25.0012
R_x_PM_DFFRS_X2%11_r33 x_PM_DFFRS_X2%11_67 x_PM_DFFRS_X2%11_65 0.161852
R_x_PM_DFFRS_X2%11_r34 x_PM_DFFRS_X2%11_62 x_PM_DFFRS_X2%11_59 0.312143
R_x_PM_DFFRS_X2%11_r35 x_PM_DFFRS_X2%11_75 x_PM_DFFRS_X2%11_59 25.0012
R_x_PM_DFFRS_X2%11_r36 x_PM_DFFRS_X2%11_65 x_PM_DFFRS_X2%11_56 0.095
R_x_PM_DFFRS_X2%11_r37 x_PM_DFFRS_X2%11_57 x_PM_DFFRS_X2%11_56 1.71
R_x_PM_DFFRS_X2%11_r38 x_PM_DFFRS_X2%11_57 x_PM_DFFRS_X2%11_54 0.212317
R_x_PM_DFFRS_X2%11_r39 x_PM_DFFRS_X2%11_55 x_PM_DFFRS_X2%11_54 2.19857
R_x_PM_DFFRS_X2%11_r40 x_PM_DFFRS_X2%11_55 x_PM_DFFRS_X2%11_53 0.212317
R_x_PM_DFFRS_X2%11_r41 x_PM_DFFRS_X2%11_64 x_PM_DFFRS_X2%11_52 0.160909
R_x_PM_DFFRS_X2%11_r42 x_PM_DFFRS_X2%11_53 x_PM_DFFRS_X2%11_52 1.19429
R_x_PM_DFFRS_X2%11_r43 x_PM_DFFRS_X2%11_64 x_PM_DFFRS_X2%11_51 0.160909
R_x_PM_DFFRS_X2%11_r44 x_PM_DFFRS_X2%11_62 x_PM_DFFRS_X2%11_50 0.095
R_x_PM_DFFRS_X2%11_r45 x_PM_DFFRS_X2%11_51 x_PM_DFFRS_X2%11_50 1.98143
R_x_PM_DFFRS_X2%11_r46 x_PM_DFFRS_X2%11_64 x_PM_DFFRS_X2%11_48 0.0418175
R_x_PM_DFFRS_X2%11_r47 x_PM_DFFRS_X2%11_49 x_PM_DFFRS_X2%11_48 1.24857
R_x_PM_DFFRS_X2%11_r48 x_PM_DFFRS_X2%11_49 x_PM_DFFRS_X2%11_46 0.212317
R_x_PM_DFFRS_X2%11_r49 x_PM_DFFRS_X2%11_47 x_PM_DFFRS_X2%11_46 1.27571
R_x_PM_DFFRS_X2%11_r50 x_PM_DFFRS_X2%11_47 x_PM_DFFRS_X2%11_44 0.212317
R_x_PM_DFFRS_X2%11_r51 x_PM_DFFRS_X2%11_45 x_PM_DFFRS_X2%11_44 1.76429
R_x_PM_DFFRS_X2%11_r52 x_PM_DFFRS_X2%11_45 x_PM_DFFRS_X2%11_41 0.212317
R_x_PM_DFFRS_X2%11_r53 N_11_M13_d x_PM_DFFRS_X2%11_41 0.990714
R_x_PM_DFFRS_X2%11_r54 N_11_M13_d x_PM_DFFRS_X2%11_40 2.64643
R_x_PM_DFFRS_X2%11_r55 x_PM_DFFRS_X2%11_40 x_PM_DFFRS_X2%11_38 0.212317
R_x_PM_DFFRS_X2%11_r56 x_PM_DFFRS_X2%11_39 x_PM_DFFRS_X2%11_38 2.36143
R_x_PM_DFFRS_X2%11_r57 x_PM_DFFRS_X2%11_39 x_PM_DFFRS_X2%11_37 0.212317
R_x_PM_DFFRS_X2%11_r58 x_PM_DFFRS_X2%11_37 x_PM_DFFRS_X2%11_36 0.461429
R_x_PM_DFFRS_X2%11_r59 x_PM_DFFRS_X2%11_36 x_PM_DFFRS_X2%11_34 0.212317
R_x_PM_DFFRS_X2%11_r60 x_PM_DFFRS_X2%11_35 x_PM_DFFRS_X2%11_34 1.19429
R_x_PM_DFFRS_X2%11_r61 N_11_M32_d x_PM_DFFRS_X2%11_31 0.665
R_x_PM_DFFRS_X2%11_r62 x_PM_DFFRS_X2%11_35 x_PM_DFFRS_X2%11_30 0.212317
R_x_PM_DFFRS_X2%11_r63 N_11_M32_d x_PM_DFFRS_X2%11_30 0.0135714
R_x_PM_DFFRS_X2%11_r64 x_PM_DFFRS_X2%11_28 x_PM_DFFRS_X2%11_71 5.46
R_x_PM_DFFRS_X2%11_r65 x_PM_DFFRS_X2%11_28 x_PM_DFFRS_X2%11_26 25.0012
R_x_PM_DFFRS_X2%11_r66 x_PM_DFFRS_X2%11_31 x_PM_DFFRS_X2%11_25 0.212317
R_x_PM_DFFRS_X2%11_r67 x_PM_DFFRS_X2%11_26 x_PM_DFFRS_X2%11_25 2.07643
R_x_PM_DFFRS_X2%11_r68 N_11_M19_g x_PM_DFFRS_X2%11_80 35.88
R_x_PM_DFFRS_X2%11_r69 x_PM_DFFRS_X2%11_15 x_PM_DFFRS_X2%11_75 4.7687
R_x_PM_DFFRS_X2%11_r70 N_11_M37_g x_PM_DFFRS_X2%11_15 15.6
R_x_PM_DFFRS_X2%11_r71 N_11_M8_g x_PM_DFFRS_X2%11_12 35.1
R_x_PM_DFFRS_X2%11_r72 x_PM_DFFRS_X2%11_71 x_PM_DFFRS_X2%11_11 1.95
R_x_PM_DFFRS_X2%11_r73 N_11_M8_g x_PM_DFFRS_X2%11_11 82.68
R_x_PM_DFFRS_X2%11_r74 x_PM_DFFRS_X2%11_71 x_PM_DFFRS_X2%11_7 1.95
R_x_PM_DFFRS_X2%11_r75 N_11_M30_g x_PM_DFFRS_X2%11_7 14.82
R_x_PM_DFFRS_X2%11_r76 x_PM_DFFRS_X2%11_12 x_PM_DFFRS_X2%11_5 4.35808
R_x_PM_DFFRS_X2%11_r77 x_PM_DFFRS_X2%11_6 x_PM_DFFRS_X2%11_5 74.88
R_x_PM_DFFRS_X2%11_r78 x_PM_DFFRS_X2%11_6 x_PM_DFFRS_X2%11_VSS 4.35808
R_x_PM_DFFRS_X2%11_r79 N_11_M6_g x_PM_DFFRS_X2%11_VSS 28.86
C_x_PM_DFFRS_X2%12_c0 VSS x_PM_DFFRS_X2%12_75 1.02234e-17
C_x_PM_DFFRS_X2%12_c1 VSS x_PM_DFFRS_X2%12_67 2.1839e-17
C_x_PM_DFFRS_X2%12_c2 VSS x_PM_DFFRS_X2%12_65 4.02161e-17
C_x_PM_DFFRS_X2%12_c3 VSS x_PM_DFFRS_X2%12_59 3.15561e-17
C_x_PM_DFFRS_X2%12_c4 VSS N_12_M17_d 2.97662e-17
C_x_PM_DFFRS_X2%12_c5 VSS x_PM_DFFRS_X2%12_53 2.17199e-17
C_x_PM_DFFRS_X2%12_c6 VSS x_PM_DFFRS_X2%12_51 1.70506e-16
C_x_PM_DFFRS_X2%12_c7 VSS x_PM_DFFRS_X2%12_50 1.22212e-16
C_x_PM_DFFRS_X2%12_c8 VSS x_PM_DFFRS_X2%12_48 1.85421e-17
C_x_PM_DFFRS_X2%12_c9 VSS x_PM_DFFRS_X2%12_44 1.90235e-17
C_x_PM_DFFRS_X2%12_c10 VSS x_PM_DFFRS_X2%12_43 1.70639e-16
C_x_PM_DFFRS_X2%12_c11 VSS x_PM_DFFRS_X2%12_42 5.58642e-17
C_x_PM_DFFRS_X2%12_c12 VSS x_PM_DFFRS_X2%12_40 9.44191e-17
C_x_PM_DFFRS_X2%12_c13 VSS x_PM_DFFRS_X2%12_35 4.50599e-17
C_x_PM_DFFRS_X2%12_c14 VSS x_PM_DFFRS_X2%12_33 2.08688e-17
C_x_PM_DFFRS_X2%12_c15 VSS x_PM_DFFRS_X2%12_32 3.79534e-17
C_x_PM_DFFRS_X2%12_c16 VSS x_PM_DFFRS_X2%12_30 2.12221e-17
C_x_PM_DFFRS_X2%12_c17 VSS x_PM_DFFRS_X2%12_29 5.89066e-17
C_x_PM_DFFRS_X2%12_c18 VSS x_PM_DFFRS_X2%12_28 3.82032e-18
C_x_PM_DFFRS_X2%12_c19 VSS x_PM_DFFRS_X2%12_26 2.00526e-17
C_x_PM_DFFRS_X2%12_c20 VSS x_PM_DFFRS_X2%12_25 7.54156e-17
C_x_PM_DFFRS_X2%12_c21 VSS x_PM_DFFRS_X2%12_24 3.82849e-17
C_x_PM_DFFRS_X2%12_c22 VSS x_PM_DFFRS_X2%12_21 1.26476e-17
C_x_PM_DFFRS_X2%12_c23 VSS x_PM_DFFRS_X2%12_18 7.9781e-17
C_x_PM_DFFRS_X2%12_c24 VSS N_12_M21_g 5.2064e-17
C_x_PM_DFFRS_X2%12_c25 VSS N_12_M41_g 4.43223e-17
C_x_PM_DFFRS_X2%12_c26 VSS N_12_M31_g 9.58696e-17
R_x_PM_DFFRS_X2%12_r27 x_PM_DFFRS_X2%12_77 x_PM_DFFRS_X2%12_75 4.7687
R_x_PM_DFFRS_X2%12_r28 x_PM_DFFRS_X2%12_65 N_12_M14_s 0.176429
R_x_PM_DFFRS_X2%12_r29 x_PM_DFFRS_X2%12_75 x_PM_DFFRS_X2%12_59 25.0012
R_x_PM_DFFRS_X2%12_r30 x_PM_DFFRS_X2%12_59 x_PM_DFFRS_X2%12_57 0.149286
R_x_PM_DFFRS_X2%12_r31 N_12_M17_d x_PM_DFFRS_X2%12_53 0.482308
R_x_PM_DFFRS_X2%12_r32 x_PM_DFFRS_X2%12_67 x_PM_DFFRS_X2%12_52 0.0418175
R_x_PM_DFFRS_X2%12_r33 x_PM_DFFRS_X2%12_57 x_PM_DFFRS_X2%12_51 0.212317
R_x_PM_DFFRS_X2%12_r34 x_PM_DFFRS_X2%12_52 x_PM_DFFRS_X2%12_51 3.82714
R_x_PM_DFFRS_X2%12_r35 x_PM_DFFRS_X2%12_53 x_PM_DFFRS_X2%12_50 0.212696
R_x_PM_DFFRS_X2%12_r36 x_PM_DFFRS_X2%12_67 x_PM_DFFRS_X2%12_49 0.160909
R_x_PM_DFFRS_X2%12_r37 x_PM_DFFRS_X2%12_50 x_PM_DFFRS_X2%12_49 2.06286
R_x_PM_DFFRS_X2%12_r38 x_PM_DFFRS_X2%12_67 x_PM_DFFRS_X2%12_48 0.160909
R_x_PM_DFFRS_X2%12_r39 x_PM_DFFRS_X2%12_48 x_PM_DFFRS_X2%12_47 0.651429
R_x_PM_DFFRS_X2%12_r40 N_12_M37_d x_PM_DFFRS_X2%12_44 2.64643
R_x_PM_DFFRS_X2%12_r41 x_PM_DFFRS_X2%12_47 x_PM_DFFRS_X2%12_43 0.212317
R_x_PM_DFFRS_X2%12_r42 N_12_M37_d x_PM_DFFRS_X2%12_43 0.285
R_x_PM_DFFRS_X2%12_r43 x_PM_DFFRS_X2%12_42 x_PM_DFFRS_X2%12_68 40.04
R_x_PM_DFFRS_X2%12_r44 x_PM_DFFRS_X2%12_42 x_PM_DFFRS_X2%12_40 25.0012
R_x_PM_DFFRS_X2%12_r45 x_PM_DFFRS_X2%12_65 x_PM_DFFRS_X2%12_39 0.095
R_x_PM_DFFRS_X2%12_r46 x_PM_DFFRS_X2%12_40 x_PM_DFFRS_X2%12_39 1.235
R_x_PM_DFFRS_X2%12_r47 x_PM_DFFRS_X2%12_44 x_PM_DFFRS_X2%12_38 0.212317
R_x_PM_DFFRS_X2%12_r48 x_PM_DFFRS_X2%12_40 x_PM_DFFRS_X2%12_38 2.32071
R_x_PM_DFFRS_X2%12_r49 x_PM_DFFRS_X2%12_68 x_PM_DFFRS_X2%12_35 25.0012
R_x_PM_DFFRS_X2%12_r50 x_PM_DFFRS_X2%12_35 x_PM_DFFRS_X2%12_33 0.637857
R_x_PM_DFFRS_X2%12_r51 x_PM_DFFRS_X2%12_33 x_PM_DFFRS_X2%12_31 0.212317
R_x_PM_DFFRS_X2%12_r52 x_PM_DFFRS_X2%12_32 x_PM_DFFRS_X2%12_31 1.11286
R_x_PM_DFFRS_X2%12_r53 x_PM_DFFRS_X2%12_32 x_PM_DFFRS_X2%12_29 0.212317
R_x_PM_DFFRS_X2%12_r54 x_PM_DFFRS_X2%12_30 x_PM_DFFRS_X2%12_29 1.46571
R_x_PM_DFFRS_X2%12_r55 x_PM_DFFRS_X2%12_30 x_PM_DFFRS_X2%12_28 0.212317
R_x_PM_DFFRS_X2%12_r56 x_PM_DFFRS_X2%12_28 x_PM_DFFRS_X2%12_27 0.38
R_x_PM_DFFRS_X2%12_r57 x_PM_DFFRS_X2%12_27 x_PM_DFFRS_X2%12_25 0.212317
R_x_PM_DFFRS_X2%12_r58 x_PM_DFFRS_X2%12_26 x_PM_DFFRS_X2%12_25 1.08571
R_x_PM_DFFRS_X2%12_r59 x_PM_DFFRS_X2%12_26 x_PM_DFFRS_X2%12_23 0.212317
R_x_PM_DFFRS_X2%12_r60 x_PM_DFFRS_X2%12_24 x_PM_DFFRS_X2%12_23 1.14
R_x_PM_DFFRS_X2%12_r61 x_PM_DFFRS_X2%12_73 x_PM_DFFRS_X2%12_21 4.7687
R_x_PM_DFFRS_X2%12_r62 x_PM_DFFRS_X2%12_21 x_PM_DFFRS_X2%12_19 25.0012
R_x_PM_DFFRS_X2%12_r63 x_PM_DFFRS_X2%12_24 x_PM_DFFRS_X2%12_18 0.212317
R_x_PM_DFFRS_X2%12_r64 x_PM_DFFRS_X2%12_19 x_PM_DFFRS_X2%12_18 0.665
R_x_PM_DFFRS_X2%12_r65 N_12_M21_g x_PM_DFFRS_X2%12_77 59.28
R_x_PM_DFFRS_X2%12_r66 x_PM_DFFRS_X2%12_7 x_PM_DFFRS_X2%12_75 4.7687
R_x_PM_DFFRS_X2%12_r67 N_12_M41_g x_PM_DFFRS_X2%12_7 45.24
R_x_PM_DFFRS_X2%12_r68 N_12_M9_g x_PM_DFFRS_X2%12_73 28.86
R_x_PM_DFFRS_X2%12_r69 N_12_M9_g N_12_M31_g 95.16
C_x_PM_DFFRS_X2%RN_c0 VSS RN 7.49722e-17
C_x_PM_DFFRS_X2%RN_c1 VSS x_PM_DFFRS_X2%RN_22 6.11206e-18
C_x_PM_DFFRS_X2%RN_c2 VSS x_PM_DFFRS_X2%RN_21 6.0669e-17
C_x_PM_DFFRS_X2%RN_c3 VSS x_PM_DFFRS_X2%RN_20 4.91887e-18
C_x_PM_DFFRS_X2%RN_c4 VSS N_RN_M16_g 6.19119e-17
C_x_PM_DFFRS_X2%RN_c5 VSS x_PM_DFFRS_X2%RN_13 5.74703e-17
C_x_PM_DFFRS_X2%RN_c6 VSS N_RN_M35_g 4.64496e-17
C_x_PM_DFFRS_X2%RN_c7 VSS N_RN_M12_g 6.07115e-17
C_x_PM_DFFRS_X2%RN_c8 VSS N_RN_M34_g 4.4035e-17
R_x_PM_DFFRS_X2%RN_r9 x_PM_DFFRS_X2%RN_25 x_PM_DFFRS_X2%RN_23 25.0012
R_x_PM_DFFRS_X2%RN_r10 RN x_PM_DFFRS_X2%RN_23 0.0271429
R_x_PM_DFFRS_X2%RN_r11 x_PM_DFFRS_X2%RN_25 x_PM_DFFRS_X2%RN_21 38.2687
R_x_PM_DFFRS_X2%RN_r12 x_PM_DFFRS_X2%RN_22 x_PM_DFFRS_X2%RN_21 2.19884
R_x_PM_DFFRS_X2%RN_r13 x_PM_DFFRS_X2%RN_25 x_PM_DFFRS_X2%RN_19 14.8687
R_x_PM_DFFRS_X2%RN_r14 x_PM_DFFRS_X2%RN_20 x_PM_DFFRS_X2%RN_19 0.179698
R_x_PM_DFFRS_X2%RN_r15 N_RN_M16_g x_PM_DFFRS_X2%RN_15 45.63
R_x_PM_DFFRS_X2%RN_r16 x_PM_DFFRS_X2%RN_22 x_PM_DFFRS_X2%RN_14 2.19884
R_x_PM_DFFRS_X2%RN_r17 x_PM_DFFRS_X2%RN_15 x_PM_DFFRS_X2%RN_13 4.66692
R_x_PM_DFFRS_X2%RN_r18 x_PM_DFFRS_X2%RN_14 x_PM_DFFRS_X2%RN_13 36.075
R_x_PM_DFFRS_X2%RN_r19 x_PM_DFFRS_X2%RN_22 x_PM_DFFRS_X2%RN_9 1.96807
R_x_PM_DFFRS_X2%RN_r20 N_RN_M35_g x_PM_DFFRS_X2%RN_9 39
R_x_PM_DFFRS_X2%RN_r21 x_PM_DFFRS_X2%RN_20 x_PM_DFFRS_X2%RN_5 4.78783
R_x_PM_DFFRS_X2%RN_r22 N_RN_M12_g x_PM_DFFRS_X2%RN_5 53.04
R_x_PM_DFFRS_X2%RN_r23 x_PM_DFFRS_X2%RN_20 x_PM_DFFRS_X2%RN_VSS 4.78783
R_x_PM_DFFRS_X2%RN_r24 N_RN_M34_g x_PM_DFFRS_X2%RN_VSS 30.42
C_x_PM_DFFRS_X2%14_c0 VSS x_PM_DFFRS_X2%14_47 1.37919e-17
C_x_PM_DFFRS_X2%14_c1 VSS x_PM_DFFRS_X2%14_43 1.30487e-17
C_x_PM_DFFRS_X2%14_c2 VSS x_PM_DFFRS_X2%14_40 2.68055e-18
C_x_PM_DFFRS_X2%14_c3 VSS x_PM_DFFRS_X2%14_39 3.72572e-17
C_x_PM_DFFRS_X2%14_c4 VSS x_PM_DFFRS_X2%14_33 9.57589e-18
C_x_PM_DFFRS_X2%14_c5 VSS x_PM_DFFRS_X2%14_32 2.84293e-17
C_x_PM_DFFRS_X2%14_c6 VSS N_14_M20_d 3.61958e-17
C_x_PM_DFFRS_X2%14_c7 VSS x_PM_DFFRS_X2%14_27 2.48193e-17
C_x_PM_DFFRS_X2%14_c8 VSS x_PM_DFFRS_X2%14_26 1.41775e-16
C_x_PM_DFFRS_X2%14_c9 VSS x_PM_DFFRS_X2%14_25 1.9562e-17
C_x_PM_DFFRS_X2%14_c10 VSS x_PM_DFFRS_X2%14_22 1.02359e-17
C_x_PM_DFFRS_X2%14_c11 VSS x_PM_DFFRS_X2%14_19 2.01802e-16
C_x_PM_DFFRS_X2%14_c12 VSS x_PM_DFFRS_X2%14_12 1.37351e-16
C_x_PM_DFFRS_X2%14_c13 VSS N_14_M41_d 2.2335e-17
C_x_PM_DFFRS_X2%14_c14 VSS N_14_M15_g 4.01968e-17
C_x_PM_DFFRS_X2%14_c15 VSS N_14_M36_g 2.11291e-17
R_x_PM_DFFRS_X2%14_r16 x_PM_DFFRS_X2%14_43 x_PM_DFFRS_X2%14_41 2.34
R_x_PM_DFFRS_X2%14_r17 x_PM_DFFRS_X2%14_40 x_PM_DFFRS_X2%14_38 0.140052
R_x_PM_DFFRS_X2%14_r18 x_PM_DFFRS_X2%14_39 x_PM_DFFRS_X2%14_38 1.62857
R_x_PM_DFFRS_X2%14_r19 x_PM_DFFRS_X2%14_40 x_PM_DFFRS_X2%14_34 0.140052
R_x_PM_DFFRS_X2%14_r20 x_PM_DFFRS_X2%14_39 x_PM_DFFRS_X2%14_32 0.212317
R_x_PM_DFFRS_X2%14_r21 x_PM_DFFRS_X2%14_33 x_PM_DFFRS_X2%14_32 0.76
R_x_PM_DFFRS_X2%14_r22 x_PM_DFFRS_X2%14_33 x_PM_DFFRS_X2%14_28 0.212317
R_x_PM_DFFRS_X2%14_r23 N_14_M20_d x_PM_DFFRS_X2%14_28 1.12643
R_x_PM_DFFRS_X2%14_r24 x_PM_DFFRS_X2%14_40 x_PM_DFFRS_X2%14_26 0.0604376
R_x_PM_DFFRS_X2%14_r25 x_PM_DFFRS_X2%14_27 x_PM_DFFRS_X2%14_26 3.20286
R_x_PM_DFFRS_X2%14_r26 x_PM_DFFRS_X2%14_27 x_PM_DFFRS_X2%14_25 0.212317
R_x_PM_DFFRS_X2%14_r27 x_PM_DFFRS_X2%14_25 x_PM_DFFRS_X2%14_24 0.624286
R_x_PM_DFFRS_X2%14_r28 x_PM_DFFRS_X2%14_51 x_PM_DFFRS_X2%14_22 4.7687
R_x_PM_DFFRS_X2%14_r29 x_PM_DFFRS_X2%14_22 x_PM_DFFRS_X2%14_20 25.0012
R_x_PM_DFFRS_X2%14_r30 x_PM_DFFRS_X2%14_24 x_PM_DFFRS_X2%14_19 0.212317
R_x_PM_DFFRS_X2%14_r31 x_PM_DFFRS_X2%14_20 x_PM_DFFRS_X2%14_19 2.97214
R_x_PM_DFFRS_X2%14_r32 x_PM_DFFRS_X2%14_47 x_PM_DFFRS_X2%14_17 3.38
R_x_PM_DFFRS_X2%14_r33 x_PM_DFFRS_X2%14_17 x_PM_DFFRS_X2%14_15 25.0012
R_x_PM_DFFRS_X2%14_r34 x_PM_DFFRS_X2%14_15 x_PM_DFFRS_X2%14_12 0.858519
R_x_PM_DFFRS_X2%14_r35 x_PM_DFFRS_X2%14_41 x_PM_DFFRS_X2%14_12 25.0012
R_x_PM_DFFRS_X2%14_r36 N_14_M41_d x_PM_DFFRS_X2%14_34 0.33
R_x_PM_DFFRS_X2%14_r37 x_PM_DFFRS_X2%14_47 x_PM_DFFRS_X2%14_5 1.95
R_x_PM_DFFRS_X2%14_r38 N_14_M15_g x_PM_DFFRS_X2%14_5 39.78
R_x_PM_DFFRS_X2%14_r39 N_14_M36_g x_PM_DFFRS_X2%14_51 14.82
R_x_PM_DFFRS_X2%14_r40 x_PM_DFFRS_X2%14_43 x_PM_DFFRS_X2%14_2 1.95
R_x_PM_DFFRS_X2%14_r41 N_14_M36_g x_PM_DFFRS_X2%14_2 15.6
C_x_PM_DFFRS_X2%D_c0 VSS x_PM_DFFRS_X2%D_14 9.14127e-18
C_x_PM_DFFRS_X2%D_c1 VSS x_PM_DFFRS_X2%D_12 1.05359e-16
C_x_PM_DFFRS_X2%D_c2 VSS N_D_M18_g 5.61126e-17
C_x_PM_DFFRS_X2%D_c3 VSS N_D_M39_g 5.82311e-17
R_x_PM_DFFRS_X2%D_r4 x_PM_DFFRS_X2%D_18 x_PM_DFFRS_X2%D_14 4.74714
R_x_PM_DFFRS_X2%D_r5 x_PM_DFFRS_X2%D_17 x_PM_DFFRS_X2%D_14 4.74714
R_x_PM_DFFRS_X2%D_r6 x_PM_DFFRS_X2%D_14 x_PM_DFFRS_X2%D_12 25.0012
R_x_PM_DFFRS_X2%D_r7 x_PM_DFFRS_X2%D_12 D 0.114
R_x_PM_DFFRS_X2%D_r8 N_D_M18_g x_PM_DFFRS_X2%D_18 46.8
R_x_PM_DFFRS_X2%D_r9 N_D_M39_g x_PM_DFFRS_X2%D_17 57.72
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X1 VSS VDD CK D RN QN Q
*.PININFO VSS:B VDD:B CK:I D:I RN:I QN:O Q:O
M_M16 N_VDD_M0_d N_CK_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_6_M1_d N_5_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M18 14 N_3_M2_g N_5_M2_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M19 N_VDD_M3_d N_RN_M3_g 14 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M20 15 N_6_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M21 N_5_M5_d N_3_M5_g 15 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M22 16 N_7_M6_g N_5_M5_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M23 N_VDD_M7_d N_D_M7_g 16 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M24 N_VDD_M8_d N_3_M8_g N_7_M8_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M25 17 N_5_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_9_M10_d N_3_M10_g 17 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 18 N_7_M11_g N_9_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 N_VDD_M12_d N_10_M12_g 18 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_10_M13_d N_RN_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_VDD_M14_d N_9_M14_g N_10_M13_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M15_d N_9_M15_g N_QN_M15_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M32 N_Q_M16_d N_10_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M17_d N_CK_M17_g N_3_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_6_M18_d N_5_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 19 N_RN_M19_g N_VSS_M19_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 20 N_6_M20_g 19 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_5_M21_d N_7_M21_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 21 N_3_M22_g N_5_M21_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M23_d N_D_M23_g 21 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M24_d N_3_M24_g N_7_M24_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 22 N_5_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_9_M26_d N_7_M26_g 22 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 23 N_3_M27_g N_9_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M28_d N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 24 N_RN_M29_g N_VSS_M28_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M13 N_10_M30_d N_9_M30_g 24 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VSS_M31_d N_9_M31_g N_QN_M31_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_Q_M32_d N_10_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DFFR_X1%VSS_c0 VSS x_PM_DFFR_X1%VSS_45 4.04696e-17
C_x_PM_DFFR_X1%VSS_c1 VSS x_PM_DFFR_X1%VSS_44 5.69393e-18
C_x_PM_DFFR_X1%VSS_c2 VSS x_PM_DFFR_X1%VSS_43 8.90741e-18
C_x_PM_DFFR_X1%VSS_c3 VSS x_PM_DFFR_X1%VSS_42 8.88808e-18
C_x_PM_DFFR_X1%VSS_c4 VSS x_PM_DFFR_X1%VSS_41 8.91963e-18
C_x_PM_DFFR_X1%VSS_c5 VSS N_VSS_M17_d 3.09169e-17
C_x_PM_DFFR_X1%VSS_c6 VSS N_VSS_M31_d 3.80772e-17
C_x_PM_DFFR_X1%VSS_c7 VSS x_PM_DFFR_X1%VSS_29 6.86001e-17
C_x_PM_DFFR_X1%VSS_c8 VSS N_VSS_M28_d 3.69317e-17
C_x_PM_DFFR_X1%VSS_c9 VSS x_PM_DFFR_X1%VSS_23 6.44161e-17
C_x_PM_DFFR_X1%VSS_c10 VSS x_PM_DFFR_X1%VSS_22 3.84077e-17
C_x_PM_DFFR_X1%VSS_c11 VSS x_PM_DFFR_X1%VSS_17 1.88782e-17
C_x_PM_DFFR_X1%VSS_c12 VSS x_PM_DFFR_X1%VSS_16 4.75383e-17
C_x_PM_DFFR_X1%VSS_c13 VSS x_PM_DFFR_X1%VSS_13 8.39614e-17
C_x_PM_DFFR_X1%VSS_c14 VSS x_PM_DFFR_X1%VSS_12 5.96875e-17
C_x_PM_DFFR_X1%VSS_c15 VSS x_PM_DFFR_X1%VSS_10 2.05819e-17
C_x_PM_DFFR_X1%VSS_c16 VSS x_PM_DFFR_X1%VSS_9 5.8985e-17
R_x_PM_DFFR_X1%VSS_r17 x_PM_DFFR_X1%VSS_45 x_PM_DFFR_X1%VSS_31 0.0680382
R_x_PM_DFFR_X1%VSS_r18 N_VSS_M31_d x_PM_DFFR_X1%VSS_31 0.330741
R_x_PM_DFFR_X1%VSS_r19 x_PM_DFFR_X1%VSS_44 x_PM_DFFR_X1%VSS_30 0.132285
R_x_PM_DFFR_X1%VSS_r20 x_PM_DFFR_X1%VSS_45 x_PM_DFFR_X1%VSS_29 0.132285
R_x_PM_DFFR_X1%VSS_r21 x_PM_DFFR_X1%VSS_30 x_PM_DFFR_X1%VSS_29 1.41941
R_x_PM_DFFR_X1%VSS_r22 x_PM_DFFR_X1%VSS_44 x_PM_DFFR_X1%VSS_25 0.0680382
R_x_PM_DFFR_X1%VSS_r23 N_VSS_M28_d x_PM_DFFR_X1%VSS_25 0.682593
R_x_PM_DFFR_X1%VSS_r24 x_PM_DFFR_X1%VSS_43 x_PM_DFFR_X1%VSS_24 0.132285
R_x_PM_DFFR_X1%VSS_r25 x_PM_DFFR_X1%VSS_44 x_PM_DFFR_X1%VSS_23 0.132285
R_x_PM_DFFR_X1%VSS_r26 x_PM_DFFR_X1%VSS_24 x_PM_DFFR_X1%VSS_23 1.43059
R_x_PM_DFFR_X1%VSS_r27 x_PM_DFFR_X1%VSS_43 x_PM_DFFR_X1%VSS_22 0.0680382
R_x_PM_DFFR_X1%VSS_r28 x_PM_DFFR_X1%VSS_22 N_VSS_M24_d 0.60062
R_x_PM_DFFR_X1%VSS_r29 x_PM_DFFR_X1%VSS_42 x_PM_DFFR_X1%VSS_18 0.132285
R_x_PM_DFFR_X1%VSS_r30 VSS x_PM_DFFR_X1%VSS_18 0.279412
R_x_PM_DFFR_X1%VSS_r31 x_PM_DFFR_X1%VSS_43 x_PM_DFFR_X1%VSS_17 0.132285
R_x_PM_DFFR_X1%VSS_r32 VSS x_PM_DFFR_X1%VSS_17 0.212353
R_x_PM_DFFR_X1%VSS_r33 x_PM_DFFR_X1%VSS_42 x_PM_DFFR_X1%VSS_16 0.0680382
R_x_PM_DFFR_X1%VSS_r34 x_PM_DFFR_X1%VSS_16 N_VSS_M23_d 0.516176
R_x_PM_DFFR_X1%VSS_r35 x_PM_DFFR_X1%VSS_41 x_PM_DFFR_X1%VSS_14 0.132285
R_x_PM_DFFR_X1%VSS_r36 x_PM_DFFR_X1%VSS_42 x_PM_DFFR_X1%VSS_13 0.132285
R_x_PM_DFFR_X1%VSS_r37 x_PM_DFFR_X1%VSS_14 x_PM_DFFR_X1%VSS_13 1.81059
R_x_PM_DFFR_X1%VSS_r38 x_PM_DFFR_X1%VSS_41 x_PM_DFFR_X1%VSS_12 0.0680382
R_x_PM_DFFR_X1%VSS_r39 x_PM_DFFR_X1%VSS_12 N_VSS_M19_s 0.656916
R_x_PM_DFFR_X1%VSS_r40 x_PM_DFFR_X1%VSS_10 N_VSS_M17_d 0.140674
R_x_PM_DFFR_X1%VSS_r41 x_PM_DFFR_X1%VSS_41 x_PM_DFFR_X1%VSS_9 0.132285
R_x_PM_DFFR_X1%VSS_r42 x_PM_DFFR_X1%VSS_10 x_PM_DFFR_X1%VSS_9 1.02824
C_x_PM_DFFR_X1%VDD_c0 VSS x_PM_DFFR_X1%VDD_54 2.86662e-17
C_x_PM_DFFR_X1%VDD_c1 VSS N_VDD_M14_d 2.23262e-17
C_x_PM_DFFR_X1%VDD_c2 VSS x_PM_DFFR_X1%VDD_48 8.86015e-18
C_x_PM_DFFR_X1%VDD_c3 VSS x_PM_DFFR_X1%VDD_47 8.91963e-18
C_x_PM_DFFR_X1%VDD_c4 VSS x_PM_DFFR_X1%VDD_46 4.64531e-18
C_x_PM_DFFR_X1%VDD_c5 VSS x_PM_DFFR_X1%VDD_45 8.97391e-18
C_x_PM_DFFR_X1%VDD_c6 VSS x_PM_DFFR_X1%VDD_44 2.96617e-18
C_x_PM_DFFR_X1%VDD_c7 VSS x_PM_DFFR_X1%VDD_41 3.65893e-17
C_x_PM_DFFR_X1%VDD_c8 VSS x_PM_DFFR_X1%VDD_38 1.80671e-17
C_x_PM_DFFR_X1%VDD_c9 VSS x_PM_DFFR_X1%VDD_36 3.76867e-17
C_x_PM_DFFR_X1%VDD_c10 VSS x_PM_DFFR_X1%VDD_35 6.40023e-17
C_x_PM_DFFR_X1%VDD_c11 VSS x_PM_DFFR_X1%VDD_32 7.69963e-17
C_x_PM_DFFR_X1%VDD_c12 VSS x_PM_DFFR_X1%VDD_31 5.33783e-17
C_x_PM_DFFR_X1%VDD_c13 VSS x_PM_DFFR_X1%VDD_28 2.35633e-17
C_x_PM_DFFR_X1%VDD_c14 VSS N_VDD_M7_d 3.37121e-17
C_x_PM_DFFR_X1%VDD_c15 VSS x_PM_DFFR_X1%VDD_22 6.89221e-17
C_x_PM_DFFR_X1%VDD_c16 VSS N_VDD_M3_d 6.32289e-17
C_x_PM_DFFR_X1%VDD_c17 VSS x_PM_DFFR_X1%VDD_16 1.03797e-16
C_x_PM_DFFR_X1%VDD_c18 VSS N_VDD_M0_d 4.25154e-17
C_x_PM_DFFR_X1%VDD_c19 VSS x_PM_DFFR_X1%VDD_8 2.18563e-17
R_x_PM_DFFR_X1%VDD_r20 x_PM_DFFR_X1%VDD_52 N_VDD_M14_d 0.49963
R_x_PM_DFFR_X1%VDD_r21 x_PM_DFFR_X1%VDD_54 x_PM_DFFR_X1%VDD_41 0.0680382
R_x_PM_DFFR_X1%VDD_r22 x_PM_DFFR_X1%VDD_41 N_VDD_M15_d 0.558398
R_x_PM_DFFR_X1%VDD_r23 x_PM_DFFR_X1%VDD_52 x_PM_DFFR_X1%VDD_39 0.095
R_x_PM_DFFR_X1%VDD_r24 x_PM_DFFR_X1%VDD_54 x_PM_DFFR_X1%VDD_38 0.132285
R_x_PM_DFFR_X1%VDD_r25 x_PM_DFFR_X1%VDD_39 x_PM_DFFR_X1%VDD_38 0.447059
R_x_PM_DFFR_X1%VDD_r26 x_PM_DFFR_X1%VDD_48 x_PM_DFFR_X1%VDD_37 0.132285
R_x_PM_DFFR_X1%VDD_r27 x_PM_DFFR_X1%VDD_52 x_PM_DFFR_X1%VDD_36 0.095
R_x_PM_DFFR_X1%VDD_r28 x_PM_DFFR_X1%VDD_37 x_PM_DFFR_X1%VDD_36 0.692941
R_x_PM_DFFR_X1%VDD_r29 x_PM_DFFR_X1%VDD_48 x_PM_DFFR_X1%VDD_35 0.0680382
R_x_PM_DFFR_X1%VDD_r30 x_PM_DFFR_X1%VDD_35 N_VDD_M12_d 0.403583
R_x_PM_DFFR_X1%VDD_r31 x_PM_DFFR_X1%VDD_47 x_PM_DFFR_X1%VDD_33 0.132285
R_x_PM_DFFR_X1%VDD_r32 x_PM_DFFR_X1%VDD_48 x_PM_DFFR_X1%VDD_32 0.132285
R_x_PM_DFFR_X1%VDD_r33 x_PM_DFFR_X1%VDD_33 x_PM_DFFR_X1%VDD_32 1.40824
R_x_PM_DFFR_X1%VDD_r34 x_PM_DFFR_X1%VDD_47 x_PM_DFFR_X1%VDD_31 0.0680382
R_x_PM_DFFR_X1%VDD_r35 x_PM_DFFR_X1%VDD_31 N_VDD_M8_d 0.656916
R_x_PM_DFFR_X1%VDD_r36 x_PM_DFFR_X1%VDD_46 x_PM_DFFR_X1%VDD_29 0.0731438
R_x_PM_DFFR_X1%VDD_r37 x_PM_DFFR_X1%VDD_47 x_PM_DFFR_X1%VDD_28 0.132285
R_x_PM_DFFR_X1%VDD_r38 x_PM_DFFR_X1%VDD_29 x_PM_DFFR_X1%VDD_28 0.57
R_x_PM_DFFR_X1%VDD_r39 x_PM_DFFR_X1%VDD_46 x_PM_DFFR_X1%VDD_24 0.145286
R_x_PM_DFFR_X1%VDD_r40 N_VDD_M7_d x_PM_DFFR_X1%VDD_24 1.58786
R_x_PM_DFFR_X1%VDD_r41 x_PM_DFFR_X1%VDD_45 x_PM_DFFR_X1%VDD_23 0.132285
R_x_PM_DFFR_X1%VDD_r42 x_PM_DFFR_X1%VDD_46 x_PM_DFFR_X1%VDD_22 0.0731438
R_x_PM_DFFR_X1%VDD_r43 x_PM_DFFR_X1%VDD_23 x_PM_DFFR_X1%VDD_22 1.46412
R_x_PM_DFFR_X1%VDD_r44 x_PM_DFFR_X1%VDD_45 x_PM_DFFR_X1%VDD_18 0.0680382
R_x_PM_DFFR_X1%VDD_r45 N_VDD_M3_d x_PM_DFFR_X1%VDD_18 1.02037
R_x_PM_DFFR_X1%VDD_r46 x_PM_DFFR_X1%VDD_44 x_PM_DFFR_X1%VDD_17 0.0731438
R_x_PM_DFFR_X1%VDD_r47 x_PM_DFFR_X1%VDD_45 x_PM_DFFR_X1%VDD_16 0.132285
R_x_PM_DFFR_X1%VDD_r48 x_PM_DFFR_X1%VDD_17 x_PM_DFFR_X1%VDD_16 1.52
R_x_PM_DFFR_X1%VDD_r49 x_PM_DFFR_X1%VDD_44 x_PM_DFFR_X1%VDD_12 0.145286
R_x_PM_DFFR_X1%VDD_r50 N_VDD_M0_d x_PM_DFFR_X1%VDD_12 1.37071
R_x_PM_DFFR_X1%VDD_r51 x_PM_DFFR_X1%VDD_44 x_PM_DFFR_X1%VDD_8 0.0731438
R_x_PM_DFFR_X1%VDD_r52 VDD x_PM_DFFR_X1%VDD_8 0.296176
C_x_PM_DFFR_X1%3_c0 VSS x_PM_DFFR_X1%3_58 4.19003e-18
C_x_PM_DFFR_X1%3_c1 VSS x_PM_DFFR_X1%3_55 1.32979e-16
C_x_PM_DFFR_X1%3_c2 VSS N_3_M0_s 5.34094e-17
C_x_PM_DFFR_X1%3_c3 VSS N_3_M17_s 2.76969e-17
C_x_PM_DFFR_X1%3_c4 VSS x_PM_DFFR_X1%3_42 3.37069e-18
C_x_PM_DFFR_X1%3_c5 VSS x_PM_DFFR_X1%3_41 4.78137e-18
C_x_PM_DFFR_X1%3_c6 VSS x_PM_DFFR_X1%3_40 6.82443e-18
C_x_PM_DFFR_X1%3_c7 VSS x_PM_DFFR_X1%3_39 2.59983e-17
C_x_PM_DFFR_X1%3_c8 VSS N_3_M27_g 6.84099e-17
C_x_PM_DFFR_X1%3_c9 VSS x_PM_DFFR_X1%3_34 6.36318e-18
C_x_PM_DFFR_X1%3_c10 VSS x_PM_DFFR_X1%3_33 2.16363e-17
C_x_PM_DFFR_X1%3_c11 VSS N_3_M10_g 4.2442e-17
C_x_PM_DFFR_X1%3_c12 VSS x_PM_DFFR_X1%3_27 7.86545e-17
C_x_PM_DFFR_X1%3_c13 VSS N_3_M24_g 1.1406e-16
C_x_PM_DFFR_X1%3_c14 VSS x_PM_DFFR_X1%3_19 6.38051e-17
C_x_PM_DFFR_X1%3_c15 VSS N_3_M22_g 3.65084e-17
C_x_PM_DFFR_X1%3_c16 VSS x_PM_DFFR_X1%3_14 6.92227e-18
C_x_PM_DFFR_X1%3_c17 VSS x_PM_DFFR_X1%3_13 8.40036e-17
C_x_PM_DFFR_X1%3_c18 VSS N_3_M5_g 3.32825e-17
C_x_PM_DFFR_X1%3_c19 VSS x_PM_DFFR_X1%3_8 8.91826e-18
C_x_PM_DFFR_X1%3_c20 VSS x_PM_DFFR_X1%3_7 9.80168e-17
C_x_PM_DFFR_X1%3_c21 VSS N_3_M2_g 1.05217e-16
C_x_PM_DFFR_X1%3_c22 VSS x_PM_DFFR_X1%3_2 2.65365e-17
R_x_PM_DFFR_X1%3_r23 x_PM_DFFR_X1%3_59 x_PM_DFFR_X1%3_55 25.0012
R_x_PM_DFFR_X1%3_r24 x_PM_DFFR_X1%3_58 x_PM_DFFR_X1%3_53 0.0272847
R_x_PM_DFFR_X1%3_r25 x_PM_DFFR_X1%3_55 x_PM_DFFR_X1%3_53 1.25963
R_x_PM_DFFR_X1%3_r26 x_PM_DFFR_X1%3_58 x_PM_DFFR_X1%3_49 0.266978
R_x_PM_DFFR_X1%3_r27 N_3_M0_s x_PM_DFFR_X1%3_49 2.10357
R_x_PM_DFFR_X1%3_r28 x_PM_DFFR_X1%3_58 x_PM_DFFR_X1%3_45 0.266978
R_x_PM_DFFR_X1%3_r29 N_3_M17_s x_PM_DFFR_X1%3_45 0.610714
R_x_PM_DFFR_X1%3_r30 x_PM_DFFR_X1%3_59 x_PM_DFFR_X1%3_39 16.9
R_x_PM_DFFR_X1%3_r31 x_PM_DFFR_X1%3_40 x_PM_DFFR_X1%3_39 0.043368
R_x_PM_DFFR_X1%3_r32 N_3_M27_g x_PM_DFFR_X1%3_36 75.66
R_x_PM_DFFR_X1%3_r33 N_3_M27_g x_PM_DFFR_X1%3_35 31.2
R_x_PM_DFFR_X1%3_r34 x_PM_DFFR_X1%3_36 x_PM_DFFR_X1%3_33 4.35808
R_x_PM_DFFR_X1%3_r35 x_PM_DFFR_X1%3_34 x_PM_DFFR_X1%3_33 21.84
R_x_PM_DFFR_X1%3_r36 x_PM_DFFR_X1%3_34 x_PM_DFFR_X1%3_29 4.35808
R_x_PM_DFFR_X1%3_r37 N_3_M10_g x_PM_DFFR_X1%3_29 28.86
R_x_PM_DFFR_X1%3_r38 x_PM_DFFR_X1%3_42 x_PM_DFFR_X1%3_28 1.97748
R_x_PM_DFFR_X1%3_r39 x_PM_DFFR_X1%3_35 x_PM_DFFR_X1%3_27 4.83753
R_x_PM_DFFR_X1%3_r40 x_PM_DFFR_X1%3_28 x_PM_DFFR_X1%3_27 45.0667
R_x_PM_DFFR_X1%3_r41 N_3_M8_g N_3_M24_g 98.28
R_x_PM_DFFR_X1%3_r42 N_3_M8_g x_PM_DFFR_X1%3_22 28.08
R_x_PM_DFFR_X1%3_r43 x_PM_DFFR_X1%3_42 x_PM_DFFR_X1%3_21 2.25244
R_x_PM_DFFR_X1%3_r44 N_3_M24_g x_PM_DFFR_X1%3_21 38.22
R_x_PM_DFFR_X1%3_r45 x_PM_DFFR_X1%3_41 x_PM_DFFR_X1%3_20 1.97748
R_x_PM_DFFR_X1%3_r46 x_PM_DFFR_X1%3_42 x_PM_DFFR_X1%3_19 1.97748
R_x_PM_DFFR_X1%3_r47 x_PM_DFFR_X1%3_20 x_PM_DFFR_X1%3_19 42.4667
R_x_PM_DFFR_X1%3_r48 x_PM_DFFR_X1%3_41 x_PM_DFFR_X1%3_15 2.25244
R_x_PM_DFFR_X1%3_r49 N_3_M22_g x_PM_DFFR_X1%3_15 33.54
R_x_PM_DFFR_X1%3_r50 x_PM_DFFR_X1%3_22 x_PM_DFFR_X1%3_13 4.35808
R_x_PM_DFFR_X1%3_r51 x_PM_DFFR_X1%3_14 x_PM_DFFR_X1%3_13 106.08
R_x_PM_DFFR_X1%3_r52 x_PM_DFFR_X1%3_14 x_PM_DFFR_X1%3_9 4.35808
R_x_PM_DFFR_X1%3_r53 N_3_M5_g x_PM_DFFR_X1%3_9 37.44
R_x_PM_DFFR_X1%3_r54 x_PM_DFFR_X1%3_41 x_PM_DFFR_X1%3_7 1.97748
R_x_PM_DFFR_X1%3_r55 x_PM_DFFR_X1%3_8 x_PM_DFFR_X1%3_7 62.8333
R_x_PM_DFFR_X1%3_r56 x_PM_DFFR_X1%3_40 x_PM_DFFR_X1%3_3 4.56151
R_x_PM_DFFR_X1%3_r57 N_3_M2_g x_PM_DFFR_X1%3_3 98.28
R_x_PM_DFFR_X1%3_r58 x_PM_DFFR_X1%3_40 x_PM_DFFR_X1%3_2 4.56151
R_x_PM_DFFR_X1%3_r59 x_PM_DFFR_X1%3_8 x_PM_DFFR_X1%3_VSS 4.83753
R_x_PM_DFFR_X1%3_r60 x_PM_DFFR_X1%3_2 x_PM_DFFR_X1%3_VSS 38.22
C_x_PM_DFFR_X1%CK_c0 VSS CK 6.25345e-17
C_x_PM_DFFR_X1%CK_c1 VSS x_PM_DFFR_X1%CK_11 1.23985e-17
C_x_PM_DFFR_X1%CK_c2 VSS N_CK_M0_g 5.11479e-17
C_x_PM_DFFR_X1%CK_c3 VSS N_CK_M17_g 6.38186e-17
R_x_PM_DFFR_X1%CK_r4 x_PM_DFFR_X1%CK_11 x_PM_DFFR_X1%CK_16 3.9
R_x_PM_DFFR_X1%CK_r5 x_PM_DFFR_X1%CK_11 x_PM_DFFR_X1%CK_9 25.0012
R_x_PM_DFFR_X1%CK_r6 CK x_PM_DFFR_X1%CK_9 0.210357
R_x_PM_DFFR_X1%CK_r7 x_PM_DFFR_X1%CK_16 x_PM_DFFR_X1%CK_5 1.95
R_x_PM_DFFR_X1%CK_r8 N_CK_M0_g x_PM_DFFR_X1%CK_5 46.8
R_x_PM_DFFR_X1%CK_r9 x_PM_DFFR_X1%CK_16 x_PM_DFFR_X1%CK_VSS 1.95
R_x_PM_DFFR_X1%CK_r10 N_CK_M17_g x_PM_DFFR_X1%CK_VSS 63.96
C_x_PM_DFFR_X1%5_c0 VSS x_PM_DFFR_X1%5_48 9.08713e-18
C_x_PM_DFFR_X1%5_c1 VSS x_PM_DFFR_X1%5_41 2.97264e-17
C_x_PM_DFFR_X1%5_c2 VSS x_PM_DFFR_X1%5_37 1.65458e-16
C_x_PM_DFFR_X1%5_c3 VSS N_5_M21_d 1.29966e-17
C_x_PM_DFFR_X1%5_c4 VSS x_PM_DFFR_X1%5_31 9.66605e-18
C_x_PM_DFFR_X1%5_c5 VSS x_PM_DFFR_X1%5_30 5.46331e-17
C_x_PM_DFFR_X1%5_c6 VSS x_PM_DFFR_X1%5_28 2.42254e-17
C_x_PM_DFFR_X1%5_c7 VSS x_PM_DFFR_X1%5_27 1.16415e-16
C_x_PM_DFFR_X1%5_c8 VSS N_5_M2_s 3.97646e-17
C_x_PM_DFFR_X1%5_c9 VSS x_PM_DFFR_X1%5_21 1.58856e-17
C_x_PM_DFFR_X1%5_c10 VSS x_PM_DFFR_X1%5_18 9.53522e-17
C_x_PM_DFFR_X1%5_c11 VSS N_5_M9_g 4.45514e-17
C_x_PM_DFFR_X1%5_c12 VSS N_5_M25_g 5.68262e-17
C_x_PM_DFFR_X1%5_c13 VSS N_5_M18_g 1.17164e-16
R_x_PM_DFFR_X1%5_r14 x_PM_DFFR_X1%5_50 x_PM_DFFR_X1%5_48 4.74714
R_x_PM_DFFR_X1%5_r15 N_5_M5_d x_PM_DFFR_X1%5_41 0.292216
R_x_PM_DFFR_X1%5_r16 x_PM_DFFR_X1%5_41 x_PM_DFFR_X1%5_40 0.0596359
R_x_PM_DFFR_X1%5_r17 x_PM_DFFR_X1%5_48 x_PM_DFFR_X1%5_37 25.0012
R_x_PM_DFFR_X1%5_r18 x_PM_DFFR_X1%5_40 x_PM_DFFR_X1%5_35 0.113308
R_x_PM_DFFR_X1%5_r19 x_PM_DFFR_X1%5_37 x_PM_DFFR_X1%5_35 4.03071
R_x_PM_DFFR_X1%5_r20 N_5_M21_d x_PM_DFFR_X1%5_31 0.257857
R_x_PM_DFFR_X1%5_r21 x_PM_DFFR_X1%5_40 x_PM_DFFR_X1%5_30 0.190573
R_x_PM_DFFR_X1%5_r22 x_PM_DFFR_X1%5_31 x_PM_DFFR_X1%5_29 0.212645
R_x_PM_DFFR_X1%5_r23 x_PM_DFFR_X1%5_30 x_PM_DFFR_X1%5_29 1.824
R_x_PM_DFFR_X1%5_r24 x_PM_DFFR_X1%5_41 x_PM_DFFR_X1%5_27 0.113308
R_x_PM_DFFR_X1%5_r25 x_PM_DFFR_X1%5_28 x_PM_DFFR_X1%5_27 3.33857
R_x_PM_DFFR_X1%5_r26 N_5_M2_s x_PM_DFFR_X1%5_24 0.556429
R_x_PM_DFFR_X1%5_r27 x_PM_DFFR_X1%5_28 x_PM_DFFR_X1%5_23 0.212317
R_x_PM_DFFR_X1%5_r28 N_5_M2_s x_PM_DFFR_X1%5_23 1.235
R_x_PM_DFFR_X1%5_r29 x_PM_DFFR_X1%5_21 x_PM_DFFR_X1%5_44 5.46
R_x_PM_DFFR_X1%5_r30 x_PM_DFFR_X1%5_21 x_PM_DFFR_X1%5_19 25.0012
R_x_PM_DFFR_X1%5_r31 x_PM_DFFR_X1%5_24 x_PM_DFFR_X1%5_18 0.212317
R_x_PM_DFFR_X1%5_r32 x_PM_DFFR_X1%5_19 x_PM_DFFR_X1%5_18 1.01786
R_x_PM_DFFR_X1%5_r33 N_5_M9_g x_PM_DFFR_X1%5_50 35.1
R_x_PM_DFFR_X1%5_r34 x_PM_DFFR_X1%5_7 x_PM_DFFR_X1%5_48 4.74714
R_x_PM_DFFR_X1%5_r35 N_5_M25_g x_PM_DFFR_X1%5_7 65.52
R_x_PM_DFFR_X1%5_r36 N_5_M1_g N_5_M18_g 129.48
R_x_PM_DFFR_X1%5_r37 x_PM_DFFR_X1%5_44 x_PM_DFFR_X1%5_VSS 1.95
R_x_PM_DFFR_X1%5_r38 N_5_M1_g x_PM_DFFR_X1%5_VSS 18.72
C_x_PM_DFFR_X1%6_c0 VSS x_PM_DFFR_X1%6_28 7.74812e-18
C_x_PM_DFFR_X1%6_c1 VSS x_PM_DFFR_X1%6_25 1.1192e-16
C_x_PM_DFFR_X1%6_c2 VSS x_PM_DFFR_X1%6_22 7.88365e-17
C_x_PM_DFFR_X1%6_c3 VSS x_PM_DFFR_X1%6_20 1.63621e-17
C_x_PM_DFFR_X1%6_c4 VSS x_PM_DFFR_X1%6_19 1.54817e-17
C_x_PM_DFFR_X1%6_c5 VSS N_6_M1_d 7.48466e-17
C_x_PM_DFFR_X1%6_c6 VSS x_PM_DFFR_X1%6_11 8.0281e-17
C_x_PM_DFFR_X1%6_c7 VSS N_6_M4_g 3.81395e-17
C_x_PM_DFFR_X1%6_c8 VSS N_6_M20_g 3.57997e-17
R_x_PM_DFFR_X1%6_r9 x_PM_DFFR_X1%6_30 x_PM_DFFR_X1%6_28 4.7687
R_x_PM_DFFR_X1%6_r10 x_PM_DFFR_X1%6_28 x_PM_DFFR_X1%6_25 25.0012
R_x_PM_DFFR_X1%6_r11 x_PM_DFFR_X1%6_25 x_PM_DFFR_X1%6_23 2.51071
R_x_PM_DFFR_X1%6_r12 x_PM_DFFR_X1%6_23 x_PM_DFFR_X1%6_22 0.095
R_x_PM_DFFR_X1%6_r13 x_PM_DFFR_X1%6_22 x_PM_DFFR_X1%6_21 1.95429
R_x_PM_DFFR_X1%6_r14 x_PM_DFFR_X1%6_23 x_PM_DFFR_X1%6_19 0.19
R_x_PM_DFFR_X1%6_r15 x_PM_DFFR_X1%6_20 x_PM_DFFR_X1%6_19 0.814286
R_x_PM_DFFR_X1%6_r16 x_PM_DFFR_X1%6_20 x_PM_DFFR_X1%6_15 0.212317
R_x_PM_DFFR_X1%6_r17 N_6_M1_d x_PM_DFFR_X1%6_15 1.88643
R_x_PM_DFFR_X1%6_r18 x_PM_DFFR_X1%6_21 x_PM_DFFR_X1%6_11 0.212317
R_x_PM_DFFR_X1%6_r19 N_6_M18_d x_PM_DFFR_X1%6_11 1.01786
R_x_PM_DFFR_X1%6_r20 N_6_M4_g x_PM_DFFR_X1%6_30 38.22
R_x_PM_DFFR_X1%6_r21 x_PM_DFFR_X1%6_VSS x_PM_DFFR_X1%6_28 4.7687
R_x_PM_DFFR_X1%6_r22 N_6_M20_g x_PM_DFFR_X1%6_VSS 42.9
C_x_PM_DFFR_X1%7_c0 VSS x_PM_DFFR_X1%7_59 1.1467e-17
C_x_PM_DFFR_X1%7_c1 VSS x_PM_DFFR_X1%7_55 1.20171e-17
C_x_PM_DFFR_X1%7_c2 VSS x_PM_DFFR_X1%7_51 5.36255e-17
C_x_PM_DFFR_X1%7_c3 VSS x_PM_DFFR_X1%7_50 4.40739e-18
C_x_PM_DFFR_X1%7_c4 VSS N_7_M24_s 1.13528e-17
C_x_PM_DFFR_X1%7_c5 VSS x_PM_DFFR_X1%7_36 1.64918e-17
C_x_PM_DFFR_X1%7_c6 VSS x_PM_DFFR_X1%7_35 3.81919e-17
C_x_PM_DFFR_X1%7_c7 VSS x_PM_DFFR_X1%7_34 4.85324e-18
C_x_PM_DFFR_X1%7_c8 VSS x_PM_DFFR_X1%7_33 4.10256e-17
C_x_PM_DFFR_X1%7_c9 VSS x_PM_DFFR_X1%7_32 8.05008e-17
C_x_PM_DFFR_X1%7_c10 VSS x_PM_DFFR_X1%7_30 3.92241e-17
C_x_PM_DFFR_X1%7_c11 VSS x_PM_DFFR_X1%7_29 9.00507e-18
C_x_PM_DFFR_X1%7_c12 VSS x_PM_DFFR_X1%7_28 5.24669e-17
C_x_PM_DFFR_X1%7_c13 VSS x_PM_DFFR_X1%7_27 9.50012e-18
C_x_PM_DFFR_X1%7_c14 VSS x_PM_DFFR_X1%7_21 4.57127e-17
C_x_PM_DFFR_X1%7_c15 VSS N_7_M11_g 2.66496e-17
C_x_PM_DFFR_X1%7_c16 VSS N_7_M26_g 2.56399e-17
C_x_PM_DFFR_X1%7_c17 VSS N_7_M6_g 5.26927e-17
C_x_PM_DFFR_X1%7_c18 VSS x_PM_DFFR_X1%7_7 6.78764e-18
C_x_PM_DFFR_X1%7_c19 VSS x_PM_DFFR_X1%7_6 6.9425e-18
C_x_PM_DFFR_X1%7_c20 VSS x_PM_DFFR_X1%7_5 1.76259e-17
C_x_PM_DFFR_X1%7_c21 VSS N_7_M21_g 3.47514e-17
R_x_PM_DFFR_X1%7_r22 x_PM_DFFR_X1%7_59 x_PM_DFFR_X1%7_57 3.9
R_x_PM_DFFR_X1%7_r23 x_PM_DFFR_X1%7_63 x_PM_DFFR_X1%7_55 4.7687
R_x_PM_DFFR_X1%7_r24 x_PM_DFFR_X1%7_55 x_PM_DFFR_X1%7_53 25.0012
R_x_PM_DFFR_X1%7_r25 x_PM_DFFR_X1%7_53 x_PM_DFFR_X1%7_51 0.312143
R_x_PM_DFFR_X1%7_r26 x_PM_DFFR_X1%7_57 x_PM_DFFR_X1%7_48 25.0012
R_x_PM_DFFR_X1%7_r27 x_PM_DFFR_X1%7_46 x_PM_DFFR_X1%7_45 0.325714
R_x_PM_DFFR_X1%7_r28 x_PM_DFFR_X1%7_45 N_7_M24_s 0.0135714
R_x_PM_DFFR_X1%7_r29 x_PM_DFFR_X1%7_50 x_PM_DFFR_X1%7_37 0.160909
R_x_PM_DFFR_X1%7_r30 x_PM_DFFR_X1%7_51 x_PM_DFFR_X1%7_36 0.095
R_x_PM_DFFR_X1%7_r31 x_PM_DFFR_X1%7_37 x_PM_DFFR_X1%7_36 0.814286
R_x_PM_DFFR_X1%7_r32 x_PM_DFFR_X1%7_50 x_PM_DFFR_X1%7_35 0.0418175
R_x_PM_DFFR_X1%7_r33 x_PM_DFFR_X1%7_48 x_PM_DFFR_X1%7_34 0.0141545
R_x_PM_DFFR_X1%7_r34 x_PM_DFFR_X1%7_35 x_PM_DFFR_X1%7_34 1.98143
R_x_PM_DFFR_X1%7_r35 x_PM_DFFR_X1%7_33 N_7_M8_s 0.297071
R_x_PM_DFFR_X1%7_r36 x_PM_DFFR_X1%7_50 x_PM_DFFR_X1%7_32 0.160909
R_x_PM_DFFR_X1%7_r37 x_PM_DFFR_X1%7_33 x_PM_DFFR_X1%7_32 1.79143
R_x_PM_DFFR_X1%7_r38 x_PM_DFFR_X1%7_46 x_PM_DFFR_X1%7_31 0.095
R_x_PM_DFFR_X1%7_r39 x_PM_DFFR_X1%7_48 x_PM_DFFR_X1%7_30 0.198162
R_x_PM_DFFR_X1%7_r40 x_PM_DFFR_X1%7_31 x_PM_DFFR_X1%7_30 1.84571
R_x_PM_DFFR_X1%7_r41 x_PM_DFFR_X1%7_45 x_PM_DFFR_X1%7_28 0.095
R_x_PM_DFFR_X1%7_r42 x_PM_DFFR_X1%7_29 x_PM_DFFR_X1%7_28 1.79143
R_x_PM_DFFR_X1%7_r43 x_PM_DFFR_X1%7_29 x_PM_DFFR_X1%7_26 0.212317
R_x_PM_DFFR_X1%7_r44 x_PM_DFFR_X1%7_27 x_PM_DFFR_X1%7_26 0.57
R_x_PM_DFFR_X1%7_r45 x_PM_DFFR_X1%7_24 x_PM_DFFR_X1%7_22 25.0012
R_x_PM_DFFR_X1%7_r46 x_PM_DFFR_X1%7_27 x_PM_DFFR_X1%7_21 0.212317
R_x_PM_DFFR_X1%7_r47 x_PM_DFFR_X1%7_22 x_PM_DFFR_X1%7_21 0.257857
R_x_PM_DFFR_X1%7_r48 N_7_M11_g x_PM_DFFR_X1%7_63 18.72
R_x_PM_DFFR_X1%7_r49 x_PM_DFFR_X1%7_59 x_PM_DFFR_X1%7_11 1.95
R_x_PM_DFFR_X1%7_r50 N_7_M26_g x_PM_DFFR_X1%7_11 24.18
R_x_PM_DFFR_X1%7_r51 x_PM_DFFR_X1%7_24 x_PM_DFFR_X1%7_7 3.67098
R_x_PM_DFFR_X1%7_r52 N_7_M6_g x_PM_DFFR_X1%7_7 37.44
R_x_PM_DFFR_X1%7_r53 x_PM_DFFR_X1%7_24 x_PM_DFFR_X1%7_5 0.917744
R_x_PM_DFFR_X1%7_r54 x_PM_DFFR_X1%7_6 x_PM_DFFR_X1%7_5 14.56
R_x_PM_DFFR_X1%7_r55 x_PM_DFFR_X1%7_6 x_PM_DFFR_X1%7_VSS 4.58872
R_x_PM_DFFR_X1%7_r56 N_7_M21_g x_PM_DFFR_X1%7_VSS 33.54
C_x_PM_DFFR_X1%D_c0 VSS D 5.03473e-17
C_x_PM_DFFR_X1%D_c1 VSS x_PM_DFFR_X1%D_11 1.26457e-17
C_x_PM_DFFR_X1%D_c2 VSS N_D_M7_g 5.2268e-17
C_x_PM_DFFR_X1%D_c3 VSS N_D_M23_g 4.45074e-17
R_x_PM_DFFR_X1%D_r4 x_PM_DFFR_X1%D_11 x_PM_DFFR_X1%D_16 4.94
R_x_PM_DFFR_X1%D_r5 x_PM_DFFR_X1%D_11 x_PM_DFFR_X1%D_9 25.0012
R_x_PM_DFFR_X1%D_r6 D x_PM_DFFR_X1%D_9 0.212353
R_x_PM_DFFR_X1%D_r7 x_PM_DFFR_X1%D_16 x_PM_DFFR_X1%D_5 1.95
R_x_PM_DFFR_X1%D_r8 N_D_M7_g x_PM_DFFR_X1%D_5 35.88
R_x_PM_DFFR_X1%D_r9 x_PM_DFFR_X1%D_16 x_PM_DFFR_X1%D_VSS 1.95
R_x_PM_DFFR_X1%D_r10 N_D_M23_g x_PM_DFFR_X1%D_VSS 35.88
C_x_PM_DFFR_X1%9_c0 VSS x_PM_DFFR_X1%9_45 3.39522e-17
C_x_PM_DFFR_X1%9_c1 VSS x_PM_DFFR_X1%9_44 8.28262e-18
C_x_PM_DFFR_X1%9_c2 VSS x_PM_DFFR_X1%9_41 1.03676e-16
C_x_PM_DFFR_X1%9_c3 VSS x_PM_DFFR_X1%9_38 6.57238e-17
C_x_PM_DFFR_X1%9_c4 VSS x_PM_DFFR_X1%9_36 2.59349e-17
C_x_PM_DFFR_X1%9_c5 VSS x_PM_DFFR_X1%9_31 6.98564e-17
C_x_PM_DFFR_X1%9_c6 VSS x_PM_DFFR_X1%9_27 4.53977e-17
C_x_PM_DFFR_X1%9_c7 VSS x_PM_DFFR_X1%9_24 1.17027e-17
C_x_PM_DFFR_X1%9_c8 VSS x_PM_DFFR_X1%9_22 5.72825e-18
C_x_PM_DFFR_X1%9_c9 VSS N_9_M15_g 3.08751e-17
C_x_PM_DFFR_X1%9_c10 VSS N_9_M31_g 4.25668e-17
C_x_PM_DFFR_X1%9_c11 VSS x_PM_DFFR_X1%9_11 4.40585e-17
C_x_PM_DFFR_X1%9_c12 VSS x_PM_DFFR_X1%9_9 4.73573e-17
C_x_PM_DFFR_X1%9_c13 VSS N_9_M14_g 4.70493e-17
C_x_PM_DFFR_X1%9_c14 VSS N_9_M30_g 4.33351e-17
R_x_PM_DFFR_X1%9_r15 x_PM_DFFR_X1%9_45 x_PM_DFFR_X1%9_41 25.0012
R_x_PM_DFFR_X1%9_r16 x_PM_DFFR_X1%9_44 x_PM_DFFR_X1%9_39 0.0272847
R_x_PM_DFFR_X1%9_r17 x_PM_DFFR_X1%9_41 x_PM_DFFR_X1%9_39 1.24556
R_x_PM_DFFR_X1%9_r18 x_PM_DFFR_X1%9_44 x_PM_DFFR_X1%9_37 0.266978
R_x_PM_DFFR_X1%9_r19 x_PM_DFFR_X1%9_38 x_PM_DFFR_X1%9_37 1.84571
R_x_PM_DFFR_X1%9_r20 x_PM_DFFR_X1%9_44 x_PM_DFFR_X1%9_36 0.266978
R_x_PM_DFFR_X1%9_r21 x_PM_DFFR_X1%9_36 x_PM_DFFR_X1%9_35 1.54714
R_x_PM_DFFR_X1%9_r22 x_PM_DFFR_X1%9_38 x_PM_DFFR_X1%9_31 0.212317
R_x_PM_DFFR_X1%9_r23 N_9_M10_d x_PM_DFFR_X1%9_31 0.963571
R_x_PM_DFFR_X1%9_r24 x_PM_DFFR_X1%9_35 x_PM_DFFR_X1%9_27 0.212317
R_x_PM_DFFR_X1%9_r25 N_9_M26_d x_PM_DFFR_X1%9_27 0.990714
R_x_PM_DFFR_X1%9_r26 x_PM_DFFR_X1%9_45 x_PM_DFFR_X1%9_23 13.9941
R_x_PM_DFFR_X1%9_r27 x_PM_DFFR_X1%9_24 x_PM_DFFR_X1%9_23 3.60226
R_x_PM_DFFR_X1%9_r28 x_PM_DFFR_X1%9_45 x_PM_DFFR_X1%9_21 14.9118
R_x_PM_DFFR_X1%9_r29 x_PM_DFFR_X1%9_22 x_PM_DFFR_X1%9_21 3.60226
R_x_PM_DFFR_X1%9_r30 N_9_M15_g x_PM_DFFR_X1%9_17 19.89
R_x_PM_DFFR_X1%9_r31 N_9_M31_g x_PM_DFFR_X1%9_13 40.56
R_x_PM_DFFR_X1%9_r32 x_PM_DFFR_X1%9_24 x_PM_DFFR_X1%9_12 0.617637
R_x_PM_DFFR_X1%9_r33 x_PM_DFFR_X1%9_17 x_PM_DFFR_X1%9_11 4.58872
R_x_PM_DFFR_X1%9_r34 x_PM_DFFR_X1%9_12 x_PM_DFFR_X1%9_11 29.12
R_x_PM_DFFR_X1%9_r35 x_PM_DFFR_X1%9_22 x_PM_DFFR_X1%9_10 0.617637
R_x_PM_DFFR_X1%9_r36 x_PM_DFFR_X1%9_13 x_PM_DFFR_X1%9_9 4.58872
R_x_PM_DFFR_X1%9_r37 x_PM_DFFR_X1%9_10 x_PM_DFFR_X1%9_9 31.72
R_x_PM_DFFR_X1%9_r38 x_PM_DFFR_X1%9_24 x_PM_DFFR_X1%9_5 3.60226
R_x_PM_DFFR_X1%9_r39 N_9_M14_g x_PM_DFFR_X1%9_5 43.68
R_x_PM_DFFR_X1%9_r40 x_PM_DFFR_X1%9_22 x_PM_DFFR_X1%9_VSS 3.60226
R_x_PM_DFFR_X1%9_r41 N_9_M30_g x_PM_DFFR_X1%9_VSS 28.86
C_x_PM_DFFR_X1%10_c0 VSS x_PM_DFFR_X1%10_47 3.86975e-17
C_x_PM_DFFR_X1%10_c1 VSS x_PM_DFFR_X1%10_45 4.80442e-17
C_x_PM_DFFR_X1%10_c2 VSS N_10_M30_d 5.92356e-17
C_x_PM_DFFR_X1%10_c3 VSS x_PM_DFFR_X1%10_39 8.83209e-18
C_x_PM_DFFR_X1%10_c4 VSS x_PM_DFFR_X1%10_35 1.37209e-17
C_x_PM_DFFR_X1%10_c5 VSS x_PM_DFFR_X1%10_33 4.99489e-17
C_x_PM_DFFR_X1%10_c6 VSS x_PM_DFFR_X1%10_32 3.21842e-17
C_x_PM_DFFR_X1%10_c7 VSS x_PM_DFFR_X1%10_27 3.50624e-17
C_x_PM_DFFR_X1%10_c8 VSS N_10_M13_d 3.37914e-17
C_x_PM_DFFR_X1%10_c9 VSS x_PM_DFFR_X1%10_21 2.5039e-17
C_x_PM_DFFR_X1%10_c10 VSS x_PM_DFFR_X1%10_18 6.61384e-18
C_x_PM_DFFR_X1%10_c11 VSS x_PM_DFFR_X1%10_17 4.93731e-17
C_x_PM_DFFR_X1%10_c12 VSS N_10_M16_g 5.04614e-17
C_x_PM_DFFR_X1%10_c13 VSS N_10_M32_g 6.61903e-17
C_x_PM_DFFR_X1%10_c14 VSS N_10_M12_g 2.21278e-17
C_x_PM_DFFR_X1%10_c15 VSS N_10_M28_g 7.51288e-17
R_x_PM_DFFR_X1%10_r16 x_PM_DFFR_X1%10_53 x_PM_DFFR_X1%10_51 1.04
R_x_PM_DFFR_X1%10_r17 x_PM_DFFR_X1%10_48 x_PM_DFFR_X1%10_45 0.29113
R_x_PM_DFFR_X1%10_r18 x_PM_DFFR_X1%10_47 x_PM_DFFR_X1%10_45 0.29113
R_x_PM_DFFR_X1%10_r19 x_PM_DFFR_X1%10_49 x_PM_DFFR_X1%10_45 25.0012
R_x_PM_DFFR_X1%10_r20 x_PM_DFFR_X1%10_35 x_PM_DFFR_X1%10_53 5.98
R_x_PM_DFFR_X1%10_r21 x_PM_DFFR_X1%10_35 x_PM_DFFR_X1%10_33 25.0012
R_x_PM_DFFR_X1%10_r22 x_PM_DFFR_X1%10_37 x_PM_DFFR_X1%10_33 0.176429
R_x_PM_DFFR_X1%10_r23 x_PM_DFFR_X1%10_32 x_PM_DFFR_X1%10_48 1.11286
R_x_PM_DFFR_X1%10_r24 x_PM_DFFR_X1%10_29 N_10_M30_d 0.203618
R_x_PM_DFFR_X1%10_r25 x_PM_DFFR_X1%10_47 x_PM_DFFR_X1%10_29 1.22143
R_x_PM_DFFR_X1%10_r26 x_PM_DFFR_X1%10_39 x_PM_DFFR_X1%10_28 0.266978
R_x_PM_DFFR_X1%10_r27 x_PM_DFFR_X1%10_32 x_PM_DFFR_X1%10_27 0.212317
R_x_PM_DFFR_X1%10_r28 x_PM_DFFR_X1%10_28 x_PM_DFFR_X1%10_27 0.57
R_x_PM_DFFR_X1%10_r29 x_PM_DFFR_X1%10_39 x_PM_DFFR_X1%10_23 0.0272847
R_x_PM_DFFR_X1%10_r30 N_10_M13_d x_PM_DFFR_X1%10_23 0.330741
R_x_PM_DFFR_X1%10_r31 x_PM_DFFR_X1%10_37 x_PM_DFFR_X1%10_22 0.095
R_x_PM_DFFR_X1%10_r32 x_PM_DFFR_X1%10_39 x_PM_DFFR_X1%10_21 0.266978
R_x_PM_DFFR_X1%10_r33 x_PM_DFFR_X1%10_22 x_PM_DFFR_X1%10_21 0.922857
R_x_PM_DFFR_X1%10_r34 x_PM_DFFR_X1%10_49 x_PM_DFFR_X1%10_17 38.22
R_x_PM_DFFR_X1%10_r35 x_PM_DFFR_X1%10_18 x_PM_DFFR_X1%10_17 0.043368
R_x_PM_DFFR_X1%10_r36 x_PM_DFFR_X1%10_18 x_PM_DFFR_X1%10_13 4.56151
R_x_PM_DFFR_X1%10_r37 N_10_M16_g x_PM_DFFR_X1%10_13 49.53
R_x_PM_DFFR_X1%10_r38 x_PM_DFFR_X1%10_18 x_PM_DFFR_X1%10_9 4.56151
R_x_PM_DFFR_X1%10_r39 N_10_M32_g x_PM_DFFR_X1%10_9 71.76
R_x_PM_DFFR_X1%10_r40 x_PM_DFFR_X1%10_53 x_PM_DFFR_X1%10_5 1.95
R_x_PM_DFFR_X1%10_r41 N_10_M12_g x_PM_DFFR_X1%10_5 18.72
R_x_PM_DFFR_X1%10_r42 x_PM_DFFR_X1%10_51 x_PM_DFFR_X1%10_VSS 1.95
R_x_PM_DFFR_X1%10_r43 N_10_M28_g x_PM_DFFR_X1%10_VSS 95.94
C_x_PM_DFFR_X1%RN_c0 VSS x_PM_DFFR_X1%RN_30 1.09572e-17
C_x_PM_DFFR_X1%RN_c1 VSS RN 2.47442e-17
C_x_PM_DFFR_X1%RN_c2 VSS x_PM_DFFR_X1%RN_17 1.76785e-17
C_x_PM_DFFR_X1%RN_c3 VSS N_RN_M13_g 7.96711e-17
C_x_PM_DFFR_X1%RN_c4 VSS N_RN_M29_g 3.82205e-17
C_x_PM_DFFR_X1%RN_c5 VSS x_PM_DFFR_X1%RN_8 5.16029e-18
C_x_PM_DFFR_X1%RN_c6 VSS x_PM_DFFR_X1%RN_7 2.6783e-16
C_x_PM_DFFR_X1%RN_c7 VSS N_RN_M19_g 1.09785e-16
R_x_PM_DFFR_X1%RN_r8 x_PM_DFFR_X1%RN_25 RN 0.19
R_x_PM_DFFR_X1%RN_r9 x_PM_DFFR_X1%RN_30 x_PM_DFFR_X1%RN_20 1.3
R_x_PM_DFFR_X1%RN_r10 x_PM_DFFR_X1%RN_20 x_PM_DFFR_X1%RN_27 3.38
R_x_PM_DFFR_X1%RN_r11 x_PM_DFFR_X1%RN_20 x_PM_DFFR_X1%RN_18 25.0012
R_x_PM_DFFR_X1%RN_r12 x_PM_DFFR_X1%RN_25 x_PM_DFFR_X1%RN_17 0.095
R_x_PM_DFFR_X1%RN_r13 x_PM_DFFR_X1%RN_18 x_PM_DFFR_X1%RN_17 0.230714
R_x_PM_DFFR_X1%RN_r14 N_RN_M13_g x_PM_DFFR_X1%RN_14 28.86
R_x_PM_DFFR_X1%RN_r15 x_PM_DFFR_X1%RN_30 x_PM_DFFR_X1%RN_13 1.95
R_x_PM_DFFR_X1%RN_r16 N_RN_M13_g x_PM_DFFR_X1%RN_13 88.14
R_x_PM_DFFR_X1%RN_r17 x_PM_DFFR_X1%RN_27 x_PM_DFFR_X1%RN_9 1.95
R_x_PM_DFFR_X1%RN_r18 N_RN_M29_g x_PM_DFFR_X1%RN_9 31.2
R_x_PM_DFFR_X1%RN_r19 x_PM_DFFR_X1%RN_14 x_PM_DFFR_X1%RN_7 4.35808
R_x_PM_DFFR_X1%RN_r20 x_PM_DFFR_X1%RN_8 x_PM_DFFR_X1%RN_7 322.92
R_x_PM_DFFR_X1%RN_r21 N_RN_M3_g N_RN_M19_g 113.88
R_x_PM_DFFR_X1%RN_r22 x_PM_DFFR_X1%RN_8 x_PM_DFFR_X1%RN_VSS 4.35808
R_x_PM_DFFR_X1%RN_r23 N_RN_M3_g x_PM_DFFR_X1%RN_VSS 35.88
C_x_PM_DFFR_X1%QN_c0 VSS x_PM_DFFR_X1%QN_15 1.21847e-16
C_x_PM_DFFR_X1%QN_c1 VSS N_QN_M31_s 5.61889e-17
C_x_PM_DFFR_X1%QN_c2 VSS N_QN_M15_s 2.58317e-17
C_x_PM_DFFR_X1%QN_c3 VSS x_PM_DFFR_X1%QN_3 9.66532e-18
R_x_PM_DFFR_X1%QN_r4 x_PM_DFFR_X1%QN_9 N_QN_M31_s 0.30478
R_x_PM_DFFR_X1%QN_r5 x_PM_DFFR_X1%QN_15 x_PM_DFFR_X1%QN_9 3.77286
R_x_PM_DFFR_X1%QN_r6 QN N_QN_M15_s 0.0105556
R_x_PM_DFFR_X1%QN_r7 x_PM_DFFR_X1%QN_15 x_PM_DFFR_X1%QN_3 0.20978
R_x_PM_DFFR_X1%QN_r8 N_QN_M15_s x_PM_DFFR_X1%QN_3 0.095
C_x_PM_DFFR_X1%Q_c0 VSS N_Q_M32_d 1.06362e-16
R_x_PM_DFFR_X1%Q_r1 N_Q_M16_d Q 2.03933
R_x_PM_DFFR_X1%Q_r2 Q N_Q_M32_d 2.09
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFR_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFR_X2 VSS VDD CK D RN QN Q
*.PININFO VSS:B VDD:B CK:I D:I RN:I QN:O Q:O
M_M16 N_VDD_M0_d N_CK_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M17 N_5_M1_d N_6_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M18 14 N_3_M2_g N_6_M2_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M19 N_VDD_M3_d N_RN_M3_g 14 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M20 15 N_5_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M21 N_6_M5_d N_3_M5_g 15 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M22 16 N_7_M6_g N_6_M5_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M23 N_VDD_M7_d N_D_M7_g 16 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M24 N_VDD_M8_d N_3_M8_g N_7_M8_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M25 17 N_6_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_9_M10_d N_3_M10_g 17 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 18 N_7_M11_g N_9_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 N_VDD_M12_d N_10_M12_g 18 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_10_M13_d N_RN_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_VDD_M14_d N_9_M14_g N_10_M13_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M15_d N_9_M15_g N_QN_M15_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M32 N_Q_M16_d N_10_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M17_d N_CK_M17_g N_3_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M18_d N_6_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 19 N_RN_M19_g N_VSS_M19_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 20 N_5_M20_g 19 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_6_M21_d N_7_M21_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 21 N_3_M22_g N_6_M21_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M23_d N_D_M23_g 21 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M24_d N_3_M24_g N_7_M24_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 22 N_6_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_9_M26_d N_7_M26_g 22 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 23 N_3_M27_g N_9_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M28_d N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 24 N_RN_M29_g N_VSS_M28_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M13 N_10_M30_d N_9_M30_g 24 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VSS_M31_d N_9_M31_g N_QN_M31_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_Q_M32_d N_10_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_DFFR_X2%VSS_c0 VSS N_VSS_M31_d 6.4082e-17
C_x_PM_DFFR_X2%VSS_c1 VSS x_PM_DFFR_X2%VSS_39 6.34875e-18
C_x_PM_DFFR_X2%VSS_c2 VSS x_PM_DFFR_X2%VSS_38 8.87792e-18
C_x_PM_DFFR_X2%VSS_c3 VSS x_PM_DFFR_X2%VSS_37 8.86015e-18
C_x_PM_DFFR_X2%VSS_c4 VSS x_PM_DFFR_X2%VSS_36 8.86015e-18
C_x_PM_DFFR_X2%VSS_c5 VSS x_PM_DFFR_X2%VSS_31 5.45409e-17
C_x_PM_DFFR_X2%VSS_c6 VSS x_PM_DFFR_X2%VSS_27 9.26096e-17
C_x_PM_DFFR_X2%VSS_c7 VSS x_PM_DFFR_X2%VSS_26 2.67352e-17
C_x_PM_DFFR_X2%VSS_c8 VSS x_PM_DFFR_X2%VSS_23 6.10626e-17
C_x_PM_DFFR_X2%VSS_c9 VSS x_PM_DFFR_X2%VSS_22 4.27761e-17
C_x_PM_DFFR_X2%VSS_c10 VSS x_PM_DFFR_X2%VSS_17 1.80411e-17
C_x_PM_DFFR_X2%VSS_c11 VSS x_PM_DFFR_X2%VSS_16 4.59799e-17
C_x_PM_DFFR_X2%VSS_c12 VSS x_PM_DFFR_X2%VSS_13 8.85074e-17
C_x_PM_DFFR_X2%VSS_c13 VSS x_PM_DFFR_X2%VSS_12 5.19747e-17
C_x_PM_DFFR_X2%VSS_c14 VSS x_PM_DFFR_X2%VSS_9 5.85257e-17
R_x_PM_DFFR_X2%VSS_r15 N_VSS_M17_d x_PM_DFFR_X2%VSS_31 0.471481
R_x_PM_DFFR_X2%VSS_r16 x_PM_DFFR_X2%VSS_39 x_PM_DFFR_X2%VSS_28 0.132285
R_x_PM_DFFR_X2%VSS_r17 x_PM_DFFR_X2%VSS_27 N_VSS_M31_d 0.140674
R_x_PM_DFFR_X2%VSS_r18 x_PM_DFFR_X2%VSS_28 x_PM_DFFR_X2%VSS_27 1.56471
R_x_PM_DFFR_X2%VSS_r19 x_PM_DFFR_X2%VSS_39 x_PM_DFFR_X2%VSS_26 0.0680382
R_x_PM_DFFR_X2%VSS_r20 x_PM_DFFR_X2%VSS_26 N_VSS_M28_d 0.473954
R_x_PM_DFFR_X2%VSS_r21 x_PM_DFFR_X2%VSS_38 x_PM_DFFR_X2%VSS_24 0.132285
R_x_PM_DFFR_X2%VSS_r22 x_PM_DFFR_X2%VSS_39 x_PM_DFFR_X2%VSS_23 0.132285
R_x_PM_DFFR_X2%VSS_r23 x_PM_DFFR_X2%VSS_24 x_PM_DFFR_X2%VSS_23 1.41941
R_x_PM_DFFR_X2%VSS_r24 x_PM_DFFR_X2%VSS_38 x_PM_DFFR_X2%VSS_22 0.0680382
R_x_PM_DFFR_X2%VSS_r25 x_PM_DFFR_X2%VSS_22 N_VSS_M24_d 0.473954
R_x_PM_DFFR_X2%VSS_r26 x_PM_DFFR_X2%VSS_37 x_PM_DFFR_X2%VSS_18 0.132285
R_x_PM_DFFR_X2%VSS_r27 VSS x_PM_DFFR_X2%VSS_18 0.38
R_x_PM_DFFR_X2%VSS_r28 x_PM_DFFR_X2%VSS_38 x_PM_DFFR_X2%VSS_17 0.132285
R_x_PM_DFFR_X2%VSS_r29 VSS x_PM_DFFR_X2%VSS_17 0.0894118
R_x_PM_DFFR_X2%VSS_r30 x_PM_DFFR_X2%VSS_37 x_PM_DFFR_X2%VSS_16 0.0680382
R_x_PM_DFFR_X2%VSS_r31 x_PM_DFFR_X2%VSS_16 N_VSS_M23_d 0.403583
R_x_PM_DFFR_X2%VSS_r32 x_PM_DFFR_X2%VSS_36 x_PM_DFFR_X2%VSS_14 0.132285
R_x_PM_DFFR_X2%VSS_r33 x_PM_DFFR_X2%VSS_37 x_PM_DFFR_X2%VSS_13 0.132285
R_x_PM_DFFR_X2%VSS_r34 x_PM_DFFR_X2%VSS_14 x_PM_DFFR_X2%VSS_13 1.84412
R_x_PM_DFFR_X2%VSS_r35 x_PM_DFFR_X2%VSS_36 x_PM_DFFR_X2%VSS_12 0.0680382
R_x_PM_DFFR_X2%VSS_r36 x_PM_DFFR_X2%VSS_12 N_VSS_M19_s 0.403583
R_x_PM_DFFR_X2%VSS_r37 x_PM_DFFR_X2%VSS_31 x_PM_DFFR_X2%VSS_10 0.095
R_x_PM_DFFR_X2%VSS_r38 x_PM_DFFR_X2%VSS_36 x_PM_DFFR_X2%VSS_9 0.132285
R_x_PM_DFFR_X2%VSS_r39 x_PM_DFFR_X2%VSS_10 x_PM_DFFR_X2%VSS_9 0.894118
C_x_PM_DFFR_X2%VDD_c0 VSS N_VDD_M15_d 5.12381e-17
C_x_PM_DFFR_X2%VDD_c1 VSS x_PM_DFFR_X2%VDD_49 5.71189e-18
C_x_PM_DFFR_X2%VDD_c2 VSS x_PM_DFFR_X2%VDD_48 8.89467e-18
C_x_PM_DFFR_X2%VDD_c3 VSS x_PM_DFFR_X2%VDD_47 8.89467e-18
C_x_PM_DFFR_X2%VDD_c4 VSS x_PM_DFFR_X2%VDD_46 4.64531e-18
C_x_PM_DFFR_X2%VDD_c5 VSS x_PM_DFFR_X2%VDD_45 8.93714e-18
C_x_PM_DFFR_X2%VDD_c6 VSS x_PM_DFFR_X2%VDD_44 6.54449e-18
C_x_PM_DFFR_X2%VDD_c7 VSS x_PM_DFFR_X2%VDD_40 2.43648e-17
C_x_PM_DFFR_X2%VDD_c8 VSS N_VDD_M14_d 6.00016e-17
C_x_PM_DFFR_X2%VDD_c9 VSS x_PM_DFFR_X2%VDD_34 1.94196e-17
C_x_PM_DFFR_X2%VDD_c10 VSS x_PM_DFFR_X2%VDD_33 3.3105e-17
C_x_PM_DFFR_X2%VDD_c11 VSS x_PM_DFFR_X2%VDD_30 7.65696e-17
C_x_PM_DFFR_X2%VDD_c12 VSS x_PM_DFFR_X2%VDD_29 4.88911e-17
C_x_PM_DFFR_X2%VDD_c13 VSS x_PM_DFFR_X2%VDD_26 2.20403e-17
C_x_PM_DFFR_X2%VDD_c14 VSS N_VDD_M7_d 3.97377e-17
C_x_PM_DFFR_X2%VDD_c15 VSS x_PM_DFFR_X2%VDD_20 7.04926e-17
C_x_PM_DFFR_X2%VDD_c16 VSS N_VDD_M3_d 3.70234e-17
C_x_PM_DFFR_X2%VDD_c17 VSS x_PM_DFFR_X2%VDD_14 8.27485e-17
C_x_PM_DFFR_X2%VDD_c18 VSS x_PM_DFFR_X2%VDD_13 6.16609e-17
C_x_PM_DFFR_X2%VDD_c19 VSS x_PM_DFFR_X2%VDD_8 1.89578e-17
R_x_PM_DFFR_X2%VDD_r20 x_PM_DFFR_X2%VDD_49 x_PM_DFFR_X2%VDD_41 0.132285
R_x_PM_DFFR_X2%VDD_r21 x_PM_DFFR_X2%VDD_40 N_VDD_M15_d 0.140674
R_x_PM_DFFR_X2%VDD_r22 x_PM_DFFR_X2%VDD_41 x_PM_DFFR_X2%VDD_40 0.558824
R_x_PM_DFFR_X2%VDD_r23 x_PM_DFFR_X2%VDD_49 x_PM_DFFR_X2%VDD_36 0.0680382
R_x_PM_DFFR_X2%VDD_r24 N_VDD_M14_d x_PM_DFFR_X2%VDD_36 0.767037
R_x_PM_DFFR_X2%VDD_r25 x_PM_DFFR_X2%VDD_48 x_PM_DFFR_X2%VDD_35 0.132285
R_x_PM_DFFR_X2%VDD_r26 x_PM_DFFR_X2%VDD_49 x_PM_DFFR_X2%VDD_34 0.132285
R_x_PM_DFFR_X2%VDD_r27 x_PM_DFFR_X2%VDD_35 x_PM_DFFR_X2%VDD_34 0.592353
R_x_PM_DFFR_X2%VDD_r28 x_PM_DFFR_X2%VDD_48 x_PM_DFFR_X2%VDD_33 0.0680382
R_x_PM_DFFR_X2%VDD_r29 x_PM_DFFR_X2%VDD_33 N_VDD_M12_d 0.544324
R_x_PM_DFFR_X2%VDD_r30 x_PM_DFFR_X2%VDD_47 x_PM_DFFR_X2%VDD_31 0.132285
R_x_PM_DFFR_X2%VDD_r31 x_PM_DFFR_X2%VDD_48 x_PM_DFFR_X2%VDD_30 0.132285
R_x_PM_DFFR_X2%VDD_r32 x_PM_DFFR_X2%VDD_31 x_PM_DFFR_X2%VDD_30 1.53118
R_x_PM_DFFR_X2%VDD_r33 x_PM_DFFR_X2%VDD_47 x_PM_DFFR_X2%VDD_29 0.0680382
R_x_PM_DFFR_X2%VDD_r34 x_PM_DFFR_X2%VDD_29 N_VDD_M8_d 0.544324
R_x_PM_DFFR_X2%VDD_r35 x_PM_DFFR_X2%VDD_46 x_PM_DFFR_X2%VDD_27 0.0731438
R_x_PM_DFFR_X2%VDD_r36 x_PM_DFFR_X2%VDD_47 x_PM_DFFR_X2%VDD_26 0.132285
R_x_PM_DFFR_X2%VDD_r37 x_PM_DFFR_X2%VDD_27 x_PM_DFFR_X2%VDD_26 0.536471
R_x_PM_DFFR_X2%VDD_r38 x_PM_DFFR_X2%VDD_46 x_PM_DFFR_X2%VDD_22 0.145286
R_x_PM_DFFR_X2%VDD_r39 N_VDD_M7_d x_PM_DFFR_X2%VDD_22 1.58786
R_x_PM_DFFR_X2%VDD_r40 x_PM_DFFR_X2%VDD_45 x_PM_DFFR_X2%VDD_21 0.132285
R_x_PM_DFFR_X2%VDD_r41 x_PM_DFFR_X2%VDD_46 x_PM_DFFR_X2%VDD_20 0.0731438
R_x_PM_DFFR_X2%VDD_r42 x_PM_DFFR_X2%VDD_21 x_PM_DFFR_X2%VDD_20 1.49765
R_x_PM_DFFR_X2%VDD_r43 x_PM_DFFR_X2%VDD_45 x_PM_DFFR_X2%VDD_16 0.0680382
R_x_PM_DFFR_X2%VDD_r44 N_VDD_M3_d x_PM_DFFR_X2%VDD_16 0.823333
R_x_PM_DFFR_X2%VDD_r45 x_PM_DFFR_X2%VDD_44 x_PM_DFFR_X2%VDD_15 0.148902
R_x_PM_DFFR_X2%VDD_r46 x_PM_DFFR_X2%VDD_45 x_PM_DFFR_X2%VDD_14 0.132285
R_x_PM_DFFR_X2%VDD_r47 x_PM_DFFR_X2%VDD_15 x_PM_DFFR_X2%VDD_14 1.30765
R_x_PM_DFFR_X2%VDD_r48 x_PM_DFFR_X2%VDD_44 x_PM_DFFR_X2%VDD_13 0.0522411
R_x_PM_DFFR_X2%VDD_r49 x_PM_DFFR_X2%VDD_13 N_VDD_M0_d 0.570412
R_x_PM_DFFR_X2%VDD_r50 x_PM_DFFR_X2%VDD_44 x_PM_DFFR_X2%VDD_8 0.148902
R_x_PM_DFFR_X2%VDD_r51 VDD x_PM_DFFR_X2%VDD_8 0.195588
C_x_PM_DFFR_X2%3_c0 VSS x_PM_DFFR_X2%3_57 7.73278e-18
C_x_PM_DFFR_X2%3_c1 VSS x_PM_DFFR_X2%3_56 2.21088e-18
C_x_PM_DFFR_X2%3_c2 VSS x_PM_DFFR_X2%3_53 1.57693e-16
C_x_PM_DFFR_X2%3_c3 VSS N_3_M0_s 6.86069e-17
C_x_PM_DFFR_X2%3_c4 VSS N_3_M17_s 2.95512e-17
C_x_PM_DFFR_X2%3_c5 VSS x_PM_DFFR_X2%3_40 3.01228e-18
C_x_PM_DFFR_X2%3_c6 VSS x_PM_DFFR_X2%3_39 4.41298e-18
C_x_PM_DFFR_X2%3_c7 VSS N_3_M27_g 4.9996e-17
C_x_PM_DFFR_X2%3_c8 VSS x_PM_DFFR_X2%3_34 6.62927e-18
C_x_PM_DFFR_X2%3_c9 VSS x_PM_DFFR_X2%3_33 2.55255e-17
C_x_PM_DFFR_X2%3_c10 VSS N_3_M10_g 6.19738e-17
C_x_PM_DFFR_X2%3_c11 VSS x_PM_DFFR_X2%3_27 6.86742e-17
C_x_PM_DFFR_X2%3_c12 VSS N_3_M24_g 1.17568e-16
C_x_PM_DFFR_X2%3_c13 VSS x_PM_DFFR_X2%3_19 5.38458e-17
C_x_PM_DFFR_X2%3_c14 VSS N_3_M22_g 3.53982e-17
C_x_PM_DFFR_X2%3_c15 VSS x_PM_DFFR_X2%3_14 6.92227e-18
C_x_PM_DFFR_X2%3_c16 VSS x_PM_DFFR_X2%3_13 8.50218e-17
C_x_PM_DFFR_X2%3_c17 VSS N_3_M5_g 2.8057e-17
C_x_PM_DFFR_X2%3_c18 VSS x_PM_DFFR_X2%3_8 6.46987e-18
C_x_PM_DFFR_X2%3_c19 VSS x_PM_DFFR_X2%3_7 9.28796e-17
C_x_PM_DFFR_X2%3_c20 VSS N_3_M2_g 6.71123e-17
C_x_PM_DFFR_X2%3_c21 VSS x_PM_DFFR_X2%3_2 4.28086e-17
R_x_PM_DFFR_X2%3_r22 x_PM_DFFR_X2%3_59 x_PM_DFFR_X2%3_57 4.7687
R_x_PM_DFFR_X2%3_r23 x_PM_DFFR_X2%3_57 x_PM_DFFR_X2%3_53 25.0012
R_x_PM_DFFR_X2%3_r24 x_PM_DFFR_X2%3_56 x_PM_DFFR_X2%3_51 0.0418175
R_x_PM_DFFR_X2%3_r25 x_PM_DFFR_X2%3_53 x_PM_DFFR_X2%3_51 3.135
R_x_PM_DFFR_X2%3_r26 x_PM_DFFR_X2%3_56 x_PM_DFFR_X2%3_47 0.160909
R_x_PM_DFFR_X2%3_r27 N_3_M0_s x_PM_DFFR_X2%3_47 2.45643
R_x_PM_DFFR_X2%3_r28 x_PM_DFFR_X2%3_56 x_PM_DFFR_X2%3_43 0.160909
R_x_PM_DFFR_X2%3_r29 N_3_M17_s x_PM_DFFR_X2%3_43 1.15357
R_x_PM_DFFR_X2%3_r30 N_3_M27_g x_PM_DFFR_X2%3_36 52.26
R_x_PM_DFFR_X2%3_r31 N_3_M27_g x_PM_DFFR_X2%3_35 30.42
R_x_PM_DFFR_X2%3_r32 x_PM_DFFR_X2%3_36 x_PM_DFFR_X2%3_33 4.35808
R_x_PM_DFFR_X2%3_r33 x_PM_DFFR_X2%3_34 x_PM_DFFR_X2%3_33 23.4
R_x_PM_DFFR_X2%3_r34 x_PM_DFFR_X2%3_34 x_PM_DFFR_X2%3_29 4.35808
R_x_PM_DFFR_X2%3_r35 N_3_M10_g x_PM_DFFR_X2%3_29 51.48
R_x_PM_DFFR_X2%3_r36 x_PM_DFFR_X2%3_40 x_PM_DFFR_X2%3_28 3.30287
R_x_PM_DFFR_X2%3_r37 x_PM_DFFR_X2%3_35 x_PM_DFFR_X2%3_27 4.35808
R_x_PM_DFFR_X2%3_r38 x_PM_DFFR_X2%3_28 x_PM_DFFR_X2%3_27 82.68
R_x_PM_DFFR_X2%3_r39 N_3_M8_g N_3_M24_g 111.54
R_x_PM_DFFR_X2%3_r40 N_3_M8_g x_PM_DFFR_X2%3_22 21.84
R_x_PM_DFFR_X2%3_r41 x_PM_DFFR_X2%3_40 x_PM_DFFR_X2%3_21 0.858359
R_x_PM_DFFR_X2%3_r42 N_3_M24_g x_PM_DFFR_X2%3_21 37.44
R_x_PM_DFFR_X2%3_r43 x_PM_DFFR_X2%3_39 x_PM_DFFR_X2%3_20 3.30287
R_x_PM_DFFR_X2%3_r44 x_PM_DFFR_X2%3_40 x_PM_DFFR_X2%3_19 3.30287
R_x_PM_DFFR_X2%3_r45 x_PM_DFFR_X2%3_20 x_PM_DFFR_X2%3_19 74.88
R_x_PM_DFFR_X2%3_r46 x_PM_DFFR_X2%3_39 x_PM_DFFR_X2%3_15 0.858359
R_x_PM_DFFR_X2%3_r47 N_3_M22_g x_PM_DFFR_X2%3_15 33.54
R_x_PM_DFFR_X2%3_r48 x_PM_DFFR_X2%3_22 x_PM_DFFR_X2%3_13 4.35808
R_x_PM_DFFR_X2%3_r49 x_PM_DFFR_X2%3_14 x_PM_DFFR_X2%3_13 106.86
R_x_PM_DFFR_X2%3_r50 x_PM_DFFR_X2%3_14 x_PM_DFFR_X2%3_9 4.35808
R_x_PM_DFFR_X2%3_r51 N_3_M5_g x_PM_DFFR_X2%3_9 26.52
R_x_PM_DFFR_X2%3_r52 x_PM_DFFR_X2%3_39 x_PM_DFFR_X2%3_7 3.30287
R_x_PM_DFFR_X2%3_r53 x_PM_DFFR_X2%3_8 x_PM_DFFR_X2%3_7 117
R_x_PM_DFFR_X2%3_r54 N_3_M2_g x_PM_DFFR_X2%3_59 50.7
R_x_PM_DFFR_X2%3_r55 x_PM_DFFR_X2%3_2 x_PM_DFFR_X2%3_57 4.7687
R_x_PM_DFFR_X2%3_r56 x_PM_DFFR_X2%3_8 x_PM_DFFR_X2%3_VSS 4.35808
R_x_PM_DFFR_X2%3_r57 x_PM_DFFR_X2%3_2 x_PM_DFFR_X2%3_VSS 60.84
C_x_PM_DFFR_X2%CK_c0 VSS CK 7.11296e-17
C_x_PM_DFFR_X2%CK_c1 VSS x_PM_DFFR_X2%CK_11 1.28665e-17
C_x_PM_DFFR_X2%CK_c2 VSS N_CK_M0_g 4.64717e-17
C_x_PM_DFFR_X2%CK_c3 VSS N_CK_M17_g 7.201e-17
R_x_PM_DFFR_X2%CK_r4 x_PM_DFFR_X2%CK_11 x_PM_DFFR_X2%CK_16 3.9
R_x_PM_DFFR_X2%CK_r5 x_PM_DFFR_X2%CK_11 x_PM_DFFR_X2%CK_9 25.0012
R_x_PM_DFFR_X2%CK_r6 CK x_PM_DFFR_X2%CK_9 0.178485
R_x_PM_DFFR_X2%CK_r7 x_PM_DFFR_X2%CK_16 x_PM_DFFR_X2%CK_5 1.95
R_x_PM_DFFR_X2%CK_r8 N_CK_M0_g x_PM_DFFR_X2%CK_5 28.86
R_x_PM_DFFR_X2%CK_r9 x_PM_DFFR_X2%CK_16 x_PM_DFFR_X2%CK_VSS 1.95
R_x_PM_DFFR_X2%CK_r10 N_CK_M17_g x_PM_DFFR_X2%CK_VSS 75.66
C_x_PM_DFFR_X2%5_c0 VSS x_PM_DFFR_X2%5_29 8.06552e-18
C_x_PM_DFFR_X2%5_c1 VSS x_PM_DFFR_X2%5_28 1.34943e-17
C_x_PM_DFFR_X2%5_c2 VSS x_PM_DFFR_X2%5_25 3.16113e-17
C_x_PM_DFFR_X2%5_c3 VSS x_PM_DFFR_X2%5_22 2.60558e-17
C_x_PM_DFFR_X2%5_c4 VSS x_PM_DFFR_X2%5_20 3.56433e-17
C_x_PM_DFFR_X2%5_c5 VSS x_PM_DFFR_X2%5_19 6.52148e-17
C_x_PM_DFFR_X2%5_c6 VSS x_PM_DFFR_X2%5_18 2.13668e-17
C_x_PM_DFFR_X2%5_c7 VSS x_PM_DFFR_X2%5_17 1.08491e-16
C_x_PM_DFFR_X2%5_c8 VSS N_5_M1_d 9.92731e-17
C_x_PM_DFFR_X2%5_c9 VSS x_PM_DFFR_X2%5_12 6.0583e-17
C_x_PM_DFFR_X2%5_c10 VSS N_5_M4_g 6.97765e-17
C_x_PM_DFFR_X2%5_c11 VSS N_5_M20_g 2.07063e-17
R_x_PM_DFFR_X2%5_r12 x_PM_DFFR_X2%5_31 x_PM_DFFR_X2%5_29 4.7687
R_x_PM_DFFR_X2%5_r13 x_PM_DFFR_X2%5_29 x_PM_DFFR_X2%5_25 25.0012
R_x_PM_DFFR_X2%5_r14 x_PM_DFFR_X2%5_28 x_PM_DFFR_X2%5_23 0.156262
R_x_PM_DFFR_X2%5_r15 x_PM_DFFR_X2%5_25 x_PM_DFFR_X2%5_23 1.026
R_x_PM_DFFR_X2%5_r16 x_PM_DFFR_X2%5_28 x_PM_DFFR_X2%5_21 0.0457628
R_x_PM_DFFR_X2%5_r17 x_PM_DFFR_X2%5_22 x_PM_DFFR_X2%5_21 1.11286
R_x_PM_DFFR_X2%5_r18 x_PM_DFFR_X2%5_28 x_PM_DFFR_X2%5_19 0.156262
R_x_PM_DFFR_X2%5_r19 x_PM_DFFR_X2%5_20 x_PM_DFFR_X2%5_19 1.57429
R_x_PM_DFFR_X2%5_r20 x_PM_DFFR_X2%5_22 x_PM_DFFR_X2%5_17 0.212317
R_x_PM_DFFR_X2%5_r21 x_PM_DFFR_X2%5_18 x_PM_DFFR_X2%5_17 1.79143
R_x_PM_DFFR_X2%5_r22 x_PM_DFFR_X2%5_18 x_PM_DFFR_X2%5_13 0.212317
R_x_PM_DFFR_X2%5_r23 N_5_M1_d x_PM_DFFR_X2%5_13 1.88643
R_x_PM_DFFR_X2%5_r24 x_PM_DFFR_X2%5_20 x_PM_DFFR_X2%5_12 0.241334
R_x_PM_DFFR_X2%5_r25 x_PM_DFFR_X2%5_12 N_5_M18_d 0.403583
R_x_PM_DFFR_X2%5_r26 N_5_M4_g x_PM_DFFR_X2%5_31 91.26
R_x_PM_DFFR_X2%5_r27 x_PM_DFFR_X2%5_VSS x_PM_DFFR_X2%5_29 4.7687
R_x_PM_DFFR_X2%5_r28 N_5_M20_g x_PM_DFFR_X2%5_VSS 14.82
C_x_PM_DFFR_X2%6_c0 VSS x_PM_DFFR_X2%6_48 8.18675e-18
C_x_PM_DFFR_X2%6_c1 VSS x_PM_DFFR_X2%6_44 1.13842e-16
C_x_PM_DFFR_X2%6_c2 VSS x_PM_DFFR_X2%6_42 3.86886e-17
C_x_PM_DFFR_X2%6_c3 VSS x_PM_DFFR_X2%6_40 3.45199e-18
C_x_PM_DFFR_X2%6_c4 VSS N_6_M21_d 2.14683e-17
C_x_PM_DFFR_X2%6_c5 VSS x_PM_DFFR_X2%6_32 1.29103e-17
C_x_PM_DFFR_X2%6_c6 VSS x_PM_DFFR_X2%6_31 4.84217e-17
C_x_PM_DFFR_X2%6_c7 VSS x_PM_DFFR_X2%6_29 3.45167e-17
C_x_PM_DFFR_X2%6_c8 VSS x_PM_DFFR_X2%6_28 8.73954e-17
C_x_PM_DFFR_X2%6_c9 VSS N_6_M2_s 5.58971e-17
C_x_PM_DFFR_X2%6_c10 VSS x_PM_DFFR_X2%6_22 1.37085e-17
C_x_PM_DFFR_X2%6_c11 VSS x_PM_DFFR_X2%6_19 7.80022e-17
C_x_PM_DFFR_X2%6_c12 VSS x_PM_DFFR_X2%6_15 8.35991e-18
C_x_PM_DFFR_X2%6_c13 VSS N_6_M9_g 4.06846e-17
C_x_PM_DFFR_X2%6_c14 VSS N_6_M25_g 5.96788e-17
C_x_PM_DFFR_X2%6_c15 VSS N_6_M18_g 1.26821e-16
R_x_PM_DFFR_X2%6_r16 x_PM_DFFR_X2%6_50 x_PM_DFFR_X2%6_48 4.7687
R_x_PM_DFFR_X2%6_r17 x_PM_DFFR_X2%6_44 x_PM_DFFR_X2%6_42 0.30478
R_x_PM_DFFR_X2%6_r18 x_PM_DFFR_X2%6_48 x_PM_DFFR_X2%6_42 25.0012
R_x_PM_DFFR_X2%6_r19 N_6_M5_d x_PM_DFFR_X2%6_44 3.97643
R_x_PM_DFFR_X2%6_r20 x_PM_DFFR_X2%6_40 x_PM_DFFR_X2%6_37 0.160909
R_x_PM_DFFR_X2%6_r21 N_6_M5_d x_PM_DFFR_X2%6_37 0.312143
R_x_PM_DFFR_X2%6_r22 N_6_M21_d x_PM_DFFR_X2%6_32 0.312143
R_x_PM_DFFR_X2%6_r23 x_PM_DFFR_X2%6_40 x_PM_DFFR_X2%6_31 0.0418175
R_x_PM_DFFR_X2%6_r24 x_PM_DFFR_X2%6_32 x_PM_DFFR_X2%6_30 0.212317
R_x_PM_DFFR_X2%6_r25 x_PM_DFFR_X2%6_31 x_PM_DFFR_X2%6_30 2.00857
R_x_PM_DFFR_X2%6_r26 x_PM_DFFR_X2%6_40 x_PM_DFFR_X2%6_28 0.160909
R_x_PM_DFFR_X2%6_r27 x_PM_DFFR_X2%6_29 x_PM_DFFR_X2%6_28 3.33857
R_x_PM_DFFR_X2%6_r28 N_6_M2_s x_PM_DFFR_X2%6_25 1.12643
R_x_PM_DFFR_X2%6_r29 x_PM_DFFR_X2%6_29 x_PM_DFFR_X2%6_24 0.212317
R_x_PM_DFFR_X2%6_r30 N_6_M2_s x_PM_DFFR_X2%6_24 0.746429
R_x_PM_DFFR_X2%6_r31 x_PM_DFFR_X2%6_22 x_PM_DFFR_X2%6_20 25.0012
R_x_PM_DFFR_X2%6_r32 x_PM_DFFR_X2%6_25 x_PM_DFFR_X2%6_19 0.212317
R_x_PM_DFFR_X2%6_r33 x_PM_DFFR_X2%6_20 x_PM_DFFR_X2%6_19 0.583571
R_x_PM_DFFR_X2%6_r34 x_PM_DFFR_X2%6_22 x_PM_DFFR_X2%6_15 8.06
R_x_PM_DFFR_X2%6_r35 N_6_M9_g x_PM_DFFR_X2%6_50 28.86
R_x_PM_DFFR_X2%6_r36 x_PM_DFFR_X2%6_7 x_PM_DFFR_X2%6_48 4.7687
R_x_PM_DFFR_X2%6_r37 N_6_M25_g x_PM_DFFR_X2%6_7 70.98
R_x_PM_DFFR_X2%6_r38 N_6_M1_g N_6_M18_g 137.28
R_x_PM_DFFR_X2%6_r39 x_PM_DFFR_X2%6_15 x_PM_DFFR_X2%6_VSS 4.58872
R_x_PM_DFFR_X2%6_r40 N_6_M1_g x_PM_DFFR_X2%6_VSS 18.72
C_x_PM_DFFR_X2%7_c0 VSS x_PM_DFFR_X2%7_52 1.45386e-17
C_x_PM_DFFR_X2%7_c1 VSS x_PM_DFFR_X2%7_49 6.83616e-18
C_x_PM_DFFR_X2%7_c2 VSS x_PM_DFFR_X2%7_41 3.17028e-17
C_x_PM_DFFR_X2%7_c3 VSS x_PM_DFFR_X2%7_40 9.30216e-17
C_x_PM_DFFR_X2%7_c4 VSS x_PM_DFFR_X2%7_39 9.83245e-18
C_x_PM_DFFR_X2%7_c5 VSS x_PM_DFFR_X2%7_37 8.77082e-17
C_x_PM_DFFR_X2%7_c6 VSS x_PM_DFFR_X2%7_36 2.34703e-17
C_x_PM_DFFR_X2%7_c7 VSS x_PM_DFFR_X2%7_35 7.03516e-18
C_x_PM_DFFR_X2%7_c8 VSS x_PM_DFFR_X2%7_34 4.13912e-17
C_x_PM_DFFR_X2%7_c9 VSS x_PM_DFFR_X2%7_32 7.45381e-17
C_x_PM_DFFR_X2%7_c10 VSS x_PM_DFFR_X2%7_29 2.14121e-17
C_x_PM_DFFR_X2%7_c11 VSS x_PM_DFFR_X2%7_28 7.57811e-17
C_x_PM_DFFR_X2%7_c12 VSS x_PM_DFFR_X2%7_27 6.38946e-18
C_x_PM_DFFR_X2%7_c13 VSS x_PM_DFFR_X2%7_21 4.39365e-17
C_x_PM_DFFR_X2%7_c14 VSS N_7_M11_g 2.58988e-17
C_x_PM_DFFR_X2%7_c15 VSS N_7_M26_g 2.06375e-17
C_x_PM_DFFR_X2%7_c16 VSS N_7_M6_g 5.56701e-17
C_x_PM_DFFR_X2%7_c17 VSS x_PM_DFFR_X2%7_7 6.38875e-18
C_x_PM_DFFR_X2%7_c18 VSS x_PM_DFFR_X2%7_6 9.7835e-18
C_x_PM_DFFR_X2%7_c19 VSS x_PM_DFFR_X2%7_5 1.93071e-17
C_x_PM_DFFR_X2%7_c20 VSS N_7_M21_g 4.34148e-17
R_x_PM_DFFR_X2%7_r21 x_PM_DFFR_X2%7_52 x_PM_DFFR_X2%7_50 5.46
R_x_PM_DFFR_X2%7_r22 x_PM_DFFR_X2%7_50 x_PM_DFFR_X2%7_47 25.0012
R_x_PM_DFFR_X2%7_r23 N_7_M8_s x_PM_DFFR_X2%7_41 0.162857
R_x_PM_DFFR_X2%7_r24 x_PM_DFFR_X2%7_49 x_PM_DFFR_X2%7_40 0.113465
R_x_PM_DFFR_X2%7_r25 x_PM_DFFR_X2%7_56 x_PM_DFFR_X2%7_39 4.7687
R_x_PM_DFFR_X2%7_r26 x_PM_DFFR_X2%7_40 x_PM_DFFR_X2%7_38 0.403583
R_x_PM_DFFR_X2%7_r27 x_PM_DFFR_X2%7_39 x_PM_DFFR_X2%7_38 25.0012
R_x_PM_DFFR_X2%7_r28 x_PM_DFFR_X2%7_49 x_PM_DFFR_X2%7_37 0.0883294
R_x_PM_DFFR_X2%7_r29 x_PM_DFFR_X2%7_47 x_PM_DFFR_X2%7_36 0.198162
R_x_PM_DFFR_X2%7_r30 x_PM_DFFR_X2%7_37 x_PM_DFFR_X2%7_36 2.22571
R_x_PM_DFFR_X2%7_r31 x_PM_DFFR_X2%7_47 x_PM_DFFR_X2%7_34 0.0141545
R_x_PM_DFFR_X2%7_r32 x_PM_DFFR_X2%7_35 x_PM_DFFR_X2%7_34 1.9
R_x_PM_DFFR_X2%7_r33 x_PM_DFFR_X2%7_41 x_PM_DFFR_X2%7_33 0.095
R_x_PM_DFFR_X2%7_r34 x_PM_DFFR_X2%7_49 x_PM_DFFR_X2%7_32 0.113465
R_x_PM_DFFR_X2%7_r35 x_PM_DFFR_X2%7_33 x_PM_DFFR_X2%7_32 1.92533
R_x_PM_DFFR_X2%7_r36 N_7_M24_s x_PM_DFFR_X2%7_29 1.18524
R_x_PM_DFFR_X2%7_r37 x_PM_DFFR_X2%7_35 x_PM_DFFR_X2%7_28 0.232321
R_x_PM_DFFR_X2%7_r38 N_7_M24_s x_PM_DFFR_X2%7_28 0.0542857
R_x_PM_DFFR_X2%7_r39 x_PM_DFFR_X2%7_29 x_PM_DFFR_X2%7_26 0.223553
R_x_PM_DFFR_X2%7_r40 x_PM_DFFR_X2%7_27 x_PM_DFFR_X2%7_26 0.352857
R_x_PM_DFFR_X2%7_r41 x_PM_DFFR_X2%7_24 x_PM_DFFR_X2%7_22 25.0012
R_x_PM_DFFR_X2%7_r42 x_PM_DFFR_X2%7_27 x_PM_DFFR_X2%7_21 0.212317
R_x_PM_DFFR_X2%7_r43 x_PM_DFFR_X2%7_22 x_PM_DFFR_X2%7_21 0.312143
R_x_PM_DFFR_X2%7_r44 N_7_M11_g x_PM_DFFR_X2%7_56 18.72
R_x_PM_DFFR_X2%7_r45 x_PM_DFFR_X2%7_52 x_PM_DFFR_X2%7_11 1.95
R_x_PM_DFFR_X2%7_r46 N_7_M26_g x_PM_DFFR_X2%7_11 14.82
R_x_PM_DFFR_X2%7_r47 x_PM_DFFR_X2%7_24 x_PM_DFFR_X2%7_7 4.03807
R_x_PM_DFFR_X2%7_r48 N_7_M6_g x_PM_DFFR_X2%7_7 44.46
R_x_PM_DFFR_X2%7_r49 x_PM_DFFR_X2%7_24 x_PM_DFFR_X2%7_5 0.550646
R_x_PM_DFFR_X2%7_r50 x_PM_DFFR_X2%7_6 x_PM_DFFR_X2%7_5 16.12
R_x_PM_DFFR_X2%7_r51 x_PM_DFFR_X2%7_6 x_PM_DFFR_X2%7_VSS 4.58872
R_x_PM_DFFR_X2%7_r52 N_7_M21_g x_PM_DFFR_X2%7_VSS 40.56
C_x_PM_DFFR_X2%D_c0 VSS D 9.71385e-17
C_x_PM_DFFR_X2%D_c1 VSS x_PM_DFFR_X2%D_11 7.94792e-18
C_x_PM_DFFR_X2%D_c2 VSS N_D_M7_g 5.25079e-17
C_x_PM_DFFR_X2%D_c3 VSS N_D_M23_g 4.59146e-17
R_x_PM_DFFR_X2%D_r4 x_PM_DFFR_X2%D_18 x_PM_DFFR_X2%D_11 4.74714
R_x_PM_DFFR_X2%D_r5 x_PM_DFFR_X2%D_17 x_PM_DFFR_X2%D_11 4.74714
R_x_PM_DFFR_X2%D_r6 x_PM_DFFR_X2%D_11 x_PM_DFFR_X2%D_9 25.0012
R_x_PM_DFFR_X2%D_r7 D x_PM_DFFR_X2%D_9 0.266
R_x_PM_DFFR_X2%D_r8 N_D_M7_g x_PM_DFFR_X2%D_18 39
R_x_PM_DFFR_X2%D_r9 N_D_M23_g x_PM_DFFR_X2%D_17 39
C_x_PM_DFFR_X2%9_c0 VSS x_PM_DFFR_X2%9_51 5.05737e-17
C_x_PM_DFFR_X2%9_c1 VSS x_PM_DFFR_X2%9_48 1.23443e-16
C_x_PM_DFFR_X2%9_c2 VSS x_PM_DFFR_X2%9_44 5.2381e-17
C_x_PM_DFFR_X2%9_c3 VSS x_PM_DFFR_X2%9_42 3.25144e-17
C_x_PM_DFFR_X2%9_c4 VSS x_PM_DFFR_X2%9_41 1.13594e-17
C_x_PM_DFFR_X2%9_c5 VSS x_PM_DFFR_X2%9_40 6.43862e-17
C_x_PM_DFFR_X2%9_c6 VSS x_PM_DFFR_X2%9_39 3.69181e-18
C_x_PM_DFFR_X2%9_c7 VSS N_9_M26_d 1.59994e-17
C_x_PM_DFFR_X2%9_c8 VSS x_PM_DFFR_X2%9_31 6.41834e-17
C_x_PM_DFFR_X2%9_c9 VSS x_PM_DFFR_X2%9_28 1.19357e-17
C_x_PM_DFFR_X2%9_c10 VSS x_PM_DFFR_X2%9_26 7.68253e-18
C_x_PM_DFFR_X2%9_c11 VSS N_9_M15_g 4.80935e-17
C_x_PM_DFFR_X2%9_c12 VSS N_9_M31_g 4.36836e-17
C_x_PM_DFFR_X2%9_c13 VSS x_PM_DFFR_X2%9_15 1.99304e-17
C_x_PM_DFFR_X2%9_c14 VSS x_PM_DFFR_X2%9_13 1.86423e-17
C_x_PM_DFFR_X2%9_c15 VSS x_PM_DFFR_X2%9_12 6.88424e-18
C_x_PM_DFFR_X2%9_c16 VSS x_PM_DFFR_X2%9_11 1.06319e-17
C_x_PM_DFFR_X2%9_c17 VSS N_9_M14_g 2.15364e-17
C_x_PM_DFFR_X2%9_c18 VSS x_PM_DFFR_X2%9_6 5.85767e-18
C_x_PM_DFFR_X2%9_c19 VSS x_PM_DFFR_X2%9_5 1.79305e-17
C_x_PM_DFFR_X2%9_c20 VSS N_9_M30_g 4.20824e-17
R_x_PM_DFFR_X2%9_r21 x_PM_DFFR_X2%9_51 x_PM_DFFR_X2%9_48 25.0012
R_x_PM_DFFR_X2%9_r22 x_PM_DFFR_X2%9_48 x_PM_DFFR_X2%9_46 3.86786
R_x_PM_DFFR_X2%9_r23 x_PM_DFFR_X2%9_46 x_PM_DFFR_X2%9_43 0.095
R_x_PM_DFFR_X2%9_r24 x_PM_DFFR_X2%9_44 x_PM_DFFR_X2%9_43 1.79143
R_x_PM_DFFR_X2%9_r25 x_PM_DFFR_X2%9_46 x_PM_DFFR_X2%9_41 0.19
R_x_PM_DFFR_X2%9_r26 x_PM_DFFR_X2%9_42 x_PM_DFFR_X2%9_41 0.705714
R_x_PM_DFFR_X2%9_r27 x_PM_DFFR_X2%9_42 x_PM_DFFR_X2%9_40 0.212317
R_x_PM_DFFR_X2%9_r28 x_PM_DFFR_X2%9_40 x_PM_DFFR_X2%9_39 1.65571
R_x_PM_DFFR_X2%9_r29 x_PM_DFFR_X2%9_39 x_PM_DFFR_X2%9_35 0.192227
R_x_PM_DFFR_X2%9_r30 N_9_M26_d x_PM_DFFR_X2%9_35 0.152
R_x_PM_DFFR_X2%9_r31 x_PM_DFFR_X2%9_44 x_PM_DFFR_X2%9_31 0.212317
R_x_PM_DFFR_X2%9_r32 N_9_M10_d x_PM_DFFR_X2%9_31 0.963571
R_x_PM_DFFR_X2%9_r33 x_PM_DFFR_X2%9_51 x_PM_DFFR_X2%9_27 12.5125
R_x_PM_DFFR_X2%9_r34 x_PM_DFFR_X2%9_28 x_PM_DFFR_X2%9_27 0.974676
R_x_PM_DFFR_X2%9_r35 x_PM_DFFR_X2%9_51 x_PM_DFFR_X2%9_25 15.4375
R_x_PM_DFFR_X2%9_r36 x_PM_DFFR_X2%9_26 x_PM_DFFR_X2%9_25 0.974676
R_x_PM_DFFR_X2%9_r37 N_9_M15_g x_PM_DFFR_X2%9_21 36.66
R_x_PM_DFFR_X2%9_r38 N_9_M31_g x_PM_DFFR_X2%9_17 35.88
R_x_PM_DFFR_X2%9_r39 x_PM_DFFR_X2%9_28 x_PM_DFFR_X2%9_16 6.35445
R_x_PM_DFFR_X2%9_r40 x_PM_DFFR_X2%9_21 x_PM_DFFR_X2%9_15 4.35808
R_x_PM_DFFR_X2%9_r41 x_PM_DFFR_X2%9_16 x_PM_DFFR_X2%9_15 17.94
R_x_PM_DFFR_X2%9_r42 x_PM_DFFR_X2%9_26 x_PM_DFFR_X2%9_14 6.35445
R_x_PM_DFFR_X2%9_r43 x_PM_DFFR_X2%9_17 x_PM_DFFR_X2%9_13 4.35808
R_x_PM_DFFR_X2%9_r44 x_PM_DFFR_X2%9_14 x_PM_DFFR_X2%9_13 17.94
R_x_PM_DFFR_X2%9_r45 x_PM_DFFR_X2%9_28 x_PM_DFFR_X2%9_11 6.35445
R_x_PM_DFFR_X2%9_r46 x_PM_DFFR_X2%9_12 x_PM_DFFR_X2%9_11 15.6
R_x_PM_DFFR_X2%9_r47 x_PM_DFFR_X2%9_12 x_PM_DFFR_X2%9_7 4.35808
R_x_PM_DFFR_X2%9_r48 N_9_M14_g x_PM_DFFR_X2%9_7 14.82
R_x_PM_DFFR_X2%9_r49 x_PM_DFFR_X2%9_26 x_PM_DFFR_X2%9_5 6.35445
R_x_PM_DFFR_X2%9_r50 x_PM_DFFR_X2%9_6 x_PM_DFFR_X2%9_5 26.52
R_x_PM_DFFR_X2%9_r51 x_PM_DFFR_X2%9_6 x_PM_DFFR_X2%9_VSS 4.35808
R_x_PM_DFFR_X2%9_r52 N_9_M30_g x_PM_DFFR_X2%9_VSS 28.86
C_x_PM_DFFR_X2%10_c0 VSS x_PM_DFFR_X2%10_45 1.6544e-17
C_x_PM_DFFR_X2%10_c1 VSS x_PM_DFFR_X2%10_43 7.47901e-17
C_x_PM_DFFR_X2%10_c2 VSS x_PM_DFFR_X2%10_39 2.33308e-17
C_x_PM_DFFR_X2%10_c3 VSS x_PM_DFFR_X2%10_38 5.92646e-17
C_x_PM_DFFR_X2%10_c4 VSS x_PM_DFFR_X2%10_36 9.58245e-17
C_x_PM_DFFR_X2%10_c5 VSS N_10_M30_d 7.324e-17
C_x_PM_DFFR_X2%10_c6 VSS N_10_M13_d 2.56072e-17
C_x_PM_DFFR_X2%10_c7 VSS x_PM_DFFR_X2%10_26 1.32221e-17
C_x_PM_DFFR_X2%10_c8 VSS x_PM_DFFR_X2%10_23 5.73667e-17
C_x_PM_DFFR_X2%10_c9 VSS x_PM_DFFR_X2%10_20 7.48087e-18
C_x_PM_DFFR_X2%10_c10 VSS x_PM_DFFR_X2%10_19 2.2434e-17
C_x_PM_DFFR_X2%10_c11 VSS x_PM_DFFR_X2%10_18 5.91319e-18
C_x_PM_DFFR_X2%10_c12 VSS N_10_M16_g 7.42893e-17
C_x_PM_DFFR_X2%10_c13 VSS N_10_M32_g 7.54618e-17
C_x_PM_DFFR_X2%10_c14 VSS N_10_M12_g 2.72679e-17
C_x_PM_DFFR_X2%10_c15 VSS N_10_M28_g 6.78591e-17
R_x_PM_DFFR_X2%10_r16 x_PM_DFFR_X2%10_44 x_PM_DFFR_X2%10_43 25.0012
R_x_PM_DFFR_X2%10_r17 x_PM_DFFR_X2%10_43 x_PM_DFFR_X2%10_41 0.827857
R_x_PM_DFFR_X2%10_r18 x_PM_DFFR_X2%10_43 x_PM_DFFR_X2%10_40 0.719286
R_x_PM_DFFR_X2%10_r19 x_PM_DFFR_X2%10_40 x_PM_DFFR_X2%10_38 0.212317
R_x_PM_DFFR_X2%10_r20 x_PM_DFFR_X2%10_39 x_PM_DFFR_X2%10_38 1.49286
R_x_PM_DFFR_X2%10_r21 x_PM_DFFR_X2%10_45 x_PM_DFFR_X2%10_37 0.260444
R_x_PM_DFFR_X2%10_r22 x_PM_DFFR_X2%10_41 x_PM_DFFR_X2%10_36 0.212317
R_x_PM_DFFR_X2%10_r23 x_PM_DFFR_X2%10_37 x_PM_DFFR_X2%10_36 2.19857
R_x_PM_DFFR_X2%10_r24 x_PM_DFFR_X2%10_39 x_PM_DFFR_X2%10_32 0.241334
R_x_PM_DFFR_X2%10_r25 N_10_M30_d x_PM_DFFR_X2%10_32 0.471481
R_x_PM_DFFR_X2%10_r26 x_PM_DFFR_X2%10_45 x_PM_DFFR_X2%10_28 0.0238872
R_x_PM_DFFR_X2%10_r27 N_10_M13_d x_PM_DFFR_X2%10_28 0.302593
R_x_PM_DFFR_X2%10_r28 x_PM_DFFR_X2%10_26 x_PM_DFFR_X2%10_24 25.0012
R_x_PM_DFFR_X2%10_r29 x_PM_DFFR_X2%10_45 x_PM_DFFR_X2%10_23 0.260444
R_x_PM_DFFR_X2%10_r30 x_PM_DFFR_X2%10_24 x_PM_DFFR_X2%10_23 0.924667
R_x_PM_DFFR_X2%10_r31 x_PM_DFFR_X2%10_44 x_PM_DFFR_X2%10_19 11.9847
R_x_PM_DFFR_X2%10_r32 x_PM_DFFR_X2%10_20 x_PM_DFFR_X2%10_19 0.043368
R_x_PM_DFFR_X2%10_r33 x_PM_DFFR_X2%10_26 x_PM_DFFR_X2%10_17 7.02
R_x_PM_DFFR_X2%10_r34 x_PM_DFFR_X2%10_18 x_PM_DFFR_X2%10_17 0.043368
R_x_PM_DFFR_X2%10_r35 x_PM_DFFR_X2%10_20 x_PM_DFFR_X2%10_13 4.56151
R_x_PM_DFFR_X2%10_r36 N_10_M16_g x_PM_DFFR_X2%10_13 69.42
R_x_PM_DFFR_X2%10_r37 x_PM_DFFR_X2%10_20 x_PM_DFFR_X2%10_9 4.56151
R_x_PM_DFFR_X2%10_r38 N_10_M32_g x_PM_DFFR_X2%10_9 74.1
R_x_PM_DFFR_X2%10_r39 x_PM_DFFR_X2%10_18 x_PM_DFFR_X2%10_5 4.56151
R_x_PM_DFFR_X2%10_r40 N_10_M12_g x_PM_DFFR_X2%10_5 27.3
R_x_PM_DFFR_X2%10_r41 x_PM_DFFR_X2%10_18 x_PM_DFFR_X2%10_VSS 4.56151
R_x_PM_DFFR_X2%10_r42 N_10_M28_g x_PM_DFFR_X2%10_VSS 86.58
C_x_PM_DFFR_X2%RN_c0 VSS x_PM_DFFR_X2%RN_27 1.30837e-17
C_x_PM_DFFR_X2%RN_c1 VSS x_PM_DFFR_X2%RN_20 2.65576e-17
C_x_PM_DFFR_X2%RN_c2 VSS N_RN_M13_g 8.14411e-17
C_x_PM_DFFR_X2%RN_c3 VSS N_RN_M29_g 4.27325e-17
C_x_PM_DFFR_X2%RN_c4 VSS x_PM_DFFR_X2%RN_8 5.16333e-18
C_x_PM_DFFR_X2%RN_c5 VSS x_PM_DFFR_X2%RN_7 2.65816e-16
C_x_PM_DFFR_X2%RN_c6 VSS N_RN_M19_g 1.29817e-16
R_x_PM_DFFR_X2%RN_r7 x_PM_DFFR_X2%RN_27 x_PM_DFFR_X2%RN_22 4.94
R_x_PM_DFFR_X2%RN_r8 x_PM_DFFR_X2%RN_22 x_PM_DFFR_X2%RN_24 1.3
R_x_PM_DFFR_X2%RN_r9 x_PM_DFFR_X2%RN_22 x_PM_DFFR_X2%RN_20 25.0012
R_x_PM_DFFR_X2%RN_r10 x_PM_DFFR_X2%RN_20 RN 0.0882143
R_x_PM_DFFR_X2%RN_r11 N_RN_M13_g x_PM_DFFR_X2%RN_14 28.86
R_x_PM_DFFR_X2%RN_r12 x_PM_DFFR_X2%RN_27 x_PM_DFFR_X2%RN_13 1.95
R_x_PM_DFFR_X2%RN_r13 N_RN_M13_g x_PM_DFFR_X2%RN_13 92.82
R_x_PM_DFFR_X2%RN_r14 x_PM_DFFR_X2%RN_24 x_PM_DFFR_X2%RN_9 1.95
R_x_PM_DFFR_X2%RN_r15 N_RN_M29_g x_PM_DFFR_X2%RN_9 35.88
R_x_PM_DFFR_X2%RN_r16 x_PM_DFFR_X2%RN_14 x_PM_DFFR_X2%RN_7 4.35808
R_x_PM_DFFR_X2%RN_r17 x_PM_DFFR_X2%RN_8 x_PM_DFFR_X2%RN_7 325.26
R_x_PM_DFFR_X2%RN_r18 N_RN_M3_g N_RN_M19_g 96.72
R_x_PM_DFFR_X2%RN_r19 x_PM_DFFR_X2%RN_8 x_PM_DFFR_X2%RN_VSS 4.35808
R_x_PM_DFFR_X2%RN_r20 N_RN_M3_g x_PM_DFFR_X2%RN_VSS 67.08
C_x_PM_DFFR_X2%QN_c0 VSS x_PM_DFFR_X2%QN_16 6.35498e-17
C_x_PM_DFFR_X2%QN_c1 VSS N_QN_M31_s 3.56505e-17
C_x_PM_DFFR_X2%QN_c2 VSS x_PM_DFFR_X2%QN_10 1.94652e-16
C_x_PM_DFFR_X2%QN_c3 VSS x_PM_DFFR_X2%QN_7 1.29962e-17
C_x_PM_DFFR_X2%QN_c4 VSS x_PM_DFFR_X2%QN_3 7.78691e-17
R_x_PM_DFFR_X2%QN_r5 x_PM_DFFR_X2%QN_20 QN 0.28578
R_x_PM_DFFR_X2%QN_r6 QN x_PM_DFFR_X2%QN_16 0.1976
R_x_PM_DFFR_X2%QN_r7 x_PM_DFFR_X2%QN_14 N_QN_M31_s 0.147778
R_x_PM_DFFR_X2%QN_r8 x_PM_DFFR_X2%QN_10 x_PM_DFFR_X2%QN_20 3.36571
R_x_PM_DFFR_X2%QN_r9 x_PM_DFFR_X2%QN_14 x_PM_DFFR_X2%QN_8 0.095
R_x_PM_DFFR_X2%QN_r10 x_PM_DFFR_X2%QN_16 x_PM_DFFR_X2%QN_7 0.095
R_x_PM_DFFR_X2%QN_r11 x_PM_DFFR_X2%QN_8 x_PM_DFFR_X2%QN_7 0.461429
R_x_PM_DFFR_X2%QN_r12 x_PM_DFFR_X2%QN_10 x_PM_DFFR_X2%QN_3 0.212317
R_x_PM_DFFR_X2%QN_r13 N_QN_M15_s x_PM_DFFR_X2%QN_3 1.12643
C_x_PM_DFFR_X2%Q_c0 VSS N_Q_M32_d 1.97871e-16
R_x_PM_DFFR_X2%Q_r1 N_Q_M16_d Q 2.42929
R_x_PM_DFFR_X2%Q_r2 Q N_Q_M32_d 2.15786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X1 VSS VDD D CK SN QN Q
*.PININFO VSS:B VDD:B D:I CK:I SN:I QN:O Q:O
M_M16 N_VDD_M0_d N_5_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M17 14 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_6_M2_d N_3_M2_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 15 N_5_M3_g N_6_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M20 N_VDD_M4_d N_7_M4_g 15 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M21 N_7_M5_d N_SN_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_VDD_M6_d N_6_M6_g N_7_M5_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M23 N_5_M7_d N_CK_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M24 16 N_5_M8_g N_9_M8_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M9_d N_6_M9_g 16 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 17 N_10_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M27 N_9_M11_d N_3_M11_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 18 N_3_M12_g N_9_M11_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_VDD_M13_d N_SN_M13_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_10_M14_d N_9_M14_g N_VDD_M13_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M15_d N_9_M15_g N_QN_M15_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M32 N_Q_M16_d N_10_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M17_d N_5_M17_g N_3_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 19 N_D_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_6_M19_d N_5_M19_g 19 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 20 N_3_M20_g N_6_M19_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_VSS_M21_d N_7_M21_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 21 N_SN_M22_g N_VSS_M21_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_7_M23_d N_6_M23_g 21 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_VSS_M24_d N_CK_M24_g N_5_M24_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 22 N_6_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_9_M26_d N_3_M26_g 22 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 23 N_5_M27_g N_9_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 24 N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_VSS_M29_d N_SN_M29_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 N_10_M30_d N_9_M30_g N_VSS_M29_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VSS_M31_d N_9_M31_g N_QN_M31_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_Q_M32_d N_10_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DFFS_X1%VSS_c0 VSS x_PM_DFFS_X1%VSS_42 4.00917e-17
C_x_PM_DFFS_X1%VSS_c1 VSS x_PM_DFFS_X1%VSS_41 6.41071e-18
C_x_PM_DFFS_X1%VSS_c2 VSS x_PM_DFFS_X1%VSS_40 8.93987e-18
C_x_PM_DFFS_X1%VSS_c3 VSS x_PM_DFFS_X1%VSS_39 2.7752e-18
C_x_PM_DFFS_X1%VSS_c4 VSS x_PM_DFFS_X1%VSS_38 2.86379e-17
C_x_PM_DFFS_X1%VSS_c5 VSS N_VSS_M31_d 3.42556e-17
C_x_PM_DFFS_X1%VSS_c6 VSS x_PM_DFFS_X1%VSS_30 5.25904e-17
C_x_PM_DFFS_X1%VSS_c7 VSS N_VSS_M29_d 6.84887e-17
C_x_PM_DFFS_X1%VSS_c8 VSS x_PM_DFFS_X1%VSS_24 1.03406e-16
C_x_PM_DFFS_X1%VSS_c9 VSS VSS 9.31423e-17
C_x_PM_DFFS_X1%VSS_c10 VSS x_PM_DFFS_X1%VSS_16 1.63808e-16
C_x_PM_DFFS_X1%VSS_c11 VSS N_VSS_M21_d 1.00842e-16
C_x_PM_DFFS_X1%VSS_c12 VSS x_PM_DFFS_X1%VSS_10 1.15428e-16
C_x_PM_DFFS_X1%VSS_c13 VSS x_PM_DFFS_X1%VSS_9 3.34755e-17
R_x_PM_DFFS_X1%VSS_r14 x_PM_DFFS_X1%VSS_42 x_PM_DFFS_X1%VSS_32 0.145286
R_x_PM_DFFS_X1%VSS_r15 N_VSS_M31_d x_PM_DFFS_X1%VSS_32 0.637857
R_x_PM_DFFS_X1%VSS_r16 x_PM_DFFS_X1%VSS_41 x_PM_DFFS_X1%VSS_31 0.132285
R_x_PM_DFFS_X1%VSS_r17 x_PM_DFFS_X1%VSS_42 x_PM_DFFS_X1%VSS_30 0.0731438
R_x_PM_DFFS_X1%VSS_r18 x_PM_DFFS_X1%VSS_31 x_PM_DFFS_X1%VSS_30 1.07294
R_x_PM_DFFS_X1%VSS_r19 x_PM_DFFS_X1%VSS_41 x_PM_DFFS_X1%VSS_26 0.0680382
R_x_PM_DFFS_X1%VSS_r20 N_VSS_M29_d x_PM_DFFS_X1%VSS_26 0.823333
R_x_PM_DFFS_X1%VSS_r21 x_PM_DFFS_X1%VSS_40 x_PM_DFFS_X1%VSS_25 0.132285
R_x_PM_DFFS_X1%VSS_r22 x_PM_DFFS_X1%VSS_41 x_PM_DFFS_X1%VSS_24 0.132285
R_x_PM_DFFS_X1%VSS_r23 x_PM_DFFS_X1%VSS_25 x_PM_DFFS_X1%VSS_24 1.88882
R_x_PM_DFFS_X1%VSS_r24 N_VSS_M24_d VSS 0.605185
R_x_PM_DFFS_X1%VSS_r25 x_PM_DFFS_X1%VSS_40 x_PM_DFFS_X1%VSS_18 0.0680382
R_x_PM_DFFS_X1%VSS_r26 VSS x_PM_DFFS_X1%VSS_18 0.218148
R_x_PM_DFFS_X1%VSS_r27 x_PM_DFFS_X1%VSS_39 x_PM_DFFS_X1%VSS_17 0.0731438
R_x_PM_DFFS_X1%VSS_r28 x_PM_DFFS_X1%VSS_40 x_PM_DFFS_X1%VSS_16 0.132285
R_x_PM_DFFS_X1%VSS_r29 x_PM_DFFS_X1%VSS_17 x_PM_DFFS_X1%VSS_16 1.60941
R_x_PM_DFFS_X1%VSS_r30 x_PM_DFFS_X1%VSS_39 x_PM_DFFS_X1%VSS_12 0.145286
R_x_PM_DFFS_X1%VSS_r31 N_VSS_M21_d x_PM_DFFS_X1%VSS_12 1.37071
R_x_PM_DFFS_X1%VSS_r32 x_PM_DFFS_X1%VSS_38 x_PM_DFFS_X1%VSS_11 0.132285
R_x_PM_DFFS_X1%VSS_r33 x_PM_DFFS_X1%VSS_39 x_PM_DFFS_X1%VSS_10 0.0731438
R_x_PM_DFFS_X1%VSS_r34 x_PM_DFFS_X1%VSS_11 x_PM_DFFS_X1%VSS_10 1.62059
R_x_PM_DFFS_X1%VSS_r35 x_PM_DFFS_X1%VSS_38 x_PM_DFFS_X1%VSS_9 0.0680382
R_x_PM_DFFS_X1%VSS_r36 x_PM_DFFS_X1%VSS_9 N_VSS_M17_d 0.389509
C_x_PM_DFFS_X1%VDD_c0 VSS x_PM_DFFS_X1%VDD_52 2.87998e-17
C_x_PM_DFFS_X1%VDD_c1 VSS x_PM_DFFS_X1%VDD_51 5.6044e-18
C_x_PM_DFFS_X1%VDD_c2 VSS x_PM_DFFS_X1%VDD_50 4.6069e-18
C_x_PM_DFFS_X1%VDD_c3 VSS x_PM_DFFS_X1%VDD_49 8.92847e-18
C_x_PM_DFFS_X1%VDD_c4 VSS x_PM_DFFS_X1%VDD_48 8.92848e-18
C_x_PM_DFFS_X1%VDD_c5 VSS N_VDD_M0_d 3.64844e-17
C_x_PM_DFFS_X1%VDD_c6 VSS N_VDD_M15_d 4.06819e-17
C_x_PM_DFFS_X1%VDD_c7 VSS x_PM_DFFS_X1%VDD_35 3.9355e-17
C_x_PM_DFFS_X1%VDD_c8 VSS N_VDD_M13_d 2.46551e-17
C_x_PM_DFFS_X1%VDD_c9 VSS x_PM_DFFS_X1%VDD_29 6.62457e-17
C_x_PM_DFFS_X1%VDD_c10 VSS N_VDD_M9_d 3.46084e-17
C_x_PM_DFFS_X1%VDD_c11 VSS x_PM_DFFS_X1%VDD_23 6.36805e-17
C_x_PM_DFFS_X1%VDD_c12 VSS N_VDD_M6_d 4.2287e-17
C_x_PM_DFFS_X1%VDD_c13 VSS x_PM_DFFS_X1%VDD_17 2.32157e-17
C_x_PM_DFFS_X1%VDD_c14 VSS N_VDD_M4_d 5.55221e-17
C_x_PM_DFFS_X1%VDD_c15 VSS x_PM_DFFS_X1%VDD_11 6.73272e-17
C_x_PM_DFFS_X1%VDD_c16 VSS x_PM_DFFS_X1%VDD_7 2.99213e-17
R_x_PM_DFFS_X1%VDD_r17 x_PM_DFFS_X1%VDD_46 N_VDD_M0_d 0.49963
R_x_PM_DFFS_X1%VDD_r18 x_PM_DFFS_X1%VDD_52 x_PM_DFFS_X1%VDD_37 0.145286
R_x_PM_DFFS_X1%VDD_r19 N_VDD_M15_d x_PM_DFFS_X1%VDD_37 1.45214
R_x_PM_DFFS_X1%VDD_r20 x_PM_DFFS_X1%VDD_51 x_PM_DFFS_X1%VDD_36 0.132285
R_x_PM_DFFS_X1%VDD_r21 x_PM_DFFS_X1%VDD_52 x_PM_DFFS_X1%VDD_35 0.0731438
R_x_PM_DFFS_X1%VDD_r22 x_PM_DFFS_X1%VDD_36 x_PM_DFFS_X1%VDD_35 0.905294
R_x_PM_DFFS_X1%VDD_r23 x_PM_DFFS_X1%VDD_51 x_PM_DFFS_X1%VDD_31 0.0680382
R_x_PM_DFFS_X1%VDD_r24 N_VDD_M13_d x_PM_DFFS_X1%VDD_31 0.330741
R_x_PM_DFFS_X1%VDD_r25 x_PM_DFFS_X1%VDD_50 x_PM_DFFS_X1%VDD_30 0.0731438
R_x_PM_DFFS_X1%VDD_r26 x_PM_DFFS_X1%VDD_51 x_PM_DFFS_X1%VDD_29 0.132285
R_x_PM_DFFS_X1%VDD_r27 x_PM_DFFS_X1%VDD_30 x_PM_DFFS_X1%VDD_29 1.48647
R_x_PM_DFFS_X1%VDD_r28 x_PM_DFFS_X1%VDD_50 x_PM_DFFS_X1%VDD_25 0.145286
R_x_PM_DFFS_X1%VDD_r29 N_VDD_M9_d x_PM_DFFS_X1%VDD_25 0.909286
R_x_PM_DFFS_X1%VDD_r30 x_PM_DFFS_X1%VDD_49 x_PM_DFFS_X1%VDD_24 0.132285
R_x_PM_DFFS_X1%VDD_r31 x_PM_DFFS_X1%VDD_50 x_PM_DFFS_X1%VDD_23 0.0731438
R_x_PM_DFFS_X1%VDD_r32 x_PM_DFFS_X1%VDD_24 x_PM_DFFS_X1%VDD_23 1.37471
R_x_PM_DFFS_X1%VDD_r33 x_PM_DFFS_X1%VDD_49 x_PM_DFFS_X1%VDD_19 0.0680382
R_x_PM_DFFS_X1%VDD_r34 N_VDD_M6_d x_PM_DFFS_X1%VDD_19 0.767037
R_x_PM_DFFS_X1%VDD_r35 x_PM_DFFS_X1%VDD_48 x_PM_DFFS_X1%VDD_18 0.132285
R_x_PM_DFFS_X1%VDD_r36 x_PM_DFFS_X1%VDD_49 x_PM_DFFS_X1%VDD_17 0.132285
R_x_PM_DFFS_X1%VDD_r37 x_PM_DFFS_X1%VDD_18 x_PM_DFFS_X1%VDD_17 0.581176
R_x_PM_DFFS_X1%VDD_r38 x_PM_DFFS_X1%VDD_48 x_PM_DFFS_X1%VDD_13 0.0680382
R_x_PM_DFFS_X1%VDD_r39 N_VDD_M4_d x_PM_DFFS_X1%VDD_13 0.767037
R_x_PM_DFFS_X1%VDD_r40 x_PM_DFFS_X1%VDD_46 x_PM_DFFS_X1%VDD_12 0.095
R_x_PM_DFFS_X1%VDD_r41 x_PM_DFFS_X1%VDD_48 x_PM_DFFS_X1%VDD_11 0.132285
R_x_PM_DFFS_X1%VDD_r42 x_PM_DFFS_X1%VDD_12 x_PM_DFFS_X1%VDD_11 1.38588
R_x_PM_DFFS_X1%VDD_r43 x_PM_DFFS_X1%VDD_46 x_PM_DFFS_X1%VDD_7 0.095
R_x_PM_DFFS_X1%VDD_r44 VDD x_PM_DFFS_X1%VDD_7 0.312941
C_x_PM_DFFS_X1%3_c0 VSS x_PM_DFFS_X1%3_55 1.6975e-17
C_x_PM_DFFS_X1%3_c1 VSS x_PM_DFFS_X1%3_50 1.0985e-17
C_x_PM_DFFS_X1%3_c2 VSS x_PM_DFFS_X1%3_46 1.19435e-16
C_x_PM_DFFS_X1%3_c3 VSS x_PM_DFFS_X1%3_41 1.90554e-17
C_x_PM_DFFS_X1%3_c4 VSS x_PM_DFFS_X1%3_40 3.71575e-17
C_x_PM_DFFS_X1%3_c5 VSS x_PM_DFFS_X1%3_39 1.36e-17
C_x_PM_DFFS_X1%3_c6 VSS x_PM_DFFS_X1%3_35 7.19493e-18
C_x_PM_DFFS_X1%3_c7 VSS x_PM_DFFS_X1%3_34 8.10036e-17
C_x_PM_DFFS_X1%3_c8 VSS N_3_M17_s 6.99702e-17
C_x_PM_DFFS_X1%3_c9 VSS x_PM_DFFS_X1%3_27 4.47133e-18
C_x_PM_DFFS_X1%3_c10 VSS N_3_M12_g 2.0358e-17
C_x_PM_DFFS_X1%3_c11 VSS x_PM_DFFS_X1%3_21 2.14561e-17
C_x_PM_DFFS_X1%3_c12 VSS N_3_M11_g 6.77548e-17
C_x_PM_DFFS_X1%3_c13 VSS x_PM_DFFS_X1%3_16 5.60163e-18
C_x_PM_DFFS_X1%3_c14 VSS x_PM_DFFS_X1%3_15 3.25626e-17
C_x_PM_DFFS_X1%3_c15 VSS N_3_M26_g 2.83876e-17
C_x_PM_DFFS_X1%3_c16 VSS N_3_M20_g 2.59998e-17
C_x_PM_DFFS_X1%3_c17 VSS x_PM_DFFS_X1%3_6 6.59589e-18
C_x_PM_DFFS_X1%3_c18 VSS x_PM_DFFS_X1%3_5 2.21349e-16
C_x_PM_DFFS_X1%3_c19 VSS N_3_M2_g 3.39899e-17
R_x_PM_DFFS_X1%3_r20 x_PM_DFFS_X1%3_55 x_PM_DFFS_X1%3_48 5.46
R_x_PM_DFFS_X1%3_r21 x_PM_DFFS_X1%3_48 x_PM_DFFS_X1%3_46 25.0012
R_x_PM_DFFS_X1%3_r22 x_PM_DFFS_X1%3_46 x_PM_DFFS_X1%3_45 1.995
R_x_PM_DFFS_X1%3_r23 x_PM_DFFS_X1%3_50 x_PM_DFFS_X1%3_43 25.0012
R_x_PM_DFFS_X1%3_r24 x_PM_DFFS_X1%3_43 x_PM_DFFS_X1%3_41 0.257857
R_x_PM_DFFS_X1%3_r25 x_PM_DFFS_X1%3_45 x_PM_DFFS_X1%3_40 0.212317
R_x_PM_DFFS_X1%3_r26 x_PM_DFFS_X1%3_43 x_PM_DFFS_X1%3_40 0.149286
R_x_PM_DFFS_X1%3_r27 x_PM_DFFS_X1%3_41 x_PM_DFFS_X1%3_38 0.212317
R_x_PM_DFFS_X1%3_r28 x_PM_DFFS_X1%3_39 x_PM_DFFS_X1%3_38 0.515714
R_x_PM_DFFS_X1%3_r29 N_3_M0_s x_PM_DFFS_X1%3_35 0.0407143
R_x_PM_DFFS_X1%3_r30 x_PM_DFFS_X1%3_39 x_PM_DFFS_X1%3_34 0.212317
R_x_PM_DFFS_X1%3_r31 N_3_M0_s x_PM_DFFS_X1%3_34 2.07643
R_x_PM_DFFS_X1%3_r32 x_PM_DFFS_X1%3_35 x_PM_DFFS_X1%3_30 0.212317
R_x_PM_DFFS_X1%3_r33 N_3_M17_s x_PM_DFFS_X1%3_30 3.705
R_x_PM_DFFS_X1%3_r34 N_3_M12_g x_PM_DFFS_X1%3_23 26.52
R_x_PM_DFFS_X1%3_r35 x_PM_DFFS_X1%3_27 x_PM_DFFS_X1%3_22 3.30287
R_x_PM_DFFS_X1%3_r36 x_PM_DFFS_X1%3_23 x_PM_DFFS_X1%3_21 4.35808
R_x_PM_DFFS_X1%3_r37 x_PM_DFFS_X1%3_22 x_PM_DFFS_X1%3_21 21.84
R_x_PM_DFFS_X1%3_r38 x_PM_DFFS_X1%3_27 x_PM_DFFS_X1%3_18 0.858359
R_x_PM_DFFS_X1%3_r39 N_3_M11_g x_PM_DFFS_X1%3_18 26.52
R_x_PM_DFFS_X1%3_r40 N_3_M11_g x_PM_DFFS_X1%3_17 83.46
R_x_PM_DFFS_X1%3_r41 x_PM_DFFS_X1%3_17 x_PM_DFFS_X1%3_15 4.35808
R_x_PM_DFFS_X1%3_r42 x_PM_DFFS_X1%3_16 x_PM_DFFS_X1%3_15 31.98
R_x_PM_DFFS_X1%3_r43 x_PM_DFFS_X1%3_16 x_PM_DFFS_X1%3_11 4.35808
R_x_PM_DFFS_X1%3_r44 N_3_M26_g x_PM_DFFS_X1%3_11 26.52
R_x_PM_DFFS_X1%3_r45 x_PM_DFFS_X1%3_55 x_PM_DFFS_X1%3_7 1.95
R_x_PM_DFFS_X1%3_r46 N_3_M20_g x_PM_DFFS_X1%3_7 18.72
R_x_PM_DFFS_X1%3_r47 x_PM_DFFS_X1%3_27 x_PM_DFFS_X1%3_5 3.30287
R_x_PM_DFFS_X1%3_r48 x_PM_DFFS_X1%3_6 x_PM_DFFS_X1%3_5 284.7
R_x_PM_DFFS_X1%3_r49 x_PM_DFFS_X1%3_6 x_PM_DFFS_X1%3_2 4.35808
R_x_PM_DFFS_X1%3_r50 N_3_M2_g x_PM_DFFS_X1%3_2 28.86
R_x_PM_DFFS_X1%3_r51 x_PM_DFFS_X1%3_VSS x_PM_DFFS_X1%3_50 4.7687
R_x_PM_DFFS_X1%3_r52 N_3_M2_g x_PM_DFFS_X1%3_VSS 28.86
C_x_PM_DFFS_X1%D_c0 VSS x_PM_DFFS_X1%D_22 1.10146e-17
C_x_PM_DFFS_X1%D_c1 VSS x_PM_DFFS_X1%D_20 6.02796e-17
C_x_PM_DFFS_X1%D_c2 VSS x_PM_DFFS_X1%D_13 1.10896e-17
C_x_PM_DFFS_X1%D_c3 VSS x_PM_DFFS_X1%D_11 5.65968e-17
C_x_PM_DFFS_X1%D_c4 VSS x_PM_DFFS_X1%D_10 5.36866e-17
C_x_PM_DFFS_X1%D_c5 VSS N_D_M1_g 4.23968e-17
C_x_PM_DFFS_X1%D_c6 VSS N_D_M18_g 2.86792e-17
R_x_PM_DFFS_X1%D_r7 x_PM_DFFS_X1%D_29 x_PM_DFFS_X1%D_22 4.7687
R_x_PM_DFFS_X1%D_r8 x_PM_DFFS_X1%D_22 x_PM_DFFS_X1%D_20 25.0012
R_x_PM_DFFS_X1%D_r9 x_PM_DFFS_X1%D_20 x_PM_DFFS_X1%D_18 0.175926
R_x_PM_DFFS_X1%D_r10 x_PM_DFFS_X1%D_17 D 0.286226
R_x_PM_DFFS_X1%D_r11 x_PM_DFFS_X1%D_25 x_PM_DFFS_X1%D_13 4.7687
R_x_PM_DFFS_X1%D_r12 x_PM_DFFS_X1%D_13 x_PM_DFFS_X1%D_11 25.0012
R_x_PM_DFFS_X1%D_r13 D x_PM_DFFS_X1%D_11 0.0316667
R_x_PM_DFFS_X1%D_r14 x_PM_DFFS_X1%D_18 x_PM_DFFS_X1%D_10 0.095
R_x_PM_DFFS_X1%D_r15 x_PM_DFFS_X1%D_10 x_PM_DFFS_X1%D_17 1.49286
R_x_PM_DFFS_X1%D_r16 N_D_M1_g x_PM_DFFS_X1%D_29 28.86
R_x_PM_DFFS_X1%D_r17 N_D_M18_g x_PM_DFFS_X1%D_25 21.84
C_x_PM_DFFS_X1%5_c0 VSS x_PM_DFFS_X1%5_75 9.30389e-18
C_x_PM_DFFS_X1%5_c1 VSS x_PM_DFFS_X1%5_70 6.69732e-18
C_x_PM_DFFS_X1%5_c2 VSS x_PM_DFFS_X1%5_67 5.41811e-17
C_x_PM_DFFS_X1%5_c3 VSS x_PM_DFFS_X1%5_65 2.6649e-17
C_x_PM_DFFS_X1%5_c4 VSS x_PM_DFFS_X1%5_64 9.83275e-17
C_x_PM_DFFS_X1%5_c5 VSS x_PM_DFFS_X1%5_62 9.90496e-18
C_x_PM_DFFS_X1%5_c6 VSS x_PM_DFFS_X1%5_58 1.16362e-16
C_x_PM_DFFS_X1%5_c7 VSS N_5_M24_s 9.48945e-17
C_x_PM_DFFS_X1%5_c8 VSS x_PM_DFFS_X1%5_50 1.70909e-17
C_x_PM_DFFS_X1%5_c9 VSS x_PM_DFFS_X1%5_49 3.64235e-17
C_x_PM_DFFS_X1%5_c10 VSS x_PM_DFFS_X1%5_48 1.64226e-16
C_x_PM_DFFS_X1%5_c11 VSS x_PM_DFFS_X1%5_47 4.48571e-17
C_x_PM_DFFS_X1%5_c12 VSS x_PM_DFFS_X1%5_45 2.52351e-17
C_x_PM_DFFS_X1%5_c13 VSS x_PM_DFFS_X1%5_44 5.407e-17
C_x_PM_DFFS_X1%5_c14 VSS x_PM_DFFS_X1%5_43 6.3453e-17
C_x_PM_DFFS_X1%5_c15 VSS x_PM_DFFS_X1%5_41 2.29088e-17
C_x_PM_DFFS_X1%5_c16 VSS x_PM_DFFS_X1%5_40 1.45569e-16
C_x_PM_DFFS_X1%5_c17 VSS x_PM_DFFS_X1%5_36 9.72347e-17
C_x_PM_DFFS_X1%5_c18 VSS x_PM_DFFS_X1%5_32 4.40197e-18
C_x_PM_DFFS_X1%5_c19 VSS x_PM_DFFS_X1%5_31 3.59673e-17
C_x_PM_DFFS_X1%5_c20 VSS x_PM_DFFS_X1%5_27 1.39013e-17
C_x_PM_DFFS_X1%5_c21 VSS N_5_M27_g 2.08693e-17
C_x_PM_DFFS_X1%5_c22 VSS N_5_M8_g 4.08847e-17
C_x_PM_DFFS_X1%5_c23 VSS N_5_M3_g 4.74792e-17
C_x_PM_DFFS_X1%5_c24 VSS x_PM_DFFS_X1%5_13 4.41942e-17
C_x_PM_DFFS_X1%5_c25 VSS N_5_M19_g 4.49699e-17
C_x_PM_DFFS_X1%5_c26 VSS N_5_M0_g 5.71684e-17
C_x_PM_DFFS_X1%5_c27 VSS N_5_M17_g 5.372e-17
R_x_PM_DFFS_X1%5_r28 x_PM_DFFS_X1%5_75 x_PM_DFFS_X1%5_67 25.0012
R_x_PM_DFFS_X1%5_r29 x_PM_DFFS_X1%5_67 x_PM_DFFS_X1%5_65 1.58786
R_x_PM_DFFS_X1%5_r30 x_PM_DFFS_X1%5_65 x_PM_DFFS_X1%5_63 0.212317
R_x_PM_DFFS_X1%5_r31 x_PM_DFFS_X1%5_64 x_PM_DFFS_X1%5_63 2.74143
R_x_PM_DFFS_X1%5_r32 x_PM_DFFS_X1%5_74 x_PM_DFFS_X1%5_62 4.7687
R_x_PM_DFFS_X1%5_r33 x_PM_DFFS_X1%5_62 x_PM_DFFS_X1%5_60 25.0012
R_x_PM_DFFS_X1%5_r34 x_PM_DFFS_X1%5_70 x_PM_DFFS_X1%5_59 0.14772
R_x_PM_DFFS_X1%5_r35 x_PM_DFFS_X1%5_60 x_PM_DFFS_X1%5_59 0.726471
R_x_PM_DFFS_X1%5_r36 x_PM_DFFS_X1%5_64 x_PM_DFFS_X1%5_58 0.214913
R_x_PM_DFFS_X1%5_r37 x_PM_DFFS_X1%5_60 x_PM_DFFS_X1%5_58 0.525294
R_x_PM_DFFS_X1%5_r38 x_PM_DFFS_X1%5_70 x_PM_DFFS_X1%5_55 0.0533096
R_x_PM_DFFS_X1%5_r39 N_5_M24_s x_PM_DFFS_X1%5_55 2.26643
R_x_PM_DFFS_X1%5_r40 N_5_M24_s x_PM_DFFS_X1%5_54 0.855
R_x_PM_DFFS_X1%5_r41 x_PM_DFFS_X1%5_70 x_PM_DFFS_X1%5_50 0.14772
R_x_PM_DFFS_X1%5_r42 N_5_M7_d x_PM_DFFS_X1%5_50 0.149286
R_x_PM_DFFS_X1%5_r43 x_PM_DFFS_X1%5_54 x_PM_DFFS_X1%5_48 0.212317
R_x_PM_DFFS_X1%5_r44 x_PM_DFFS_X1%5_49 x_PM_DFFS_X1%5_48 2.33429
R_x_PM_DFFS_X1%5_r45 x_PM_DFFS_X1%5_49 x_PM_DFFS_X1%5_46 0.212317
R_x_PM_DFFS_X1%5_r46 x_PM_DFFS_X1%5_47 x_PM_DFFS_X1%5_46 1.35714
R_x_PM_DFFS_X1%5_r47 x_PM_DFFS_X1%5_47 x_PM_DFFS_X1%5_44 0.212317
R_x_PM_DFFS_X1%5_r48 x_PM_DFFS_X1%5_45 x_PM_DFFS_X1%5_44 1.11286
R_x_PM_DFFS_X1%5_r49 x_PM_DFFS_X1%5_45 x_PM_DFFS_X1%5_43 0.212317
R_x_PM_DFFS_X1%5_r50 x_PM_DFFS_X1%5_43 x_PM_DFFS_X1%5_42 1.27571
R_x_PM_DFFS_X1%5_r51 x_PM_DFFS_X1%5_42 x_PM_DFFS_X1%5_40 0.212317
R_x_PM_DFFS_X1%5_r52 x_PM_DFFS_X1%5_41 x_PM_DFFS_X1%5_40 2.19857
R_x_PM_DFFS_X1%5_r53 x_PM_DFFS_X1%5_38 x_PM_DFFS_X1%5_36 25.0012
R_x_PM_DFFS_X1%5_r54 x_PM_DFFS_X1%5_41 x_PM_DFFS_X1%5_35 0.212317
R_x_PM_DFFS_X1%5_r55 x_PM_DFFS_X1%5_36 x_PM_DFFS_X1%5_35 2.375
R_x_PM_DFFS_X1%5_r56 x_PM_DFFS_X1%5_38 x_PM_DFFS_X1%5_31 3.0875
R_x_PM_DFFS_X1%5_r57 x_PM_DFFS_X1%5_32 x_PM_DFFS_X1%5_31 1.51801
R_x_PM_DFFS_X1%5_r58 x_PM_DFFS_X1%5_38 x_PM_DFFS_X1%5_28 15.4375
R_x_PM_DFFS_X1%5_r59 x_PM_DFFS_X1%5_30 x_PM_DFFS_X1%5_27 6.66768
R_x_PM_DFFS_X1%5_r60 x_PM_DFFS_X1%5_29 x_PM_DFFS_X1%5_27 6.66768
R_x_PM_DFFS_X1%5_r61 x_PM_DFFS_X1%5_28 x_PM_DFFS_X1%5_27 1.95
R_x_PM_DFFS_X1%5_r62 x_PM_DFFS_X1%5_23 x_PM_DFFS_X1%5_75 4.7687
R_x_PM_DFFS_X1%5_r63 N_5_M27_g x_PM_DFFS_X1%5_23 14.82
R_x_PM_DFFS_X1%5_r64 N_5_M8_g x_PM_DFFS_X1%5_74 28.86
R_x_PM_DFFS_X1%5_r65 N_5_M3_g x_PM_DFFS_X1%5_15 46.02
R_x_PM_DFFS_X1%5_r66 x_PM_DFFS_X1%5_32 x_PM_DFFS_X1%5_14 1.51801
R_x_PM_DFFS_X1%5_r67 x_PM_DFFS_X1%5_15 x_PM_DFFS_X1%5_13 5.39646
R_x_PM_DFFS_X1%5_r68 x_PM_DFFS_X1%5_14 x_PM_DFFS_X1%5_13 13
R_x_PM_DFFS_X1%5_r69 x_PM_DFFS_X1%5_32 x_PM_DFFS_X1%5_9 2.95322
R_x_PM_DFFS_X1%5_r70 N_5_M19_g x_PM_DFFS_X1%5_9 49.92
R_x_PM_DFFS_X1%5_r71 N_5_M0_g x_PM_DFFS_X1%5_30 53.04
R_x_PM_DFFS_X1%5_r72 N_5_M17_g x_PM_DFFS_X1%5_29 49.92
C_x_PM_DFFS_X1%6_c0 VSS x_PM_DFFS_X1%6_47 1.3096e-17
C_x_PM_DFFS_X1%6_c1 VSS x_PM_DFFS_X1%6_39 4.43656e-17
C_x_PM_DFFS_X1%6_c2 VSS x_PM_DFFS_X1%6_37 2.40403e-17
C_x_PM_DFFS_X1%6_c3 VSS x_PM_DFFS_X1%6_35 8.46373e-17
C_x_PM_DFFS_X1%6_c4 VSS x_PM_DFFS_X1%6_34 5.86129e-17
C_x_PM_DFFS_X1%6_c5 VSS x_PM_DFFS_X1%6_32 8.34856e-17
C_x_PM_DFFS_X1%6_c6 VSS x_PM_DFFS_X1%6_27 4.80236e-17
C_x_PM_DFFS_X1%6_c7 VSS x_PM_DFFS_X1%6_26 1.04973e-16
C_x_PM_DFFS_X1%6_c8 VSS x_PM_DFFS_X1%6_21 1.8618e-17
C_x_PM_DFFS_X1%6_c9 VSS N_6_M9_g 7.06748e-17
C_x_PM_DFFS_X1%6_c10 VSS N_6_M25_g 3.92829e-17
C_x_PM_DFFS_X1%6_c11 VSS x_PM_DFFS_X1%6_10 6.51904e-18
C_x_PM_DFFS_X1%6_c12 VSS x_PM_DFFS_X1%6_9 7.68128e-17
C_x_PM_DFFS_X1%6_c13 VSS N_6_M6_g 4.60836e-17
C_x_PM_DFFS_X1%6_c14 VSS N_6_M23_g 4.55681e-17
R_x_PM_DFFS_X1%6_r15 x_PM_DFFS_X1%6_47 x_PM_DFFS_X1%6_46 1.56
R_x_PM_DFFS_X1%6_r16 x_PM_DFFS_X1%6_46 x_PM_DFFS_X1%6_44 4.42
R_x_PM_DFFS_X1%6_r17 x_PM_DFFS_X1%6_42 x_PM_DFFS_X1%6_39 0.176429
R_x_PM_DFFS_X1%6_r18 x_PM_DFFS_X1%6_44 x_PM_DFFS_X1%6_39 25.0012
R_x_PM_DFFS_X1%6_r19 x_PM_DFFS_X1%6_37 x_PM_DFFS_X1%6_36 0.0418175
R_x_PM_DFFS_X1%6_r20 x_PM_DFFS_X1%6_42 x_PM_DFFS_X1%6_35 0.095
R_x_PM_DFFS_X1%6_r21 x_PM_DFFS_X1%6_36 x_PM_DFFS_X1%6_35 2.36143
R_x_PM_DFFS_X1%6_r22 x_PM_DFFS_X1%6_37 x_PM_DFFS_X1%6_33 0.160909
R_x_PM_DFFS_X1%6_r23 x_PM_DFFS_X1%6_34 x_PM_DFFS_X1%6_33 1.46571
R_x_PM_DFFS_X1%6_r24 x_PM_DFFS_X1%6_37 x_PM_DFFS_X1%6_32 0.160909
R_x_PM_DFFS_X1%6_r25 x_PM_DFFS_X1%6_32 x_PM_DFFS_X1%6_31 1.60143
R_x_PM_DFFS_X1%6_r26 x_PM_DFFS_X1%6_34 x_PM_DFFS_X1%6_27 0.212317
R_x_PM_DFFS_X1%6_r27 N_6_M2_d x_PM_DFFS_X1%6_27 0.420714
R_x_PM_DFFS_X1%6_r28 x_PM_DFFS_X1%6_31 x_PM_DFFS_X1%6_26 0.212317
R_x_PM_DFFS_X1%6_r29 x_PM_DFFS_X1%6_26 N_6_M19_d 0.570339
R_x_PM_DFFS_X1%6_r30 x_PM_DFFS_X1%6_21 x_PM_DFFS_X1%6_19 14.82
R_x_PM_DFFS_X1%6_r31 x_PM_DFFS_X1%6_21 x_PM_DFFS_X1%6_15 1.95
R_x_PM_DFFS_X1%6_r32 N_6_M9_g x_PM_DFFS_X1%6_15 63.18
R_x_PM_DFFS_X1%6_r33 x_PM_DFFS_X1%6_19 x_PM_DFFS_X1%6_12 1.95
R_x_PM_DFFS_X1%6_r34 N_6_M25_g x_PM_DFFS_X1%6_12 32.76
R_x_PM_DFFS_X1%6_r35 N_6_M25_g x_PM_DFFS_X1%6_11 26.52
R_x_PM_DFFS_X1%6_r36 x_PM_DFFS_X1%6_11 x_PM_DFFS_X1%6_9 4.35808
R_x_PM_DFFS_X1%6_r37 x_PM_DFFS_X1%6_10 x_PM_DFFS_X1%6_9 92.04
R_x_PM_DFFS_X1%6_r38 x_PM_DFFS_X1%6_47 x_PM_DFFS_X1%6_5 1.95
R_x_PM_DFFS_X1%6_r39 N_6_M6_g x_PM_DFFS_X1%6_5 51.48
R_x_PM_DFFS_X1%6_r40 x_PM_DFFS_X1%6_46 x_PM_DFFS_X1%6_2 1.95
R_x_PM_DFFS_X1%6_r41 N_6_M23_g x_PM_DFFS_X1%6_2 44.46
R_x_PM_DFFS_X1%6_r42 x_PM_DFFS_X1%6_10 x_PM_DFFS_X1%6_VSS 4.35808
R_x_PM_DFFS_X1%6_r43 N_6_M23_g x_PM_DFFS_X1%6_VSS 20.28
C_x_PM_DFFS_X1%7_c0 VSS x_PM_DFFS_X1%7_14 8.30636e-18
C_x_PM_DFFS_X1%7_c1 VSS x_PM_DFFS_X1%7_11 1.74572e-16
C_x_PM_DFFS_X1%7_c2 VSS N_7_M23_d 1.21809e-16
C_x_PM_DFFS_X1%7_c3 VSS N_7_M4_g 2.07844e-17
C_x_PM_DFFS_X1%7_c4 VSS N_7_M21_g 6.69046e-17
R_x_PM_DFFS_X1%7_r5 x_PM_DFFS_X1%7_24 x_PM_DFFS_X1%7_14 4.7687
R_x_PM_DFFS_X1%7_r6 x_PM_DFFS_X1%7_23 x_PM_DFFS_X1%7_14 4.7687
R_x_PM_DFFS_X1%7_r7 x_PM_DFFS_X1%7_14 x_PM_DFFS_X1%7_12 25.0012
R_x_PM_DFFS_X1%7_r8 N_7_M5_d x_PM_DFFS_X1%7_12 0.83037
R_x_PM_DFFS_X1%7_r9 x_PM_DFFS_X1%7_18 x_PM_DFFS_X1%7_11 0.241334
R_x_PM_DFFS_X1%7_r10 N_7_M5_d x_PM_DFFS_X1%7_11 0.429259
R_x_PM_DFFS_X1%7_r11 N_7_M23_d x_PM_DFFS_X1%7_18 2.48357
R_x_PM_DFFS_X1%7_r12 N_7_M4_g x_PM_DFFS_X1%7_24 18.72
R_x_PM_DFFS_X1%7_r13 N_7_M21_g x_PM_DFFS_X1%7_23 77.22
C_x_PM_DFFS_X1%CK_c0 VSS CK 9.04075e-17
C_x_PM_DFFS_X1%CK_c1 VSS N_CK_M24_g 3.48356e-17
C_x_PM_DFFS_X1%CK_c2 VSS x_PM_DFFS_X1%CK_5 3.12892e-17
C_x_PM_DFFS_X1%CK_c3 VSS N_CK_M7_g 5.04572e-17
C_x_PM_DFFS_X1%CK_c4 VSS x_PM_DFFS_X1%CK_VSS 6.123e-18
R_x_PM_DFFS_X1%CK_r5 x_PM_DFFS_X1%CK_16 x_PM_DFFS_X1%CK_14 25.0012
R_x_PM_DFFS_X1%CK_r6 x_PM_DFFS_X1%CK_14 CK 0.637857
R_x_PM_DFFS_X1%CK_r7 N_CK_M24_g x_PM_DFFS_X1%CK_7 21.84
R_x_PM_DFFS_X1%CK_r8 x_PM_DFFS_X1%CK_16 x_PM_DFFS_X1%CK_6 0.183549
R_x_PM_DFFS_X1%CK_r9 x_PM_DFFS_X1%CK_7 x_PM_DFFS_X1%CK_5 4.58872
R_x_PM_DFFS_X1%CK_r10 x_PM_DFFS_X1%CK_6 x_PM_DFFS_X1%CK_5 20.28
R_x_PM_DFFS_X1%CK_r11 x_PM_DFFS_X1%CK_16 x_PM_DFFS_X1%CK_VSS 4.40517
R_x_PM_DFFS_X1%CK_r12 N_CK_M7_g x_PM_DFFS_X1%CK_VSS 46.8
C_x_PM_DFFS_X1%9_c0 VSS x_PM_DFFS_X1%9_52 4.33077e-17
C_x_PM_DFFS_X1%9_c1 VSS x_PM_DFFS_X1%9_46 5.01048e-17
C_x_PM_DFFS_X1%9_c2 VSS x_PM_DFFS_X1%9_45 1.39377e-17
C_x_PM_DFFS_X1%9_c3 VSS N_9_M11_d 2.41729e-17
C_x_PM_DFFS_X1%9_c4 VSS x_PM_DFFS_X1%9_37 7.82085e-17
C_x_PM_DFFS_X1%9_c5 VSS x_PM_DFFS_X1%9_36 8.3395e-17
C_x_PM_DFFS_X1%9_c6 VSS x_PM_DFFS_X1%9_34 5.08432e-17
C_x_PM_DFFS_X1%9_c7 VSS x_PM_DFFS_X1%9_33 1.04742e-16
C_x_PM_DFFS_X1%9_c8 VSS x_PM_DFFS_X1%9_28 9.11309e-17
C_x_PM_DFFS_X1%9_c9 VSS x_PM_DFFS_X1%9_24 7.17017e-18
C_x_PM_DFFS_X1%9_c10 VSS x_PM_DFFS_X1%9_22 3.38369e-18
C_x_PM_DFFS_X1%9_c11 VSS N_9_M15_g 3.01675e-17
C_x_PM_DFFS_X1%9_c12 VSS N_9_M31_g 4.677e-17
C_x_PM_DFFS_X1%9_c13 VSS x_PM_DFFS_X1%9_11 3.77265e-17
C_x_PM_DFFS_X1%9_c14 VSS x_PM_DFFS_X1%9_9 3.7848e-17
C_x_PM_DFFS_X1%9_c15 VSS N_9_M14_g 4.39991e-17
C_x_PM_DFFS_X1%9_c16 VSS N_9_M30_g 4.0072e-17
R_x_PM_DFFS_X1%9_r17 x_PM_DFFS_X1%9_52 x_PM_DFFS_X1%9_49 25.0012
R_x_PM_DFFS_X1%9_r18 x_PM_DFFS_X1%9_49 x_PM_DFFS_X1%9_46 0.176429
R_x_PM_DFFS_X1%9_r19 N_9_M26_d x_PM_DFFS_X1%9_42 0.277702
R_x_PM_DFFS_X1%9_r20 N_9_M11_d x_PM_DFFS_X1%9_38 0.637857
R_x_PM_DFFS_X1%9_r21 N_9_M26_d x_PM_DFFS_X1%9_37 0.279275
R_x_PM_DFFS_X1%9_r22 x_PM_DFFS_X1%9_46 x_PM_DFFS_X1%9_36 0.095
R_x_PM_DFFS_X1%9_r23 x_PM_DFFS_X1%9_37 x_PM_DFFS_X1%9_36 3.20286
R_x_PM_DFFS_X1%9_r24 x_PM_DFFS_X1%9_45 x_PM_DFFS_X1%9_35 0.160909
R_x_PM_DFFS_X1%9_r25 x_PM_DFFS_X1%9_38 x_PM_DFFS_X1%9_34 0.212317
R_x_PM_DFFS_X1%9_r26 x_PM_DFFS_X1%9_35 x_PM_DFFS_X1%9_34 1.57429
R_x_PM_DFFS_X1%9_r27 x_PM_DFFS_X1%9_45 x_PM_DFFS_X1%9_33 0.0418175
R_x_PM_DFFS_X1%9_r28 x_PM_DFFS_X1%9_33 x_PM_DFFS_X1%9_42 2.14429
R_x_PM_DFFS_X1%9_r29 x_PM_DFFS_X1%9_45 x_PM_DFFS_X1%9_28 0.160909
R_x_PM_DFFS_X1%9_r30 N_9_M8_s x_PM_DFFS_X1%9_28 1.94071
R_x_PM_DFFS_X1%9_r31 x_PM_DFFS_X1%9_52 x_PM_DFFS_X1%9_23 22.4714
R_x_PM_DFFS_X1%9_r32 x_PM_DFFS_X1%9_24 x_PM_DFFS_X1%9_23 2.26208
R_x_PM_DFFS_X1%9_r33 x_PM_DFFS_X1%9_52 x_PM_DFFS_X1%9_21 1.3
R_x_PM_DFFS_X1%9_r34 x_PM_DFFS_X1%9_22 x_PM_DFFS_X1%9_21 2.26208
R_x_PM_DFFS_X1%9_r35 N_9_M15_g x_PM_DFFS_X1%9_17 18.33
R_x_PM_DFFS_X1%9_r36 N_9_M31_g x_PM_DFFS_X1%9_13 42.12
R_x_PM_DFFS_X1%9_r37 x_PM_DFFS_X1%9_24 x_PM_DFFS_X1%9_12 1.89174
R_x_PM_DFFS_X1%9_r38 x_PM_DFFS_X1%9_17 x_PM_DFFS_X1%9_11 4.35808
R_x_PM_DFFS_X1%9_r39 x_PM_DFFS_X1%9_12 x_PM_DFFS_X1%9_11 42.12
R_x_PM_DFFS_X1%9_r40 x_PM_DFFS_X1%9_22 x_PM_DFFS_X1%9_10 1.89174
R_x_PM_DFFS_X1%9_r41 x_PM_DFFS_X1%9_13 x_PM_DFFS_X1%9_9 4.35808
R_x_PM_DFFS_X1%9_r42 x_PM_DFFS_X1%9_10 x_PM_DFFS_X1%9_9 42.12
R_x_PM_DFFS_X1%9_r43 x_PM_DFFS_X1%9_24 x_PM_DFFS_X1%9_5 2.26208
R_x_PM_DFFS_X1%9_r44 N_9_M14_g x_PM_DFFS_X1%9_5 45.24
R_x_PM_DFFS_X1%9_r45 x_PM_DFFS_X1%9_22 x_PM_DFFS_X1%9_VSS 2.26208
R_x_PM_DFFS_X1%9_r46 N_9_M30_g x_PM_DFFS_X1%9_VSS 28.86
C_x_PM_DFFS_X1%10_c0 VSS x_PM_DFFS_X1%10_45 5.82053e-17
C_x_PM_DFFS_X1%10_c1 VSS x_PM_DFFS_X1%10_43 4.33586e-17
C_x_PM_DFFS_X1%10_c2 VSS x_PM_DFFS_X1%10_40 4.06467e-17
C_x_PM_DFFS_X1%10_c3 VSS N_10_M14_d 9.28367e-17
C_x_PM_DFFS_X1%10_c4 VSS x_PM_DFFS_X1%10_30 1.05649e-17
C_x_PM_DFFS_X1%10_c5 VSS x_PM_DFFS_X1%10_27 2.61273e-17
C_x_PM_DFFS_X1%10_c6 VSS x_PM_DFFS_X1%10_26 1.04266e-16
C_x_PM_DFFS_X1%10_c7 VSS x_PM_DFFS_X1%10_24 1.57057e-17
C_x_PM_DFFS_X1%10_c8 VSS x_PM_DFFS_X1%10_22 3.83205e-17
C_x_PM_DFFS_X1%10_c9 VSS x_PM_DFFS_X1%10_18 7.57477e-18
C_x_PM_DFFS_X1%10_c10 VSS x_PM_DFFS_X1%10_17 5.05726e-17
C_x_PM_DFFS_X1%10_c11 VSS N_10_M16_g 4.50252e-17
C_x_PM_DFFS_X1%10_c12 VSS N_10_M32_g 6.89561e-17
C_x_PM_DFFS_X1%10_c13 VSS N_10_M28_g 4.37764e-17
C_x_PM_DFFS_X1%10_c14 VSS N_10_M10_g 4.34048e-17
R_x_PM_DFFS_X1%10_r15 x_PM_DFFS_X1%10_47 x_PM_DFFS_X1%10_46 0.291873
R_x_PM_DFFS_X1%10_r16 x_PM_DFFS_X1%10_46 x_PM_DFFS_X1%10_43 0.00863636
R_x_PM_DFFS_X1%10_r17 x_PM_DFFS_X1%10_45 x_PM_DFFS_X1%10_43 0.283237
R_x_PM_DFFS_X1%10_r18 x_PM_DFFS_X1%10_48 x_PM_DFFS_X1%10_43 25.0012
R_x_PM_DFFS_X1%10_r19 x_PM_DFFS_X1%10_40 N_10_M30_d 0.312143
R_x_PM_DFFS_X1%10_r20 N_10_M14_d x_PM_DFFS_X1%10_47 2.13071
R_x_PM_DFFS_X1%10_r21 x_PM_DFFS_X1%10_40 x_PM_DFFS_X1%10_31 0.095
R_x_PM_DFFS_X1%10_r22 x_PM_DFFS_X1%10_45 x_PM_DFFS_X1%10_31 1.27571
R_x_PM_DFFS_X1%10_r23 x_PM_DFFS_X1%10_55 x_PM_DFFS_X1%10_30 4.7687
R_x_PM_DFFS_X1%10_r24 x_PM_DFFS_X1%10_30 x_PM_DFFS_X1%10_28 25.0012
R_x_PM_DFFS_X1%10_r25 x_PM_DFFS_X1%10_28 x_PM_DFFS_X1%10_27 1.28929
R_x_PM_DFFS_X1%10_r26 x_PM_DFFS_X1%10_46 x_PM_DFFS_X1%10_26 0.095
R_x_PM_DFFS_X1%10_r27 x_PM_DFFS_X1%10_28 x_PM_DFFS_X1%10_26 2.67357
R_x_PM_DFFS_X1%10_r28 x_PM_DFFS_X1%10_24 x_PM_DFFS_X1%10_50 5.46
R_x_PM_DFFS_X1%10_r29 x_PM_DFFS_X1%10_24 x_PM_DFFS_X1%10_22 25.0012
R_x_PM_DFFS_X1%10_r30 x_PM_DFFS_X1%10_27 x_PM_DFFS_X1%10_21 0.212317
R_x_PM_DFFS_X1%10_r31 x_PM_DFFS_X1%10_22 x_PM_DFFS_X1%10_21 0.312143
R_x_PM_DFFS_X1%10_r32 x_PM_DFFS_X1%10_48 x_PM_DFFS_X1%10_17 36.14
R_x_PM_DFFS_X1%10_r33 x_PM_DFFS_X1%10_18 x_PM_DFFS_X1%10_17 0.043368
R_x_PM_DFFS_X1%10_r34 x_PM_DFFS_X1%10_18 x_PM_DFFS_X1%10_13 4.56151
R_x_PM_DFFS_X1%10_r35 N_10_M16_g x_PM_DFFS_X1%10_13 40.95
R_x_PM_DFFS_X1%10_r36 x_PM_DFFS_X1%10_18 x_PM_DFFS_X1%10_9 4.56151
R_x_PM_DFFS_X1%10_r37 N_10_M32_g x_PM_DFFS_X1%10_9 73.32
R_x_PM_DFFS_X1%10_r38 N_10_M28_g x_PM_DFFS_X1%10_55 46.02
R_x_PM_DFFS_X1%10_r39 x_PM_DFFS_X1%10_50 x_PM_DFFS_X1%10_VSS 1.95
R_x_PM_DFFS_X1%10_r40 N_10_M10_g x_PM_DFFS_X1%10_VSS 45.24
C_x_PM_DFFS_X1%SN_c0 VSS x_PM_DFFS_X1%SN_27 1.15725e-17
C_x_PM_DFFS_X1%SN_c1 VSS x_PM_DFFS_X1%SN_20 4.26344e-17
C_x_PM_DFFS_X1%SN_c2 VSS N_SN_M13_g 3.56801e-17
C_x_PM_DFFS_X1%SN_c3 VSS N_SN_M29_g 7.55121e-17
C_x_PM_DFFS_X1%SN_c4 VSS x_PM_DFFS_X1%SN_8 5.58699e-18
C_x_PM_DFFS_X1%SN_c5 VSS x_PM_DFFS_X1%SN_7 1.9747e-16
C_x_PM_DFFS_X1%SN_c6 VSS N_SN_M22_g 1.19568e-16
R_x_PM_DFFS_X1%SN_r7 x_PM_DFFS_X1%SN_27 x_PM_DFFS_X1%SN_22 5.46
R_x_PM_DFFS_X1%SN_r8 x_PM_DFFS_X1%SN_22 x_PM_DFFS_X1%SN_24 1.3
R_x_PM_DFFS_X1%SN_r9 x_PM_DFFS_X1%SN_22 x_PM_DFFS_X1%SN_20 25.0012
R_x_PM_DFFS_X1%SN_r10 x_PM_DFFS_X1%SN_20 SN 0.210357
R_x_PM_DFFS_X1%SN_r11 x_PM_DFFS_X1%SN_27 x_PM_DFFS_X1%SN_13 1.95
R_x_PM_DFFS_X1%SN_r12 N_SN_M13_g x_PM_DFFS_X1%SN_13 28.86
R_x_PM_DFFS_X1%SN_r13 x_PM_DFFS_X1%SN_24 x_PM_DFFS_X1%SN_10 1.95
R_x_PM_DFFS_X1%SN_r14 N_SN_M29_g x_PM_DFFS_X1%SN_10 70.98
R_x_PM_DFFS_X1%SN_r15 N_SN_M29_g x_PM_DFFS_X1%SN_9 46.02
R_x_PM_DFFS_X1%SN_r16 x_PM_DFFS_X1%SN_9 x_PM_DFFS_X1%SN_7 4.35808
R_x_PM_DFFS_X1%SN_r17 x_PM_DFFS_X1%SN_8 x_PM_DFFS_X1%SN_7 244.92
R_x_PM_DFFS_X1%SN_r18 N_SN_M5_g N_SN_M22_g 93.6
R_x_PM_DFFS_X1%SN_r19 x_PM_DFFS_X1%SN_8 x_PM_DFFS_X1%SN_VSS 4.35808
R_x_PM_DFFS_X1%SN_r20 N_SN_M22_g x_PM_DFFS_X1%SN_VSS 39.78
C_x_PM_DFFS_X1%QN_c0 VSS x_PM_DFFS_X1%QN_15 4.99421e-17
C_x_PM_DFFS_X1%QN_c1 VSS x_PM_DFFS_X1%QN_11 1.72598e-17
C_x_PM_DFFS_X1%QN_c2 VSS x_PM_DFFS_X1%QN_10 8.51744e-17
C_x_PM_DFFS_X1%QN_c3 VSS N_QN_M31_s 8.61902e-17
R_x_PM_DFFS_X1%QN_r4 x_PM_DFFS_X1%QN_15 N_QN_M15_s 0.11963
R_x_PM_DFFS_X1%QN_r5 x_PM_DFFS_X1%QN_15 x_PM_DFFS_X1%QN_10 0.095
R_x_PM_DFFS_X1%QN_r6 x_PM_DFFS_X1%QN_10 x_PM_DFFS_X1%QN_11 2.33429
R_x_PM_DFFS_X1%QN_r7 QN N_QN_M31_s 0.457727
R_x_PM_DFFS_X1%QN_r8 x_PM_DFFS_X1%QN_11 x_PM_DFFS_X1%QN_3 0.240055
R_x_PM_DFFS_X1%QN_r9 QN x_PM_DFFS_X1%QN_3 0.293636
C_x_PM_DFFS_X1%Q_c0 VSS x_PM_DFFS_X1%Q_15 4.04714e-18
C_x_PM_DFFS_X1%Q_c1 VSS N_Q_M16_d 3.38115e-17
C_x_PM_DFFS_X1%Q_c2 VSS N_Q_M32_d 5.58713e-17
C_x_PM_DFFS_X1%Q_c3 VSS x_PM_DFFS_X1%Q_3 3.92774e-17
R_x_PM_DFFS_X1%Q_r4 x_PM_DFFS_X1%Q_15 x_PM_DFFS_X1%Q_11 0.273842
R_x_PM_DFFS_X1%Q_r5 N_Q_M16_d x_PM_DFFS_X1%Q_11 1.56071
R_x_PM_DFFS_X1%Q_r6 x_PM_DFFS_X1%Q_15 x_PM_DFFS_X1%Q_7 0.273842
R_x_PM_DFFS_X1%Q_r7 N_Q_M32_d x_PM_DFFS_X1%Q_7 1.85929
R_x_PM_DFFS_X1%Q_r8 x_PM_DFFS_X1%Q_15 x_PM_DFFS_X1%Q_3 0.0307623
R_x_PM_DFFS_X1%Q_r9 Q x_PM_DFFS_X1%Q_3 0.339286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFFS_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFFS_X2 VSS VDD D CK SN QN Q
*.PININFO VSS:B VDD:B D:I CK:I SN:I QN:O Q:O
M_M16 N_VDD_M0_d N_5_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M17 14 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M18 N_6_M2_d N_3_M2_g 14 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M19 15 N_5_M3_g N_6_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M20 N_VDD_M4_d N_7_M4_g 15 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M21 N_7_M5_d N_SN_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_VDD_M6_d N_6_M6_g N_7_M5_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M23 N_5_M7_d N_CK_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M24 16 N_5_M8_g N_9_M8_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M9_d N_6_M9_g 16 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 17 N_10_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M27 N_9_M11_d N_3_M11_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 18 N_3_M12_g N_9_M11_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_VDD_M13_d N_SN_M13_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M30 N_10_M14_d N_9_M14_g N_VDD_M13_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M15_d N_9_M15_g N_QN_M15_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M32 N_Q_M16_d N_10_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M17_d N_5_M17_g N_3_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 19 N_D_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_6_M19_d N_5_M19_g 19 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 20 N_3_M20_g N_6_M19_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_VSS_M21_d N_7_M21_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 21 N_SN_M22_g N_VSS_M21_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_7_M23_d N_6_M23_g 21 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_VSS_M24_d N_CK_M24_g N_5_M24_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 22 N_6_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 N_9_M26_d N_3_M26_g 22 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 23 N_5_M27_g N_9_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 24 N_10_M28_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_VSS_M29_d N_SN_M29_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 N_10_M30_d N_9_M30_g N_VSS_M29_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M14 N_VSS_M31_d N_9_M31_g N_QN_M31_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_Q_M32_d N_10_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_DFFS_X2%VSS_c0 VSS x_PM_DFFS_X2%VSS_44 3.83683e-17
C_x_PM_DFFS_X2%VSS_c1 VSS x_PM_DFFS_X2%VSS_43 6.41071e-18
C_x_PM_DFFS_X2%VSS_c2 VSS x_PM_DFFS_X2%VSS_42 4.64531e-18
C_x_PM_DFFS_X2%VSS_c3 VSS x_PM_DFFS_X2%VSS_41 2.7646e-18
C_x_PM_DFFS_X2%VSS_c4 VSS x_PM_DFFS_X2%VSS_40 2.75846e-17
C_x_PM_DFFS_X2%VSS_c5 VSS N_VSS_M31_d 1.56687e-17
C_x_PM_DFFS_X2%VSS_c6 VSS x_PM_DFFS_X2%VSS_32 6.69418e-17
C_x_PM_DFFS_X2%VSS_c7 VSS N_VSS_M29_d 7.30087e-17
C_x_PM_DFFS_X2%VSS_c8 VSS x_PM_DFFS_X2%VSS_26 1.16002e-16
C_x_PM_DFFS_X2%VSS_c9 VSS VSS 7.90921e-17
C_x_PM_DFFS_X2%VSS_c10 VSS x_PM_DFFS_X2%VSS_18 1.65678e-16
C_x_PM_DFFS_X2%VSS_c11 VSS N_VSS_M21_d 7.52795e-17
C_x_PM_DFFS_X2%VSS_c12 VSS x_PM_DFFS_X2%VSS_12 1.40875e-16
C_x_PM_DFFS_X2%VSS_c13 VSS N_VSS_M17_d 2.89304e-17
R_x_PM_DFFS_X2%VSS_r14 x_PM_DFFS_X2%VSS_44 x_PM_DFFS_X2%VSS_34 0.145286
R_x_PM_DFFS_X2%VSS_r15 N_VSS_M31_d x_PM_DFFS_X2%VSS_34 0.230714
R_x_PM_DFFS_X2%VSS_r16 x_PM_DFFS_X2%VSS_43 x_PM_DFFS_X2%VSS_33 0.132285
R_x_PM_DFFS_X2%VSS_r17 x_PM_DFFS_X2%VSS_44 x_PM_DFFS_X2%VSS_32 0.0731438
R_x_PM_DFFS_X2%VSS_r18 x_PM_DFFS_X2%VSS_33 x_PM_DFFS_X2%VSS_32 1.11765
R_x_PM_DFFS_X2%VSS_r19 x_PM_DFFS_X2%VSS_43 x_PM_DFFS_X2%VSS_28 0.0680382
R_x_PM_DFFS_X2%VSS_r20 N_VSS_M29_d x_PM_DFFS_X2%VSS_28 0.823333
R_x_PM_DFFS_X2%VSS_r21 x_PM_DFFS_X2%VSS_42 x_PM_DFFS_X2%VSS_27 0.0731438
R_x_PM_DFFS_X2%VSS_r22 x_PM_DFFS_X2%VSS_43 x_PM_DFFS_X2%VSS_26 0.132285
R_x_PM_DFFS_X2%VSS_r23 x_PM_DFFS_X2%VSS_27 x_PM_DFFS_X2%VSS_26 1.91118
R_x_PM_DFFS_X2%VSS_r24 N_VSS_M24_d VSS 1.07214
R_x_PM_DFFS_X2%VSS_r25 x_PM_DFFS_X2%VSS_42 x_PM_DFFS_X2%VSS_20 0.145286
R_x_PM_DFFS_X2%VSS_r26 VSS x_PM_DFFS_X2%VSS_20 0.515714
R_x_PM_DFFS_X2%VSS_r27 x_PM_DFFS_X2%VSS_41 x_PM_DFFS_X2%VSS_19 0.0731438
R_x_PM_DFFS_X2%VSS_r28 x_PM_DFFS_X2%VSS_42 x_PM_DFFS_X2%VSS_18 0.0731438
R_x_PM_DFFS_X2%VSS_r29 x_PM_DFFS_X2%VSS_19 x_PM_DFFS_X2%VSS_18 1.76588
R_x_PM_DFFS_X2%VSS_r30 x_PM_DFFS_X2%VSS_41 x_PM_DFFS_X2%VSS_14 0.145286
R_x_PM_DFFS_X2%VSS_r31 N_VSS_M21_d x_PM_DFFS_X2%VSS_14 1.18071
R_x_PM_DFFS_X2%VSS_r32 x_PM_DFFS_X2%VSS_40 x_PM_DFFS_X2%VSS_13 0.0731438
R_x_PM_DFFS_X2%VSS_r33 x_PM_DFFS_X2%VSS_41 x_PM_DFFS_X2%VSS_12 0.0731438
R_x_PM_DFFS_X2%VSS_r34 x_PM_DFFS_X2%VSS_13 x_PM_DFFS_X2%VSS_12 1.69882
R_x_PM_DFFS_X2%VSS_r35 x_PM_DFFS_X2%VSS_40 x_PM_DFFS_X2%VSS_8 0.145286
R_x_PM_DFFS_X2%VSS_r36 N_VSS_M17_d x_PM_DFFS_X2%VSS_8 0.692143
C_x_PM_DFFS_X2%VDD_c0 VSS x_PM_DFFS_X2%VDD_48 4.15683e-17
C_x_PM_DFFS_X2%VDD_c1 VSS x_PM_DFFS_X2%VDD_47 2.78352e-18
C_x_PM_DFFS_X2%VDD_c2 VSS x_PM_DFFS_X2%VDD_46 8.89791e-18
C_x_PM_DFFS_X2%VDD_c3 VSS x_PM_DFFS_X2%VDD_45 8.96913e-18
C_x_PM_DFFS_X2%VDD_c4 VSS x_PM_DFFS_X2%VDD_44 8.86015e-18
C_x_PM_DFFS_X2%VDD_c5 VSS x_PM_DFFS_X2%VDD_43 2.91027e-18
C_x_PM_DFFS_X2%VDD_c6 VSS N_VDD_M15_d 2.4358e-17
C_x_PM_DFFS_X2%VDD_c7 VSS x_PM_DFFS_X2%VDD_35 4.60475e-17
C_x_PM_DFFS_X2%VDD_c8 VSS N_VDD_M13_d 3.53684e-17
C_x_PM_DFFS_X2%VDD_c9 VSS x_PM_DFFS_X2%VDD_29 6.58025e-17
C_x_PM_DFFS_X2%VDD_c10 VSS x_PM_DFFS_X2%VDD_28 5.33645e-17
C_x_PM_DFFS_X2%VDD_c11 VSS x_PM_DFFS_X2%VDD_25 6.3311e-17
C_x_PM_DFFS_X2%VDD_c12 VSS N_VDD_M6_d 7.68134e-17
C_x_PM_DFFS_X2%VDD_c13 VSS x_PM_DFFS_X2%VDD_19 2.17167e-17
C_x_PM_DFFS_X2%VDD_c14 VSS x_PM_DFFS_X2%VDD_18 2.0829e-17
C_x_PM_DFFS_X2%VDD_c15 VSS x_PM_DFFS_X2%VDD_15 7.48258e-17
C_x_PM_DFFS_X2%VDD_c16 VSS N_VDD_M0_d 3.3481e-17
C_x_PM_DFFS_X2%VDD_c17 VSS x_PM_DFFS_X2%VDD_7 2.74662e-17
R_x_PM_DFFS_X2%VDD_r18 x_PM_DFFS_X2%VDD_48 x_PM_DFFS_X2%VDD_37 0.145286
R_x_PM_DFFS_X2%VDD_r19 N_VDD_M15_d x_PM_DFFS_X2%VDD_37 0.420714
R_x_PM_DFFS_X2%VDD_r20 x_PM_DFFS_X2%VDD_47 x_PM_DFFS_X2%VDD_36 0.0731438
R_x_PM_DFFS_X2%VDD_r21 x_PM_DFFS_X2%VDD_48 x_PM_DFFS_X2%VDD_35 0.0731438
R_x_PM_DFFS_X2%VDD_r22 x_PM_DFFS_X2%VDD_36 x_PM_DFFS_X2%VDD_35 1.02824
R_x_PM_DFFS_X2%VDD_r23 x_PM_DFFS_X2%VDD_47 x_PM_DFFS_X2%VDD_31 0.145286
R_x_PM_DFFS_X2%VDD_r24 N_VDD_M13_d x_PM_DFFS_X2%VDD_31 1.20786
R_x_PM_DFFS_X2%VDD_r25 x_PM_DFFS_X2%VDD_46 x_PM_DFFS_X2%VDD_30 0.132285
R_x_PM_DFFS_X2%VDD_r26 x_PM_DFFS_X2%VDD_47 x_PM_DFFS_X2%VDD_29 0.0731438
R_x_PM_DFFS_X2%VDD_r27 x_PM_DFFS_X2%VDD_30 x_PM_DFFS_X2%VDD_29 1.47529
R_x_PM_DFFS_X2%VDD_r28 x_PM_DFFS_X2%VDD_46 x_PM_DFFS_X2%VDD_28 0.0680382
R_x_PM_DFFS_X2%VDD_r29 x_PM_DFFS_X2%VDD_28 N_VDD_M9_d 0.558398
R_x_PM_DFFS_X2%VDD_r30 x_PM_DFFS_X2%VDD_45 x_PM_DFFS_X2%VDD_26 0.132285
R_x_PM_DFFS_X2%VDD_r31 x_PM_DFFS_X2%VDD_46 x_PM_DFFS_X2%VDD_25 0.132285
R_x_PM_DFFS_X2%VDD_r32 x_PM_DFFS_X2%VDD_26 x_PM_DFFS_X2%VDD_25 1.37471
R_x_PM_DFFS_X2%VDD_r33 x_PM_DFFS_X2%VDD_45 x_PM_DFFS_X2%VDD_21 0.0680382
R_x_PM_DFFS_X2%VDD_r34 N_VDD_M6_d x_PM_DFFS_X2%VDD_21 0.978148
R_x_PM_DFFS_X2%VDD_r35 x_PM_DFFS_X2%VDD_44 x_PM_DFFS_X2%VDD_20 0.132285
R_x_PM_DFFS_X2%VDD_r36 x_PM_DFFS_X2%VDD_45 x_PM_DFFS_X2%VDD_19 0.132285
R_x_PM_DFFS_X2%VDD_r37 x_PM_DFFS_X2%VDD_20 x_PM_DFFS_X2%VDD_19 0.547647
R_x_PM_DFFS_X2%VDD_r38 x_PM_DFFS_X2%VDD_44 x_PM_DFFS_X2%VDD_18 0.0680382
R_x_PM_DFFS_X2%VDD_r39 x_PM_DFFS_X2%VDD_18 N_VDD_M4_d 0.403583
R_x_PM_DFFS_X2%VDD_r40 x_PM_DFFS_X2%VDD_43 x_PM_DFFS_X2%VDD_16 0.0731438
R_x_PM_DFFS_X2%VDD_r41 x_PM_DFFS_X2%VDD_44 x_PM_DFFS_X2%VDD_15 0.132285
R_x_PM_DFFS_X2%VDD_r42 x_PM_DFFS_X2%VDD_16 x_PM_DFFS_X2%VDD_15 1.60941
R_x_PM_DFFS_X2%VDD_r43 x_PM_DFFS_X2%VDD_43 x_PM_DFFS_X2%VDD_11 0.145286
R_x_PM_DFFS_X2%VDD_r44 N_VDD_M0_d x_PM_DFFS_X2%VDD_11 0.502143
R_x_PM_DFFS_X2%VDD_r45 x_PM_DFFS_X2%VDD_43 x_PM_DFFS_X2%VDD_7 0.0731438
R_x_PM_DFFS_X2%VDD_r46 VDD x_PM_DFFS_X2%VDD_7 0.251471
C_x_PM_DFFS_X2%3_c0 VSS x_PM_DFFS_X2%3_57 2.21911e-17
C_x_PM_DFFS_X2%3_c1 VSS x_PM_DFFS_X2%3_52 9.33429e-18
C_x_PM_DFFS_X2%3_c2 VSS x_PM_DFFS_X2%3_49 2.13751e-18
C_x_PM_DFFS_X2%3_c3 VSS x_PM_DFFS_X2%3_45 1.21931e-16
C_x_PM_DFFS_X2%3_c4 VSS x_PM_DFFS_X2%3_42 4.03347e-17
C_x_PM_DFFS_X2%3_c5 VSS x_PM_DFFS_X2%3_41 7.14562e-18
C_x_PM_DFFS_X2%3_c6 VSS x_PM_DFFS_X2%3_40 1.32404e-17
C_x_PM_DFFS_X2%3_c7 VSS x_PM_DFFS_X2%3_38 8.29309e-17
C_x_PM_DFFS_X2%3_c8 VSS N_3_M0_s 1.67052e-17
C_x_PM_DFFS_X2%3_c9 VSS N_3_M17_s 8.10355e-17
C_x_PM_DFFS_X2%3_c10 VSS x_PM_DFFS_X2%3_27 4.48664e-18
C_x_PM_DFFS_X2%3_c11 VSS N_3_M12_g 2.45076e-17
C_x_PM_DFFS_X2%3_c12 VSS x_PM_DFFS_X2%3_21 2.17026e-17
C_x_PM_DFFS_X2%3_c13 VSS N_3_M11_g 6.58786e-17
C_x_PM_DFFS_X2%3_c14 VSS x_PM_DFFS_X2%3_16 5.35738e-18
C_x_PM_DFFS_X2%3_c15 VSS x_PM_DFFS_X2%3_15 3.31941e-17
C_x_PM_DFFS_X2%3_c16 VSS N_3_M26_g 2.9182e-17
C_x_PM_DFFS_X2%3_c17 VSS N_3_M20_g 2.87102e-17
C_x_PM_DFFS_X2%3_c18 VSS x_PM_DFFS_X2%3_6 6.4868e-18
C_x_PM_DFFS_X2%3_c19 VSS x_PM_DFFS_X2%3_5 2.28825e-16
C_x_PM_DFFS_X2%3_c20 VSS N_3_M2_g 3.25298e-17
R_x_PM_DFFS_X2%3_r21 x_PM_DFFS_X2%3_52 x_PM_DFFS_X2%3_50 25.0012
R_x_PM_DFFS_X2%3_r22 x_PM_DFFS_X2%3_57 x_PM_DFFS_X2%3_47 8.06
R_x_PM_DFFS_X2%3_r23 x_PM_DFFS_X2%3_47 x_PM_DFFS_X2%3_45 25.0012
R_x_PM_DFFS_X2%3_r24 x_PM_DFFS_X2%3_45 x_PM_DFFS_X2%3_44 2.04929
R_x_PM_DFFS_X2%3_r25 x_PM_DFFS_X2%3_50 x_PM_DFFS_X2%3_43 0.0151655
R_x_PM_DFFS_X2%3_r26 x_PM_DFFS_X2%3_44 x_PM_DFFS_X2%3_42 0.212317
R_x_PM_DFFS_X2%3_r27 x_PM_DFFS_X2%3_43 x_PM_DFFS_X2%3_42 0.461429
R_x_PM_DFFS_X2%3_r28 x_PM_DFFS_X2%3_50 x_PM_DFFS_X2%3_40 0.197151
R_x_PM_DFFS_X2%3_r29 x_PM_DFFS_X2%3_41 x_PM_DFFS_X2%3_40 0.461429
R_x_PM_DFFS_X2%3_r30 x_PM_DFFS_X2%3_49 x_PM_DFFS_X2%3_39 0.0418175
R_x_PM_DFFS_X2%3_r31 x_PM_DFFS_X2%3_41 x_PM_DFFS_X2%3_38 0.212317
R_x_PM_DFFS_X2%3_r32 x_PM_DFFS_X2%3_39 x_PM_DFFS_X2%3_38 2.06286
R_x_PM_DFFS_X2%3_r33 x_PM_DFFS_X2%3_49 x_PM_DFFS_X2%3_34 0.160909
R_x_PM_DFFS_X2%3_r34 N_3_M0_s x_PM_DFFS_X2%3_34 0.149286
R_x_PM_DFFS_X2%3_r35 x_PM_DFFS_X2%3_49 x_PM_DFFS_X2%3_30 0.160909
R_x_PM_DFFS_X2%3_r36 N_3_M17_s x_PM_DFFS_X2%3_30 3.81357
R_x_PM_DFFS_X2%3_r37 N_3_M12_g x_PM_DFFS_X2%3_23 35.1
R_x_PM_DFFS_X2%3_r38 x_PM_DFFS_X2%3_27 x_PM_DFFS_X2%3_22 3.30287
R_x_PM_DFFS_X2%3_r39 x_PM_DFFS_X2%3_23 x_PM_DFFS_X2%3_21 4.35808
R_x_PM_DFFS_X2%3_r40 x_PM_DFFS_X2%3_22 x_PM_DFFS_X2%3_21 21.84
R_x_PM_DFFS_X2%3_r41 x_PM_DFFS_X2%3_27 x_PM_DFFS_X2%3_18 0.858359
R_x_PM_DFFS_X2%3_r42 N_3_M11_g x_PM_DFFS_X2%3_18 35.1
R_x_PM_DFFS_X2%3_r43 N_3_M11_g x_PM_DFFS_X2%3_17 74.88
R_x_PM_DFFS_X2%3_r44 x_PM_DFFS_X2%3_17 x_PM_DFFS_X2%3_15 4.35808
R_x_PM_DFFS_X2%3_r45 x_PM_DFFS_X2%3_16 x_PM_DFFS_X2%3_15 31.98
R_x_PM_DFFS_X2%3_r46 x_PM_DFFS_X2%3_16 x_PM_DFFS_X2%3_11 4.35808
R_x_PM_DFFS_X2%3_r47 N_3_M26_g x_PM_DFFS_X2%3_11 26.52
R_x_PM_DFFS_X2%3_r48 x_PM_DFFS_X2%3_57 x_PM_DFFS_X2%3_7 1.95
R_x_PM_DFFS_X2%3_r49 N_3_M20_g x_PM_DFFS_X2%3_7 21.84
R_x_PM_DFFS_X2%3_r50 x_PM_DFFS_X2%3_27 x_PM_DFFS_X2%3_5 3.30287
R_x_PM_DFFS_X2%3_r51 x_PM_DFFS_X2%3_6 x_PM_DFFS_X2%3_5 296.4
R_x_PM_DFFS_X2%3_r52 x_PM_DFFS_X2%3_6 x_PM_DFFS_X2%3_2 4.35808
R_x_PM_DFFS_X2%3_r53 N_3_M2_g x_PM_DFFS_X2%3_2 28.86
R_x_PM_DFFS_X2%3_r54 x_PM_DFFS_X2%3_VSS x_PM_DFFS_X2%3_52 4.7687
R_x_PM_DFFS_X2%3_r55 N_3_M2_g x_PM_DFFS_X2%3_VSS 28.86
C_x_PM_DFFS_X2%D_c0 VSS x_PM_DFFS_X2%D_17 9.00873e-18
C_x_PM_DFFS_X2%D_c1 VSS x_PM_DFFS_X2%D_11 1.15584e-17
C_x_PM_DFFS_X2%D_c2 VSS x_PM_DFFS_X2%D_9 1.90929e-16
C_x_PM_DFFS_X2%D_c3 VSS N_D_M1_g 4.23764e-17
C_x_PM_DFFS_X2%D_c4 VSS N_D_M18_g 2.84111e-17
R_x_PM_DFFS_X2%D_r5 x_PM_DFFS_X2%D_21 x_PM_DFFS_X2%D_17 4.7687
R_x_PM_DFFS_X2%D_r6 x_PM_DFFS_X2%D_17 x_PM_DFFS_X2%D_15 25.0012
R_x_PM_DFFS_X2%D_r7 x_PM_DFFS_X2%D_15 D 0.63129
R_x_PM_DFFS_X2%D_r8 x_PM_DFFS_X2%D_23 x_PM_DFFS_X2%D_11 4.7687
R_x_PM_DFFS_X2%D_r9 x_PM_DFFS_X2%D_11 x_PM_DFFS_X2%D_9 25.0012
R_x_PM_DFFS_X2%D_r10 D x_PM_DFFS_X2%D_9 0.459677
R_x_PM_DFFS_X2%D_r11 N_D_M1_g x_PM_DFFS_X2%D_21 31.2
R_x_PM_DFFS_X2%D_r12 N_D_M18_g x_PM_DFFS_X2%D_23 21.84
C_x_PM_DFFS_X2%5_c0 VSS x_PM_DFFS_X2%5_74 9.27195e-18
C_x_PM_DFFS_X2%5_c1 VSS x_PM_DFFS_X2%5_65 5.80642e-17
C_x_PM_DFFS_X2%5_c2 VSS x_PM_DFFS_X2%5_63 3.16462e-17
C_x_PM_DFFS_X2%5_c3 VSS x_PM_DFFS_X2%5_62 9.74049e-17
C_x_PM_DFFS_X2%5_c4 VSS x_PM_DFFS_X2%5_60 9.45168e-18
C_x_PM_DFFS_X2%5_c5 VSS x_PM_DFFS_X2%5_57 3.18155e-17
C_x_PM_DFFS_X2%5_c6 VSS x_PM_DFFS_X2%5_56 7.06877e-17
C_x_PM_DFFS_X2%5_c7 VSS N_5_M24_s 8.62449e-17
C_x_PM_DFFS_X2%5_c8 VSS N_5_M7_d 3.22515e-17
C_x_PM_DFFS_X2%5_c9 VSS x_PM_DFFS_X2%5_47 2.52046e-17
C_x_PM_DFFS_X2%5_c10 VSS x_PM_DFFS_X2%5_46 1.62191e-16
C_x_PM_DFFS_X2%5_c11 VSS x_PM_DFFS_X2%5_45 3.36752e-17
C_x_PM_DFFS_X2%5_c12 VSS x_PM_DFFS_X2%5_43 2.8701e-17
C_x_PM_DFFS_X2%5_c13 VSS x_PM_DFFS_X2%5_42 7.80938e-17
C_x_PM_DFFS_X2%5_c14 VSS x_PM_DFFS_X2%5_41 5.62036e-17
C_x_PM_DFFS_X2%5_c15 VSS x_PM_DFFS_X2%5_39 2.37751e-17
C_x_PM_DFFS_X2%5_c16 VSS x_PM_DFFS_X2%5_38 1.6435e-16
C_x_PM_DFFS_X2%5_c17 VSS x_PM_DFFS_X2%5_34 8.40756e-17
C_x_PM_DFFS_X2%5_c18 VSS x_PM_DFFS_X2%5_30 5.8296e-18
C_x_PM_DFFS_X2%5_c19 VSS x_PM_DFFS_X2%5_29 3.65549e-17
C_x_PM_DFFS_X2%5_c20 VSS x_PM_DFFS_X2%5_28 8.45509e-18
C_x_PM_DFFS_X2%5_c21 VSS N_5_M27_g 2.298e-17
C_x_PM_DFFS_X2%5_c22 VSS N_5_M8_g 3.854e-17
C_x_PM_DFFS_X2%5_c23 VSS N_5_M3_g 6.77879e-17
C_x_PM_DFFS_X2%5_c24 VSS x_PM_DFFS_X2%5_13 2.54619e-17
C_x_PM_DFFS_X2%5_c25 VSS N_5_M19_g 4.02396e-17
C_x_PM_DFFS_X2%5_c26 VSS N_5_M0_g 8.08083e-17
C_x_PM_DFFS_X2%5_c27 VSS N_5_M17_g 5.09092e-17
R_x_PM_DFFS_X2%5_r28 x_PM_DFFS_X2%5_69 x_PM_DFFS_X2%5_68 0.551451
R_x_PM_DFFS_X2%5_r29 x_PM_DFFS_X2%5_74 x_PM_DFFS_X2%5_65 25.0012
R_x_PM_DFFS_X2%5_r30 x_PM_DFFS_X2%5_65 x_PM_DFFS_X2%5_63 1.64214
R_x_PM_DFFS_X2%5_r31 x_PM_DFFS_X2%5_63 x_PM_DFFS_X2%5_61 0.212317
R_x_PM_DFFS_X2%5_r32 x_PM_DFFS_X2%5_62 x_PM_DFFS_X2%5_61 2.60571
R_x_PM_DFFS_X2%5_r33 x_PM_DFFS_X2%5_73 x_PM_DFFS_X2%5_60 4.7687
R_x_PM_DFFS_X2%5_r34 x_PM_DFFS_X2%5_60 x_PM_DFFS_X2%5_58 25.0012
R_x_PM_DFFS_X2%5_r35 x_PM_DFFS_X2%5_69 x_PM_DFFS_X2%5_57 0.16181
R_x_PM_DFFS_X2%5_r36 x_PM_DFFS_X2%5_58 x_PM_DFFS_X2%5_57 0.525294
R_x_PM_DFFS_X2%5_r37 x_PM_DFFS_X2%5_62 x_PM_DFFS_X2%5_56 0.214913
R_x_PM_DFFS_X2%5_r38 x_PM_DFFS_X2%5_58 x_PM_DFFS_X2%5_56 0.592353
R_x_PM_DFFS_X2%5_r39 x_PM_DFFS_X2%5_69 x_PM_DFFS_X2%5_53 0.10653
R_x_PM_DFFS_X2%5_r40 N_5_M24_s x_PM_DFFS_X2%5_53 1.64214
R_x_PM_DFFS_X2%5_r41 N_5_M24_s x_PM_DFFS_X2%5_52 1.18071
R_x_PM_DFFS_X2%5_r42 x_PM_DFFS_X2%5_68 x_PM_DFFS_X2%5_48 0.10653
R_x_PM_DFFS_X2%5_r43 N_5_M7_d x_PM_DFFS_X2%5_48 0.692143
R_x_PM_DFFS_X2%5_r44 x_PM_DFFS_X2%5_52 x_PM_DFFS_X2%5_46 0.212317
R_x_PM_DFFS_X2%5_r45 x_PM_DFFS_X2%5_47 x_PM_DFFS_X2%5_46 2.17143
R_x_PM_DFFS_X2%5_r46 x_PM_DFFS_X2%5_47 x_PM_DFFS_X2%5_44 0.212317
R_x_PM_DFFS_X2%5_r47 x_PM_DFFS_X2%5_45 x_PM_DFFS_X2%5_44 1.16714
R_x_PM_DFFS_X2%5_r48 x_PM_DFFS_X2%5_45 x_PM_DFFS_X2%5_42 0.212317
R_x_PM_DFFS_X2%5_r49 x_PM_DFFS_X2%5_43 x_PM_DFFS_X2%5_42 1.46571
R_x_PM_DFFS_X2%5_r50 x_PM_DFFS_X2%5_43 x_PM_DFFS_X2%5_41 0.212317
R_x_PM_DFFS_X2%5_r51 x_PM_DFFS_X2%5_41 x_PM_DFFS_X2%5_40 1.16714
R_x_PM_DFFS_X2%5_r52 x_PM_DFFS_X2%5_40 x_PM_DFFS_X2%5_38 0.212317
R_x_PM_DFFS_X2%5_r53 x_PM_DFFS_X2%5_39 x_PM_DFFS_X2%5_38 2.06286
R_x_PM_DFFS_X2%5_r54 x_PM_DFFS_X2%5_36 x_PM_DFFS_X2%5_34 25.0012
R_x_PM_DFFS_X2%5_r55 x_PM_DFFS_X2%5_39 x_PM_DFFS_X2%5_33 0.212317
R_x_PM_DFFS_X2%5_r56 x_PM_DFFS_X2%5_34 x_PM_DFFS_X2%5_33 2.02214
R_x_PM_DFFS_X2%5_r57 x_PM_DFFS_X2%5_36 x_PM_DFFS_X2%5_29 1.43684
R_x_PM_DFFS_X2%5_r58 x_PM_DFFS_X2%5_30 x_PM_DFFS_X2%5_29 2.40002
R_x_PM_DFFS_X2%5_r59 x_PM_DFFS_X2%5_36 x_PM_DFFS_X2%5_27 25.6579
R_x_PM_DFFS_X2%5_r60 x_PM_DFFS_X2%5_28 x_PM_DFFS_X2%5_27 0.530495
R_x_PM_DFFS_X2%5_r61 x_PM_DFFS_X2%5_23 x_PM_DFFS_X2%5_74 4.7687
R_x_PM_DFFS_X2%5_r62 N_5_M27_g x_PM_DFFS_X2%5_23 18.72
R_x_PM_DFFS_X2%5_r63 N_5_M8_g x_PM_DFFS_X2%5_73 28.86
R_x_PM_DFFS_X2%5_r64 N_5_M3_g x_PM_DFFS_X2%5_15 76.44
R_x_PM_DFFS_X2%5_r65 x_PM_DFFS_X2%5_30 x_PM_DFFS_X2%5_14 2.40002
R_x_PM_DFFS_X2%5_r66 x_PM_DFFS_X2%5_15 x_PM_DFFS_X2%5_13 4.35808
R_x_PM_DFFS_X2%5_r67 x_PM_DFFS_X2%5_14 x_PM_DFFS_X2%5_13 24.96
R_x_PM_DFFS_X2%5_r68 x_PM_DFFS_X2%5_30 x_PM_DFFS_X2%5_9 1.73193
R_x_PM_DFFS_X2%5_r69 N_5_M19_g x_PM_DFFS_X2%5_9 45.24
R_x_PM_DFFS_X2%5_r70 x_PM_DFFS_X2%5_28 x_PM_DFFS_X2%5_5 5.4228
R_x_PM_DFFS_X2%5_r71 N_5_M0_g x_PM_DFFS_X2%5_5 81.12
R_x_PM_DFFS_X2%5_r72 x_PM_DFFS_X2%5_28 x_PM_DFFS_X2%5_VSS 5.4228
R_x_PM_DFFS_X2%5_r73 N_5_M17_g x_PM_DFFS_X2%5_VSS 45.24
C_x_PM_DFFS_X2%6_c0 VSS x_PM_DFFS_X2%6_50 9.74467e-18
C_x_PM_DFFS_X2%6_c1 VSS x_PM_DFFS_X2%6_42 4.71398e-17
C_x_PM_DFFS_X2%6_c2 VSS x_PM_DFFS_X2%6_41 2.31521e-17
C_x_PM_DFFS_X2%6_c3 VSS x_PM_DFFS_X2%6_39 8.37333e-17
C_x_PM_DFFS_X2%6_c4 VSS x_PM_DFFS_X2%6_38 7.07372e-17
C_x_PM_DFFS_X2%6_c5 VSS x_PM_DFFS_X2%6_36 7.1587e-17
C_x_PM_DFFS_X2%6_c6 VSS x_PM_DFFS_X2%6_34 2.86586e-17
C_x_PM_DFFS_X2%6_c7 VSS x_PM_DFFS_X2%6_33 1.76009e-17
C_x_PM_DFFS_X2%6_c8 VSS N_6_M2_d 2.04897e-17
C_x_PM_DFFS_X2%6_c9 VSS x_PM_DFFS_X2%6_25 1.00188e-16
C_x_PM_DFFS_X2%6_c10 VSS x_PM_DFFS_X2%6_21 1.63353e-17
C_x_PM_DFFS_X2%6_c11 VSS N_6_M9_g 5.9524e-17
C_x_PM_DFFS_X2%6_c12 VSS N_6_M25_g 4.68819e-17
C_x_PM_DFFS_X2%6_c13 VSS x_PM_DFFS_X2%6_10 6.66932e-18
C_x_PM_DFFS_X2%6_c14 VSS x_PM_DFFS_X2%6_9 8.23408e-17
C_x_PM_DFFS_X2%6_c15 VSS N_6_M6_g 3.8712e-17
C_x_PM_DFFS_X2%6_c16 VSS N_6_M23_g 4.4731e-17
R_x_PM_DFFS_X2%6_r17 x_PM_DFFS_X2%6_50 x_PM_DFFS_X2%6_48 2.34
R_x_PM_DFFS_X2%6_r18 x_PM_DFFS_X2%6_48 x_PM_DFFS_X2%6_45 25.0012
R_x_PM_DFFS_X2%6_r19 x_PM_DFFS_X2%6_45 x_PM_DFFS_X2%6_42 0.176429
R_x_PM_DFFS_X2%6_r20 x_PM_DFFS_X2%6_41 x_PM_DFFS_X2%6_40 0.0418175
R_x_PM_DFFS_X2%6_r21 x_PM_DFFS_X2%6_42 x_PM_DFFS_X2%6_39 0.095
R_x_PM_DFFS_X2%6_r22 x_PM_DFFS_X2%6_40 x_PM_DFFS_X2%6_39 2.47
R_x_PM_DFFS_X2%6_r23 x_PM_DFFS_X2%6_41 x_PM_DFFS_X2%6_37 0.160909
R_x_PM_DFFS_X2%6_r24 x_PM_DFFS_X2%6_38 x_PM_DFFS_X2%6_37 1.79143
R_x_PM_DFFS_X2%6_r25 x_PM_DFFS_X2%6_41 x_PM_DFFS_X2%6_36 0.160909
R_x_PM_DFFS_X2%6_r26 x_PM_DFFS_X2%6_36 x_PM_DFFS_X2%6_35 1.33
R_x_PM_DFFS_X2%6_r27 x_PM_DFFS_X2%6_38 x_PM_DFFS_X2%6_33 0.212317
R_x_PM_DFFS_X2%6_r28 x_PM_DFFS_X2%6_34 x_PM_DFFS_X2%6_33 0.434286
R_x_PM_DFFS_X2%6_r29 x_PM_DFFS_X2%6_34 x_PM_DFFS_X2%6_29 0.212317
R_x_PM_DFFS_X2%6_r30 N_6_M2_d x_PM_DFFS_X2%6_29 0.339286
R_x_PM_DFFS_X2%6_r31 x_PM_DFFS_X2%6_35 x_PM_DFFS_X2%6_25 0.212317
R_x_PM_DFFS_X2%6_r32 N_6_M19_d x_PM_DFFS_X2%6_25 0.610714
R_x_PM_DFFS_X2%6_r33 x_PM_DFFS_X2%6_21 x_PM_DFFS_X2%6_19 10.92
R_x_PM_DFFS_X2%6_r34 x_PM_DFFS_X2%6_21 x_PM_DFFS_X2%6_15 1.95
R_x_PM_DFFS_X2%6_r35 N_6_M9_g x_PM_DFFS_X2%6_15 52.26
R_x_PM_DFFS_X2%6_r36 x_PM_DFFS_X2%6_19 x_PM_DFFS_X2%6_12 1.95
R_x_PM_DFFS_X2%6_r37 N_6_M25_g x_PM_DFFS_X2%6_12 35.1
R_x_PM_DFFS_X2%6_r38 N_6_M25_g x_PM_DFFS_X2%6_11 26.52
R_x_PM_DFFS_X2%6_r39 x_PM_DFFS_X2%6_11 x_PM_DFFS_X2%6_9 4.35808
R_x_PM_DFFS_X2%6_r40 x_PM_DFFS_X2%6_10 x_PM_DFFS_X2%6_9 98.28
R_x_PM_DFFS_X2%6_r41 x_PM_DFFS_X2%6_50 x_PM_DFFS_X2%6_5 1.95
R_x_PM_DFFS_X2%6_r42 N_6_M6_g x_PM_DFFS_X2%6_5 39.78
R_x_PM_DFFS_X2%6_r43 x_PM_DFFS_X2%6_50 x_PM_DFFS_X2%6_2 1.95
R_x_PM_DFFS_X2%6_r44 N_6_M23_g x_PM_DFFS_X2%6_2 49.92
R_x_PM_DFFS_X2%6_r45 x_PM_DFFS_X2%6_10 x_PM_DFFS_X2%6_VSS 4.35808
R_x_PM_DFFS_X2%6_r46 N_6_M23_g x_PM_DFFS_X2%6_VSS 14.82
C_x_PM_DFFS_X2%7_c0 VSS x_PM_DFFS_X2%7_31 4.81768e-17
C_x_PM_DFFS_X2%7_c1 VSS x_PM_DFFS_X2%7_27 6.27416e-18
C_x_PM_DFFS_X2%7_c2 VSS x_PM_DFFS_X2%7_23 8.01967e-18
C_x_PM_DFFS_X2%7_c3 VSS x_PM_DFFS_X2%7_21 3.37123e-17
C_x_PM_DFFS_X2%7_c4 VSS x_PM_DFFS_X2%7_20 9.76286e-17
C_x_PM_DFFS_X2%7_c5 VSS x_PM_DFFS_X2%7_17 5.62979e-17
C_x_PM_DFFS_X2%7_c6 VSS N_7_M5_d 2.25199e-17
C_x_PM_DFFS_X2%7_c7 VSS x_PM_DFFS_X2%7_11 2.77287e-17
C_x_PM_DFFS_X2%7_c8 VSS N_7_M4_g 3.71224e-17
C_x_PM_DFFS_X2%7_c9 VSS N_7_M21_g 6.24005e-17
R_x_PM_DFFS_X2%7_r10 x_PM_DFFS_X2%7_35 x_PM_DFFS_X2%7_23 4.7687
R_x_PM_DFFS_X2%7_r11 x_PM_DFFS_X2%7_34 x_PM_DFFS_X2%7_23 4.7687
R_x_PM_DFFS_X2%7_r12 x_PM_DFFS_X2%7_23 x_PM_DFFS_X2%7_21 25.0012
R_x_PM_DFFS_X2%7_r13 x_PM_DFFS_X2%7_25 x_PM_DFFS_X2%7_21 0.176429
R_x_PM_DFFS_X2%7_r14 x_PM_DFFS_X2%7_31 x_PM_DFFS_X2%7_19 0.095
R_x_PM_DFFS_X2%7_r15 x_PM_DFFS_X2%7_20 x_PM_DFFS_X2%7_19 2.41571
R_x_PM_DFFS_X2%7_r16 x_PM_DFFS_X2%7_27 x_PM_DFFS_X2%7_18 0.160909
R_x_PM_DFFS_X2%7_r17 x_PM_DFFS_X2%7_20 x_PM_DFFS_X2%7_17 0.212317
R_x_PM_DFFS_X2%7_r18 x_PM_DFFS_X2%7_18 x_PM_DFFS_X2%7_17 0.732857
R_x_PM_DFFS_X2%7_r19 x_PM_DFFS_X2%7_27 x_PM_DFFS_X2%7_13 0.0418175
R_x_PM_DFFS_X2%7_r20 N_7_M5_d x_PM_DFFS_X2%7_13 0.447857
R_x_PM_DFFS_X2%7_r21 x_PM_DFFS_X2%7_25 x_PM_DFFS_X2%7_12 0.095
R_x_PM_DFFS_X2%7_r22 x_PM_DFFS_X2%7_27 x_PM_DFFS_X2%7_11 0.160909
R_x_PM_DFFS_X2%7_r23 x_PM_DFFS_X2%7_12 x_PM_DFFS_X2%7_11 1.22143
R_x_PM_DFFS_X2%7_r24 x_PM_DFFS_X2%7_31 N_7_M23_d 0.095
R_x_PM_DFFS_X2%7_r25 N_7_M4_g x_PM_DFFS_X2%7_35 46.8
R_x_PM_DFFS_X2%7_r26 N_7_M21_g x_PM_DFFS_X2%7_34 70.98
C_x_PM_DFFS_X2%CK_c0 VSS CK 1.09027e-16
C_x_PM_DFFS_X2%CK_c1 VSS x_PM_DFFS_X2%CK_10 3.57869e-17
C_x_PM_DFFS_X2%CK_c2 VSS x_PM_DFFS_X2%CK_9 7.12929e-18
C_x_PM_DFFS_X2%CK_c3 VSS N_CK_M24_g 3.72553e-17
C_x_PM_DFFS_X2%CK_c4 VSS N_CK_M7_g 6.68058e-17
R_x_PM_DFFS_X2%CK_r5 x_PM_DFFS_X2%CK_16 x_PM_DFFS_X2%CK_14 25.0012
R_x_PM_DFFS_X2%CK_r6 x_PM_DFFS_X2%CK_14 CK 0.592353
R_x_PM_DFFS_X2%CK_r7 x_PM_DFFS_X2%CK_16 x_PM_DFFS_X2%CK_10 21.58
R_x_PM_DFFS_X2%CK_r8 x_PM_DFFS_X2%CK_16 x_PM_DFFS_X2%CK_9 4.42
R_x_PM_DFFS_X2%CK_r9 x_PM_DFFS_X2%CK_10 x_PM_DFFS_X2%CK_5 4.58872
R_x_PM_DFFS_X2%CK_r10 N_CK_M24_g x_PM_DFFS_X2%CK_5 24.18
R_x_PM_DFFS_X2%CK_r11 x_PM_DFFS_X2%CK_9 x_PM_DFFS_X2%CK_VSS 4.58872
R_x_PM_DFFS_X2%CK_r12 N_CK_M7_g x_PM_DFFS_X2%CK_VSS 60.84
C_x_PM_DFFS_X2%9_c0 VSS x_PM_DFFS_X2%9_55 3.99062e-18
C_x_PM_DFFS_X2%9_c1 VSS x_PM_DFFS_X2%9_49 4.15961e-17
C_x_PM_DFFS_X2%9_c2 VSS x_PM_DFFS_X2%9_48 1.79317e-17
C_x_PM_DFFS_X2%9_c3 VSS N_9_M11_d 2.55078e-17
C_x_PM_DFFS_X2%9_c4 VSS x_PM_DFFS_X2%9_40 3.35705e-17
C_x_PM_DFFS_X2%9_c5 VSS x_PM_DFFS_X2%9_39 8.77489e-17
C_x_PM_DFFS_X2%9_c6 VSS N_9_M26_d 3.11464e-17
C_x_PM_DFFS_X2%9_c7 VSS x_PM_DFFS_X2%9_33 6.08461e-17
C_x_PM_DFFS_X2%9_c8 VSS x_PM_DFFS_X2%9_32 8.09705e-17
C_x_PM_DFFS_X2%9_c9 VSS x_PM_DFFS_X2%9_27 7.88008e-17
C_x_PM_DFFS_X2%9_c10 VSS x_PM_DFFS_X2%9_23 6.65722e-18
C_x_PM_DFFS_X2%9_c11 VSS N_9_M15_g 5.13839e-17
C_x_PM_DFFS_X2%9_c12 VSS N_9_M31_g 5.70031e-17
C_x_PM_DFFS_X2%9_c13 VSS x_PM_DFFS_X2%9_13 4.01763e-17
C_x_PM_DFFS_X2%9_c14 VSS x_PM_DFFS_X2%9_11 4.05435e-17
C_x_PM_DFFS_X2%9_c15 VSS N_9_M14_g 3.30316e-17
C_x_PM_DFFS_X2%9_c16 VSS x_PM_DFFS_X2%9_6 4.17702e-17
C_x_PM_DFFS_X2%9_c17 VSS N_9_M30_g 4.68371e-17
R_x_PM_DFFS_X2%9_r18 x_PM_DFFS_X2%9_55 x_PM_DFFS_X2%9_52 25.0012
R_x_PM_DFFS_X2%9_r19 x_PM_DFFS_X2%9_52 x_PM_DFFS_X2%9_49 0.176429
R_x_PM_DFFS_X2%9_r20 x_PM_DFFS_X2%9_47 x_PM_DFFS_X2%9_45 0.597143
R_x_PM_DFFS_X2%9_r21 N_9_M11_d x_PM_DFFS_X2%9_41 0.447857
R_x_PM_DFFS_X2%9_r22 x_PM_DFFS_X2%9_47 x_PM_DFFS_X2%9_40 0.19
R_x_PM_DFFS_X2%9_r23 x_PM_DFFS_X2%9_49 x_PM_DFFS_X2%9_39 0.095
R_x_PM_DFFS_X2%9_r24 x_PM_DFFS_X2%9_40 x_PM_DFFS_X2%9_39 3.31143
R_x_PM_DFFS_X2%9_r25 x_PM_DFFS_X2%9_47 x_PM_DFFS_X2%9_35 0.095
R_x_PM_DFFS_X2%9_r26 N_9_M26_d x_PM_DFFS_X2%9_35 0.475
R_x_PM_DFFS_X2%9_r27 x_PM_DFFS_X2%9_48 x_PM_DFFS_X2%9_34 0.160909
R_x_PM_DFFS_X2%9_r28 x_PM_DFFS_X2%9_41 x_PM_DFFS_X2%9_33 0.212317
R_x_PM_DFFS_X2%9_r29 x_PM_DFFS_X2%9_34 x_PM_DFFS_X2%9_33 1.60143
R_x_PM_DFFS_X2%9_r30 x_PM_DFFS_X2%9_48 x_PM_DFFS_X2%9_32 0.0418175
R_x_PM_DFFS_X2%9_r31 x_PM_DFFS_X2%9_45 x_PM_DFFS_X2%9_31 0.095
R_x_PM_DFFS_X2%9_r32 x_PM_DFFS_X2%9_32 x_PM_DFFS_X2%9_31 2.03571
R_x_PM_DFFS_X2%9_r33 x_PM_DFFS_X2%9_48 x_PM_DFFS_X2%9_27 0.160909
R_x_PM_DFFS_X2%9_r34 N_9_M8_s x_PM_DFFS_X2%9_27 1.91357
R_x_PM_DFFS_X2%9_r35 N_9_M15_g x_PM_DFFS_X2%9_19 35.88
R_x_PM_DFFS_X2%9_r36 N_9_M31_g x_PM_DFFS_X2%9_15 51.48
R_x_PM_DFFS_X2%9_r37 x_PM_DFFS_X2%9_23 x_PM_DFFS_X2%9_14 2.04219
R_x_PM_DFFS_X2%9_r38 x_PM_DFFS_X2%9_19 x_PM_DFFS_X2%9_13 4.35808
R_x_PM_DFFS_X2%9_r39 x_PM_DFFS_X2%9_14 x_PM_DFFS_X2%9_13 45.24
R_x_PM_DFFS_X2%9_r40 x_PM_DFFS_X2%9_55 x_PM_DFFS_X2%9_12 2.04219
R_x_PM_DFFS_X2%9_r41 x_PM_DFFS_X2%9_15 x_PM_DFFS_X2%9_11 4.35808
R_x_PM_DFFS_X2%9_r42 x_PM_DFFS_X2%9_12 x_PM_DFFS_X2%9_11 45.24
R_x_PM_DFFS_X2%9_r43 x_PM_DFFS_X2%9_23 x_PM_DFFS_X2%9_7 2.13901
R_x_PM_DFFS_X2%9_r44 N_9_M14_g x_PM_DFFS_X2%9_7 27.3
R_x_PM_DFFS_X2%9_r45 x_PM_DFFS_X2%9_23 x_PM_DFFS_X2%9_6 2.13901
R_x_PM_DFFS_X2%9_r46 x_PM_DFFS_X2%9_55 x_PM_DFFS_X2%9_5 2.13901
R_x_PM_DFFS_X2%9_r47 x_PM_DFFS_X2%9_6 x_PM_DFFS_X2%9_5 20.3478
R_x_PM_DFFS_X2%9_r48 x_PM_DFFS_X2%9_55 x_PM_DFFS_X2%9_VSS 2.13901
R_x_PM_DFFS_X2%9_r49 N_9_M30_g x_PM_DFFS_X2%9_VSS 33.54
C_x_PM_DFFS_X2%10_c0 VSS x_PM_DFFS_X2%10_42 3.35222e-17
C_x_PM_DFFS_X2%10_c1 VSS x_PM_DFFS_X2%10_38 6.2518e-17
C_x_PM_DFFS_X2%10_c2 VSS N_10_M14_d 5.56665e-17
C_x_PM_DFFS_X2%10_c3 VSS x_PM_DFFS_X2%10_30 7.01396e-17
C_x_PM_DFFS_X2%10_c4 VSS x_PM_DFFS_X2%10_28 9.89262e-18
C_x_PM_DFFS_X2%10_c5 VSS x_PM_DFFS_X2%10_24 1.6288e-17
C_x_PM_DFFS_X2%10_c6 VSS x_PM_DFFS_X2%10_21 1.95654e-16
C_x_PM_DFFS_X2%10_c7 VSS x_PM_DFFS_X2%10_18 6.49513e-18
C_x_PM_DFFS_X2%10_c8 VSS x_PM_DFFS_X2%10_17 4.04059e-17
C_x_PM_DFFS_X2%10_c9 VSS N_10_M16_g 6.41251e-17
C_x_PM_DFFS_X2%10_c10 VSS N_10_M32_g 7.92345e-17
C_x_PM_DFFS_X2%10_c11 VSS N_10_M28_g 4.38749e-17
C_x_PM_DFFS_X2%10_c12 VSS N_10_M10_g 4.34651e-17
R_x_PM_DFFS_X2%10_r13 x_PM_DFFS_X2%10_45 x_PM_DFFS_X2%10_42 25.0012
R_x_PM_DFFS_X2%10_r14 x_PM_DFFS_X2%10_42 x_PM_DFFS_X2%10_40 0.358889
R_x_PM_DFFS_X2%10_r15 x_PM_DFFS_X2%10_38 N_10_M30_d 0.175926
R_x_PM_DFFS_X2%10_r16 x_PM_DFFS_X2%10_40 x_PM_DFFS_X2%10_31 0.095
R_x_PM_DFFS_X2%10_r17 N_10_M14_d x_PM_DFFS_X2%10_31 1.425
R_x_PM_DFFS_X2%10_r18 x_PM_DFFS_X2%10_40 x_PM_DFFS_X2%10_30 0.095
R_x_PM_DFFS_X2%10_r19 x_PM_DFFS_X2%10_38 x_PM_DFFS_X2%10_29 0.095
R_x_PM_DFFS_X2%10_r20 x_PM_DFFS_X2%10_30 x_PM_DFFS_X2%10_29 2.09
R_x_PM_DFFS_X2%10_r21 x_PM_DFFS_X2%10_52 x_PM_DFFS_X2%10_28 4.7687
R_x_PM_DFFS_X2%10_r22 x_PM_DFFS_X2%10_28 x_PM_DFFS_X2%10_26 25.0012
R_x_PM_DFFS_X2%10_r23 x_PM_DFFS_X2%10_24 x_PM_DFFS_X2%10_47 5.46
R_x_PM_DFFS_X2%10_r24 x_PM_DFFS_X2%10_24 x_PM_DFFS_X2%10_22 25.0012
R_x_PM_DFFS_X2%10_r25 x_PM_DFFS_X2%10_26 x_PM_DFFS_X2%10_22 0.774074
R_x_PM_DFFS_X2%10_r26 x_PM_DFFS_X2%10_40 x_PM_DFFS_X2%10_21 0.0985185
R_x_PM_DFFS_X2%10_r27 x_PM_DFFS_X2%10_26 x_PM_DFFS_X2%10_21 1.37222
R_x_PM_DFFS_X2%10_r28 x_PM_DFFS_X2%10_45 x_PM_DFFS_X2%10_17 29.9
R_x_PM_DFFS_X2%10_r29 x_PM_DFFS_X2%10_18 x_PM_DFFS_X2%10_17 0.043368
R_x_PM_DFFS_X2%10_r30 x_PM_DFFS_X2%10_18 x_PM_DFFS_X2%10_13 4.56151
R_x_PM_DFFS_X2%10_r31 N_10_M16_g x_PM_DFFS_X2%10_13 55.38
R_x_PM_DFFS_X2%10_r32 x_PM_DFFS_X2%10_18 x_PM_DFFS_X2%10_9 4.56151
R_x_PM_DFFS_X2%10_r33 N_10_M32_g x_PM_DFFS_X2%10_9 82.68
R_x_PM_DFFS_X2%10_r34 N_10_M28_g x_PM_DFFS_X2%10_52 46.02
R_x_PM_DFFS_X2%10_r35 x_PM_DFFS_X2%10_47 x_PM_DFFS_X2%10_VSS 1.95
R_x_PM_DFFS_X2%10_r36 N_10_M10_g x_PM_DFFS_X2%10_VSS 46.8
C_x_PM_DFFS_X2%SN_c0 VSS x_PM_DFFS_X2%SN_29 1.2509e-17
C_x_PM_DFFS_X2%SN_c1 VSS x_PM_DFFS_X2%SN_22 4.65234e-17
C_x_PM_DFFS_X2%SN_c2 VSS x_PM_DFFS_X2%SN_17 2.13227e-17
C_x_PM_DFFS_X2%SN_c3 VSS N_SN_M13_g 4.01369e-17
C_x_PM_DFFS_X2%SN_c4 VSS N_SN_M29_g 8.27918e-17
C_x_PM_DFFS_X2%SN_c5 VSS x_PM_DFFS_X2%SN_8 5.64779e-18
C_x_PM_DFFS_X2%SN_c6 VSS x_PM_DFFS_X2%SN_7 2.00992e-16
C_x_PM_DFFS_X2%SN_c7 VSS N_SN_M22_g 1.27691e-16
R_x_PM_DFFS_X2%SN_r8 x_PM_DFFS_X2%SN_29 x_PM_DFFS_X2%SN_24 4.94
R_x_PM_DFFS_X2%SN_r9 x_PM_DFFS_X2%SN_24 x_PM_DFFS_X2%SN_26 1.82
R_x_PM_DFFS_X2%SN_r10 x_PM_DFFS_X2%SN_24 x_PM_DFFS_X2%SN_22 25.0012
R_x_PM_DFFS_X2%SN_r11 x_PM_DFFS_X2%SN_22 x_PM_DFFS_X2%SN_20 0.218148
R_x_PM_DFFS_X2%SN_r12 x_PM_DFFS_X2%SN_20 x_PM_DFFS_X2%SN_17 0.095
R_x_PM_DFFS_X2%SN_r13 SN x_PM_DFFS_X2%SN_17 0.162857
R_x_PM_DFFS_X2%SN_r14 x_PM_DFFS_X2%SN_29 x_PM_DFFS_X2%SN_13 1.95
R_x_PM_DFFS_X2%SN_r15 N_SN_M13_g x_PM_DFFS_X2%SN_13 28.86
R_x_PM_DFFS_X2%SN_r16 x_PM_DFFS_X2%SN_26 x_PM_DFFS_X2%SN_10 1.95
R_x_PM_DFFS_X2%SN_r17 N_SN_M29_g x_PM_DFFS_X2%SN_10 82.68
R_x_PM_DFFS_X2%SN_r18 N_SN_M29_g x_PM_DFFS_X2%SN_9 46.02
R_x_PM_DFFS_X2%SN_r19 x_PM_DFFS_X2%SN_9 x_PM_DFFS_X2%SN_7 4.35808
R_x_PM_DFFS_X2%SN_r20 x_PM_DFFS_X2%SN_8 x_PM_DFFS_X2%SN_7 247.26
R_x_PM_DFFS_X2%SN_r21 N_SN_M5_g N_SN_M22_g 115.44
R_x_PM_DFFS_X2%SN_r22 x_PM_DFFS_X2%SN_8 x_PM_DFFS_X2%SN_VSS 4.35808
R_x_PM_DFFS_X2%SN_r23 N_SN_M22_g x_PM_DFFS_X2%SN_VSS 34.32
C_x_PM_DFFS_X2%QN_c0 VSS x_PM_DFFS_X2%QN_20 3.55887e-17
C_x_PM_DFFS_X2%QN_c1 VSS x_PM_DFFS_X2%QN_16 5.47193e-17
C_x_PM_DFFS_X2%QN_c2 VSS x_PM_DFFS_X2%QN_14 1.32482e-17
C_x_PM_DFFS_X2%QN_c3 VSS x_PM_DFFS_X2%QN_13 1.75768e-17
C_x_PM_DFFS_X2%QN_c4 VSS N_QN_M15_s 4.69246e-17
C_x_PM_DFFS_X2%QN_c5 VSS N_QN_M31_s 6.76952e-17
R_x_PM_DFFS_X2%QN_r6 x_PM_DFFS_X2%QN_20 x_PM_DFFS_X2%QN_19 0.773571
R_x_PM_DFFS_X2%QN_r7 x_PM_DFFS_X2%QN_19 x_PM_DFFS_X2%QN_17 0.0135714
R_x_PM_DFFS_X2%QN_r8 x_PM_DFFS_X2%QN_20 x_PM_DFFS_X2%QN_15 0.095
R_x_PM_DFFS_X2%QN_r9 x_PM_DFFS_X2%QN_16 x_PM_DFFS_X2%QN_15 2.052
R_x_PM_DFFS_X2%QN_r10 x_PM_DFFS_X2%QN_16 x_PM_DFFS_X2%QN_13 0.213729
R_x_PM_DFFS_X2%QN_r11 x_PM_DFFS_X2%QN_14 x_PM_DFFS_X2%QN_13 0.438462
R_x_PM_DFFS_X2%QN_r12 x_PM_DFFS_X2%QN_14 x_PM_DFFS_X2%QN_9 0.212696
R_x_PM_DFFS_X2%QN_r13 N_QN_M15_s x_PM_DFFS_X2%QN_9 0.827857
R_x_PM_DFFS_X2%QN_r14 x_PM_DFFS_X2%QN_19 QN 0.095
R_x_PM_DFFS_X2%QN_r15 QN N_QN_M31_s 1.30416
R_x_PM_DFFS_X2%QN_r16 x_PM_DFFS_X2%QN_17 x_PM_DFFS_X2%QN_3 0.095
R_x_PM_DFFS_X2%QN_r17 QN x_PM_DFFS_X2%QN_3 0.000506667
C_x_PM_DFFS_X2%Q_c0 VSS Q 5.84994e-17
C_x_PM_DFFS_X2%Q_c1 VSS x_PM_DFFS_X2%Q_11 3.25057e-18
C_x_PM_DFFS_X2%Q_c2 VSS N_Q_M16_d 4.46082e-17
C_x_PM_DFFS_X2%Q_c3 VSS x_PM_DFFS_X2%Q_7 4.10514e-18
C_x_PM_DFFS_X2%Q_c4 VSS N_Q_M32_d 2.58773e-17
R_x_PM_DFFS_X2%Q_r5 Q x_PM_DFFS_X2%Q_12 1.87286
R_x_PM_DFFS_X2%Q_r6 Q x_PM_DFFS_X2%Q_11 1.79143
R_x_PM_DFFS_X2%Q_r7 x_PM_DFFS_X2%Q_12 x_PM_DFFS_X2%Q_7 0.196927
R_x_PM_DFFS_X2%Q_r8 N_Q_M16_d x_PM_DFFS_X2%Q_7 0.795625
R_x_PM_DFFS_X2%Q_r9 x_PM_DFFS_X2%Q_11 x_PM_DFFS_X2%Q_3 0.196927
R_x_PM_DFFS_X2%Q_r10 N_Q_M32_d x_PM_DFFS_X2%Q_3 0.130625
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X1 VSS VDD D CK Q QN
*.PININFO VSS:B VDD:B D:I CK:I Q:O QN:O
M_M14 N_VDD_M0_d N_7_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M15 13 N_5_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M16 N_4_M2_d N_7_M2_g 13 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M17 14 N_3_M3_g N_4_M2_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M18 N_VDD_M4_d N_D_M4_g 14 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M19 N_5_M5_d N_4_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M20 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 15 N_4_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_9_M8_d N_7_M8_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 16 N_3_M9_g N_9_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 N_VDD_M10_d N_10_M10_g 16 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M25 N_10_M11_d N_9_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 N_VDD_M12_d N_10_M12_g N_Q_M12_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M27 N_QN_M13_d N_9_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M14_d N_7_M14_g N_3_M14_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 17 N_5_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_4_M16_d N_3_M16_g 17 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 18 N_7_M17_g N_4_M16_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M18_d N_D_M18_g 18 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_5_M19_d N_4_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M20_d N_CK_M20_g N_7_M20_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 19 N_4_M21_g N_VSS_M20_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_9_M22_d N_3_M22_g 19 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 20 N_7_M23_g N_9_M22_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_VSS_M24_d N_10_M24_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_10_M25_d N_9_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M12 N_VSS_M26_d N_10_M26_g N_Q_M26_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 N_QN_M27_d N_9_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DFF_X1%VSS_c0 VSS x_PM_DFF_X1%VSS_40 3.66433e-17
C_x_PM_DFF_X1%VSS_c1 VSS x_PM_DFF_X1%VSS_35 3.23489e-17
C_x_PM_DFF_X1%VSS_c2 VSS x_PM_DFF_X1%VSS_28 2.95641e-17
C_x_PM_DFF_X1%VSS_c3 VSS x_PM_DFF_X1%VSS_27 4.953e-18
C_x_PM_DFF_X1%VSS_c4 VSS x_PM_DFF_X1%VSS_26 2.60777e-17
C_x_PM_DFF_X1%VSS_c5 VSS x_PM_DFF_X1%VSS_23 3.81987e-17
C_x_PM_DFF_X1%VSS_c6 VSS x_PM_DFF_X1%VSS_20 5.40337e-17
C_x_PM_DFF_X1%VSS_c7 VSS x_PM_DFF_X1%VSS_18 1.05996e-16
C_x_PM_DFF_X1%VSS_c8 VSS x_PM_DFF_X1%VSS_16 8.13374e-17
C_x_PM_DFF_X1%VSS_c9 VSS N_VSS_M18_d 6.52901e-17
C_x_PM_DFF_X1%VSS_c10 VSS x_PM_DFF_X1%VSS_10 5.53849e-17
C_x_PM_DFF_X1%VSS_c11 VSS x_PM_DFF_X1%VSS_9 3.44091e-17
R_x_PM_DFF_X1%VSS_r12 N_VSS_M24_d x_PM_DFF_X1%VSS_35 0.471481
R_x_PM_DFF_X1%VSS_r13 VSS N_VSS_M20_d 0.0140741
R_x_PM_DFF_X1%VSS_r14 N_VSS_M20_d x_PM_DFF_X1%VSS_28 0.471481
R_x_PM_DFF_X1%VSS_r15 x_PM_DFF_X1%VSS_40 x_PM_DFF_X1%VSS_23 0.0680382
R_x_PM_DFF_X1%VSS_r16 x_PM_DFF_X1%VSS_23 N_VSS_M26_d 0.333213
R_x_PM_DFF_X1%VSS_r17 x_PM_DFF_X1%VSS_35 x_PM_DFF_X1%VSS_21 0.095
R_x_PM_DFF_X1%VSS_r18 x_PM_DFF_X1%VSS_40 x_PM_DFF_X1%VSS_20 0.132285
R_x_PM_DFF_X1%VSS_r19 x_PM_DFF_X1%VSS_21 x_PM_DFF_X1%VSS_20 0.916471
R_x_PM_DFF_X1%VSS_r20 x_PM_DFF_X1%VSS_28 x_PM_DFF_X1%VSS_19 0.095
R_x_PM_DFF_X1%VSS_r21 x_PM_DFF_X1%VSS_35 x_PM_DFF_X1%VSS_18 0.095
R_x_PM_DFF_X1%VSS_r22 x_PM_DFF_X1%VSS_19 x_PM_DFF_X1%VSS_18 1.40824
R_x_PM_DFF_X1%VSS_r23 x_PM_DFF_X1%VSS_27 x_PM_DFF_X1%VSS_17 0.132285
R_x_PM_DFF_X1%VSS_r24 x_PM_DFF_X1%VSS_28 x_PM_DFF_X1%VSS_16 0.095
R_x_PM_DFF_X1%VSS_r25 x_PM_DFF_X1%VSS_17 x_PM_DFF_X1%VSS_16 0.994706
R_x_PM_DFF_X1%VSS_r26 x_PM_DFF_X1%VSS_27 x_PM_DFF_X1%VSS_12 0.0680382
R_x_PM_DFF_X1%VSS_r27 N_VSS_M18_d x_PM_DFF_X1%VSS_12 0.87963
R_x_PM_DFF_X1%VSS_r28 x_PM_DFF_X1%VSS_26 x_PM_DFF_X1%VSS_11 0.132285
R_x_PM_DFF_X1%VSS_r29 x_PM_DFF_X1%VSS_27 x_PM_DFF_X1%VSS_10 0.132285
R_x_PM_DFF_X1%VSS_r30 x_PM_DFF_X1%VSS_11 x_PM_DFF_X1%VSS_10 1.43059
R_x_PM_DFF_X1%VSS_r31 x_PM_DFF_X1%VSS_26 x_PM_DFF_X1%VSS_9 0.0680382
R_x_PM_DFF_X1%VSS_r32 x_PM_DFF_X1%VSS_9 N_VSS_M14_d 0.558398
C_x_PM_DFF_X1%VDD_c0 VSS x_PM_DFF_X1%VDD_36 3.79962e-17
C_x_PM_DFF_X1%VDD_c1 VSS x_PM_DFF_X1%VDD_35 5.36578e-18
C_x_PM_DFF_X1%VDD_c2 VSS x_PM_DFF_X1%VDD_34 8.86015e-18
C_x_PM_DFF_X1%VDD_c3 VSS x_PM_DFF_X1%VDD_33 8.86015e-18
C_x_PM_DFF_X1%VDD_c4 VSS x_PM_DFF_X1%VDD_32 3.41219e-17
C_x_PM_DFF_X1%VDD_c5 VSS x_PM_DFF_X1%VDD_29 3.70302e-17
C_x_PM_DFF_X1%VDD_c6 VSS x_PM_DFF_X1%VDD_26 4.66512e-17
C_x_PM_DFF_X1%VDD_c7 VSS x_PM_DFF_X1%VDD_25 3.83545e-17
C_x_PM_DFF_X1%VDD_c8 VSS x_PM_DFF_X1%VDD_22 7.20913e-17
C_x_PM_DFF_X1%VDD_c9 VSS N_VDD_M6_d 2.51887e-17
C_x_PM_DFF_X1%VDD_c10 VSS x_PM_DFF_X1%VDD_14 4.90603e-17
C_x_PM_DFF_X1%VDD_c11 VSS x_PM_DFF_X1%VDD_13 3.12166e-17
C_x_PM_DFF_X1%VDD_c12 VSS x_PM_DFF_X1%VDD_10 6.22085e-17
C_x_PM_DFF_X1%VDD_c13 VSS x_PM_DFF_X1%VDD_9 3.41951e-17
R_x_PM_DFF_X1%VDD_r14 x_PM_DFF_X1%VDD_36 x_PM_DFF_X1%VDD_29 0.0680382
R_x_PM_DFF_X1%VDD_r15 x_PM_DFF_X1%VDD_29 N_VDD_M12_d 0.403583
R_x_PM_DFF_X1%VDD_r16 x_PM_DFF_X1%VDD_35 x_PM_DFF_X1%VDD_27 0.132285
R_x_PM_DFF_X1%VDD_r17 x_PM_DFF_X1%VDD_36 x_PM_DFF_X1%VDD_26 0.132285
R_x_PM_DFF_X1%VDD_r18 x_PM_DFF_X1%VDD_27 x_PM_DFF_X1%VDD_26 0.927647
R_x_PM_DFF_X1%VDD_r19 x_PM_DFF_X1%VDD_35 x_PM_DFF_X1%VDD_25 0.0680382
R_x_PM_DFF_X1%VDD_r20 x_PM_DFF_X1%VDD_25 N_VDD_M10_d 0.403583
R_x_PM_DFF_X1%VDD_r21 x_PM_DFF_X1%VDD_34 x_PM_DFF_X1%VDD_23 0.132285
R_x_PM_DFF_X1%VDD_r22 x_PM_DFF_X1%VDD_35 x_PM_DFF_X1%VDD_22 0.132285
R_x_PM_DFF_X1%VDD_r23 x_PM_DFF_X1%VDD_23 x_PM_DFF_X1%VDD_22 1.39706
R_x_PM_DFF_X1%VDD_r24 VDD N_VDD_M6_d 0.175926
R_x_PM_DFF_X1%VDD_r25 x_PM_DFF_X1%VDD_34 x_PM_DFF_X1%VDD_16 0.0680382
R_x_PM_DFF_X1%VDD_r26 VDD x_PM_DFF_X1%VDD_16 0.295556
R_x_PM_DFF_X1%VDD_r27 x_PM_DFF_X1%VDD_33 x_PM_DFF_X1%VDD_15 0.132285
R_x_PM_DFF_X1%VDD_r28 x_PM_DFF_X1%VDD_34 x_PM_DFF_X1%VDD_14 0.132285
R_x_PM_DFF_X1%VDD_r29 x_PM_DFF_X1%VDD_15 x_PM_DFF_X1%VDD_14 1.02824
R_x_PM_DFF_X1%VDD_r30 x_PM_DFF_X1%VDD_33 x_PM_DFF_X1%VDD_13 0.0680382
R_x_PM_DFF_X1%VDD_r31 x_PM_DFF_X1%VDD_13 N_VDD_M4_d 0.403583
R_x_PM_DFF_X1%VDD_r32 x_PM_DFF_X1%VDD_32 x_PM_DFF_X1%VDD_11 0.132285
R_x_PM_DFF_X1%VDD_r33 x_PM_DFF_X1%VDD_33 x_PM_DFF_X1%VDD_10 0.132285
R_x_PM_DFF_X1%VDD_r34 x_PM_DFF_X1%VDD_11 x_PM_DFF_X1%VDD_10 1.38588
R_x_PM_DFF_X1%VDD_r35 x_PM_DFF_X1%VDD_32 x_PM_DFF_X1%VDD_9 0.0680382
R_x_PM_DFF_X1%VDD_r36 x_PM_DFF_X1%VDD_9 N_VDD_M0_d 0.445805
C_x_PM_DFF_X1%3_c0 VSS x_PM_DFF_X1%3_49 1.70252e-17
C_x_PM_DFF_X1%3_c1 VSS x_PM_DFF_X1%3_46 1.64852e-17
C_x_PM_DFF_X1%3_c2 VSS x_PM_DFF_X1%3_45 2.73725e-18
C_x_PM_DFF_X1%3_c3 VSS x_PM_DFF_X1%3_42 1.75385e-17
C_x_PM_DFF_X1%3_c4 VSS x_PM_DFF_X1%3_36 2.93207e-17
C_x_PM_DFF_X1%3_c5 VSS x_PM_DFF_X1%3_33 2.66116e-17
C_x_PM_DFF_X1%3_c6 VSS N_3_M0_s 4.80784e-17
C_x_PM_DFF_X1%3_c7 VSS N_3_M14_s 1.8803e-17
C_x_PM_DFF_X1%3_c8 VSS N_3_M9_g 7.2334e-17
C_x_PM_DFF_X1%3_c9 VSS x_PM_DFF_X1%3_18 6.95902e-18
C_x_PM_DFF_X1%3_c10 VSS x_PM_DFF_X1%3_17 1.98632e-17
C_x_PM_DFF_X1%3_c11 VSS N_3_M22_g 5.19407e-17
C_x_PM_DFF_X1%3_c12 VSS x_PM_DFF_X1%3_12 6.77603e-18
C_x_PM_DFF_X1%3_c13 VSS x_PM_DFF_X1%3_11 1.6491e-16
C_x_PM_DFF_X1%3_c14 VSS N_3_M3_g 5.74374e-17
C_x_PM_DFF_X1%3_c15 VSS x_PM_DFF_X1%3_6 1.1596e-17
C_x_PM_DFF_X1%3_c16 VSS x_PM_DFF_X1%3_5 2.86724e-17
C_x_PM_DFF_X1%3_c17 VSS N_3_M16_g 2.08696e-17
R_x_PM_DFF_X1%3_r18 x_PM_DFF_X1%3_51 x_PM_DFF_X1%3_42 25.0012
R_x_PM_DFF_X1%3_r19 x_PM_DFF_X1%3_46 x_PM_DFF_X1%3_40 0.197273
R_x_PM_DFF_X1%3_r20 x_PM_DFF_X1%3_42 x_PM_DFF_X1%3_40 0.393571
R_x_PM_DFF_X1%3_r21 x_PM_DFF_X1%3_49 x_PM_DFF_X1%3_38 5.46
R_x_PM_DFF_X1%3_r22 x_PM_DFF_X1%3_38 x_PM_DFF_X1%3_36 25.0012
R_x_PM_DFF_X1%3_r23 x_PM_DFF_X1%3_46 x_PM_DFF_X1%3_35 0.197273
R_x_PM_DFF_X1%3_r24 x_PM_DFF_X1%3_36 x_PM_DFF_X1%3_35 0.827857
R_x_PM_DFF_X1%3_r25 x_PM_DFF_X1%3_45 x_PM_DFF_X1%3_34 0.0141807
R_x_PM_DFF_X1%3_r26 x_PM_DFF_X1%3_46 x_PM_DFF_X1%3_33 0.0141807
R_x_PM_DFF_X1%3_r27 x_PM_DFF_X1%3_34 x_PM_DFF_X1%3_33 1.47778
R_x_PM_DFF_X1%3_r28 x_PM_DFF_X1%3_45 x_PM_DFF_X1%3_29 0.197273
R_x_PM_DFF_X1%3_r29 N_3_M0_s x_PM_DFF_X1%3_29 2.32071
R_x_PM_DFF_X1%3_r30 x_PM_DFF_X1%3_45 x_PM_DFF_X1%3_25 0.197273
R_x_PM_DFF_X1%3_r31 N_3_M14_s x_PM_DFF_X1%3_25 1.01786
R_x_PM_DFF_X1%3_r32 N_3_M9_g x_PM_DFF_X1%3_20 26.52
R_x_PM_DFF_X1%3_r33 N_3_M9_g x_PM_DFF_X1%3_19 87.36
R_x_PM_DFF_X1%3_r34 x_PM_DFF_X1%3_19 x_PM_DFF_X1%3_17 4.35808
R_x_PM_DFF_X1%3_r35 x_PM_DFF_X1%3_18 x_PM_DFF_X1%3_17 22.62
R_x_PM_DFF_X1%3_r36 x_PM_DFF_X1%3_18 x_PM_DFF_X1%3_13 4.35808
R_x_PM_DFF_X1%3_r37 N_3_M22_g x_PM_DFF_X1%3_13 55.38
R_x_PM_DFF_X1%3_r38 x_PM_DFF_X1%3_20 x_PM_DFF_X1%3_11 4.35808
R_x_PM_DFF_X1%3_r39 x_PM_DFF_X1%3_12 x_PM_DFF_X1%3_11 203.58
R_x_PM_DFF_X1%3_r40 x_PM_DFF_X1%3_12 x_PM_DFF_X1%3_8 4.35808
R_x_PM_DFF_X1%3_r41 N_3_M3_g x_PM_DFF_X1%3_8 47.58
R_x_PM_DFF_X1%3_r42 N_3_M3_g x_PM_DFF_X1%3_7 35.88
R_x_PM_DFF_X1%3_r43 x_PM_DFF_X1%3_6 x_PM_DFF_X1%3_51 4.7687
R_x_PM_DFF_X1%3_r44 x_PM_DFF_X1%3_7 x_PM_DFF_X1%3_5 4.35808
R_x_PM_DFF_X1%3_r45 x_PM_DFF_X1%3_6 x_PM_DFF_X1%3_5 28.08
R_x_PM_DFF_X1%3_r46 x_PM_DFF_X1%3_49 x_PM_DFF_X1%3_VSS 1.95
R_x_PM_DFF_X1%3_r47 N_3_M16_g x_PM_DFF_X1%3_VSS 14.82
C_x_PM_DFF_X1%4_c0 VSS x_PM_DFF_X1%4_44 9.0018e-18
C_x_PM_DFF_X1%4_c1 VSS x_PM_DFF_X1%4_41 3.10398e-18
C_x_PM_DFF_X1%4_c2 VSS x_PM_DFF_X1%4_37 8.43989e-17
C_x_PM_DFF_X1%4_c3 VSS x_PM_DFF_X1%4_34 6.29847e-18
C_x_PM_DFF_X1%4_c4 VSS N_4_M16_d 1.14028e-16
C_x_PM_DFF_X1%4_c5 VSS N_4_M2_d 1.80921e-17
C_x_PM_DFF_X1%4_c6 VSS x_PM_DFF_X1%4_25 4.54414e-18
C_x_PM_DFF_X1%4_c7 VSS x_PM_DFF_X1%4_22 3.51054e-18
C_x_PM_DFF_X1%4_c8 VSS x_PM_DFF_X1%4_21 4.84349e-18
C_x_PM_DFF_X1%4_c9 VSS N_4_M7_g 7.24467e-17
C_x_PM_DFF_X1%4_c10 VSS N_4_M21_g 4.88501e-17
C_x_PM_DFF_X1%4_c11 VSS x_PM_DFF_X1%4_11 5.54424e-17
C_x_PM_DFF_X1%4_c12 VSS N_4_M5_g 3.07901e-17
C_x_PM_DFF_X1%4_c13 VSS x_PM_DFF_X1%4_6 3.49991e-17
C_x_PM_DFF_X1%4_c14 VSS N_4_M19_g 2.8675e-17
R_x_PM_DFF_X1%4_r15 x_PM_DFF_X1%4_44 x_PM_DFF_X1%4_42 2.34
R_x_PM_DFF_X1%4_r16 x_PM_DFF_X1%4_42 x_PM_DFF_X1%4_37 25.0012
R_x_PM_DFF_X1%4_r17 x_PM_DFF_X1%4_41 x_PM_DFF_X1%4_35 0.0418175
R_x_PM_DFF_X1%4_r18 x_PM_DFF_X1%4_37 x_PM_DFF_X1%4_35 2.23929
R_x_PM_DFF_X1%4_r19 x_PM_DFF_X1%4_41 x_PM_DFF_X1%4_33 0.160909
R_x_PM_DFF_X1%4_r20 x_PM_DFF_X1%4_34 x_PM_DFF_X1%4_33 0.407143
R_x_PM_DFF_X1%4_r21 x_PM_DFF_X1%4_41 x_PM_DFF_X1%4_29 0.160909
R_x_PM_DFF_X1%4_r22 N_4_M16_d x_PM_DFF_X1%4_29 3.16214
R_x_PM_DFF_X1%4_r23 x_PM_DFF_X1%4_34 x_PM_DFF_X1%4_25 0.202958
R_x_PM_DFF_X1%4_r24 N_4_M2_d x_PM_DFF_X1%4_25 0.111765
R_x_PM_DFF_X1%4_r25 x_PM_DFF_X1%4_22 x_PM_DFF_X1%4_17 3.30287
R_x_PM_DFF_X1%4_r26 N_4_M7_g x_PM_DFF_X1%4_17 70.98
R_x_PM_DFF_X1%4_r27 x_PM_DFF_X1%4_22 x_PM_DFF_X1%4_13 3.30287
R_x_PM_DFF_X1%4_r28 N_4_M21_g x_PM_DFF_X1%4_13 57.72
R_x_PM_DFF_X1%4_r29 x_PM_DFF_X1%4_21 x_PM_DFF_X1%4_12 0.858359
R_x_PM_DFF_X1%4_r30 x_PM_DFF_X1%4_22 x_PM_DFF_X1%4_11 0.858359
R_x_PM_DFF_X1%4_r31 x_PM_DFF_X1%4_12 x_PM_DFF_X1%4_11 81.9
R_x_PM_DFF_X1%4_r32 x_PM_DFF_X1%4_44 x_PM_DFF_X1%4_7 1.95
R_x_PM_DFF_X1%4_r33 N_4_M5_g x_PM_DFF_X1%4_7 25.74
R_x_PM_DFF_X1%4_r34 x_PM_DFF_X1%4_44 x_PM_DFF_X1%4_6 1.95
R_x_PM_DFF_X1%4_r35 x_PM_DFF_X1%4_21 x_PM_DFF_X1%4_5 3.30287
R_x_PM_DFF_X1%4_r36 x_PM_DFF_X1%4_6 x_PM_DFF_X1%4_5 47.58
R_x_PM_DFF_X1%4_r37 x_PM_DFF_X1%4_21 x_PM_DFF_X1%4_VSS 3.30287
R_x_PM_DFF_X1%4_r38 N_4_M19_g x_PM_DFF_X1%4_VSS 21.84
C_x_PM_DFF_X1%5_c0 VSS x_PM_DFF_X1%5_27 2.88864e-17
C_x_PM_DFF_X1%5_c1 VSS x_PM_DFF_X1%5_25 6.22517e-17
C_x_PM_DFF_X1%5_c2 VSS x_PM_DFF_X1%5_21 3.67923e-17
C_x_PM_DFF_X1%5_c3 VSS N_5_M5_d 1.23221e-16
C_x_PM_DFF_X1%5_c4 VSS x_PM_DFF_X1%5_16 6.80443e-17
C_x_PM_DFF_X1%5_c5 VSS x_PM_DFF_X1%5_13 5.25732e-17
C_x_PM_DFF_X1%5_c6 VSS x_PM_DFF_X1%5_10 6.66174e-18
C_x_PM_DFF_X1%5_c7 VSS N_5_M1_g 6.15924e-17
C_x_PM_DFF_X1%5_c8 VSS N_5_M15_g 3.9416e-17
R_x_PM_DFF_X1%5_r9 x_PM_DFF_X1%5_25 x_PM_DFF_X1%5_23 25.0012
R_x_PM_DFF_X1%5_r10 x_PM_DFF_X1%5_23 x_PM_DFF_X1%5_21 0.176429
R_x_PM_DFF_X1%5_r11 x_PM_DFF_X1%5_27 x_PM_DFF_X1%5_17 0.123935
R_x_PM_DFF_X1%5_r12 N_5_M5_d x_PM_DFF_X1%5_17 2.80929
R_x_PM_DFF_X1%5_r13 x_PM_DFF_X1%5_27 x_PM_DFF_X1%5_16 0.123935
R_x_PM_DFF_X1%5_r14 x_PM_DFF_X1%5_21 x_PM_DFF_X1%5_14 0.095
R_x_PM_DFF_X1%5_r15 x_PM_DFF_X1%5_27 x_PM_DFF_X1%5_13 0.0766861
R_x_PM_DFF_X1%5_r16 x_PM_DFF_X1%5_14 x_PM_DFF_X1%5_13 1.95429
R_x_PM_DFF_X1%5_r17 x_PM_DFF_X1%5_16 N_5_M19_d 0.334316
R_x_PM_DFF_X1%5_r18 x_PM_DFF_X1%5_25 x_PM_DFF_X1%5_9 42.9
R_x_PM_DFF_X1%5_r19 x_PM_DFF_X1%5_10 x_PM_DFF_X1%5_9 0.043368
R_x_PM_DFF_X1%5_r20 x_PM_DFF_X1%5_10 x_PM_DFF_X1%5_5 4.56151
R_x_PM_DFF_X1%5_r21 N_5_M1_g x_PM_DFF_X1%5_5 74.1
R_x_PM_DFF_X1%5_r22 x_PM_DFF_X1%5_10 x_PM_DFF_X1%5_VSS 4.56151
R_x_PM_DFF_X1%5_r23 N_5_M15_g x_PM_DFF_X1%5_VSS 40.56
C_x_PM_DFF_X1%D_c0 VSS D 7.58945e-17
C_x_PM_DFF_X1%D_c1 VSS x_PM_DFF_X1%D_11 1.19567e-17
C_x_PM_DFF_X1%D_c2 VSS N_D_M18_g 5.44302e-17
C_x_PM_DFF_X1%D_c3 VSS N_D_M4_g 4.86907e-17
R_x_PM_DFF_X1%D_r4 x_PM_DFF_X1%D_18 x_PM_DFF_X1%D_16 1.56
R_x_PM_DFF_X1%D_r5 x_PM_DFF_X1%D_11 x_PM_DFF_X1%D_18 2.34
R_x_PM_DFF_X1%D_r6 x_PM_DFF_X1%D_11 x_PM_DFF_X1%D_9 25.0012
R_x_PM_DFF_X1%D_r7 D x_PM_DFF_X1%D_9 0.210357
R_x_PM_DFF_X1%D_r8 x_PM_DFF_X1%D_18 x_PM_DFF_X1%D_5 1.95
R_x_PM_DFF_X1%D_r9 N_D_M18_g x_PM_DFF_X1%D_5 52.26
R_x_PM_DFF_X1%D_r10 x_PM_DFF_X1%D_16 x_PM_DFF_X1%D_VSS 1.95
R_x_PM_DFF_X1%D_r11 N_D_M4_g x_PM_DFF_X1%D_VSS 36.66
C_x_PM_DFF_X1%7_c0 VSS x_PM_DFF_X1%7_68 1.13524e-17
C_x_PM_DFF_X1%7_c1 VSS x_PM_DFF_X1%7_59 1.67114e-17
C_x_PM_DFF_X1%7_c2 VSS x_PM_DFF_X1%7_58 1.8368e-17
C_x_PM_DFF_X1%7_c3 VSS x_PM_DFF_X1%7_53 3.72085e-17
C_x_PM_DFF_X1%7_c4 VSS x_PM_DFF_X1%7_52 9.07577e-17
C_x_PM_DFF_X1%7_c5 VSS x_PM_DFF_X1%7_49 9.69328e-18
C_x_PM_DFF_X1%7_c6 VSS x_PM_DFF_X1%7_47 5.06685e-17
C_x_PM_DFF_X1%7_c7 VSS x_PM_DFF_X1%7_43 5.41126e-17
C_x_PM_DFF_X1%7_c8 VSS N_7_M6_s 2.9535e-17
C_x_PM_DFF_X1%7_c9 VSS x_PM_DFF_X1%7_38 1.68818e-16
C_x_PM_DFF_X1%7_c10 VSS x_PM_DFF_X1%7_32 5.06834e-17
C_x_PM_DFF_X1%7_c11 VSS x_PM_DFF_X1%7_29 4.62213e-18
C_x_PM_DFF_X1%7_c12 VSS N_7_M23_g 2.90369e-17
C_x_PM_DFF_X1%7_c13 VSS N_7_M8_g 3.92419e-17
C_x_PM_DFF_X1%7_c14 VSS x_PM_DFF_X1%7_19 5.13292e-17
C_x_PM_DFF_X1%7_c15 VSS N_7_M17_g 3.7401e-17
C_x_PM_DFF_X1%7_c16 VSS N_7_M2_g 2.87283e-17
C_x_PM_DFF_X1%7_c17 VSS x_PM_DFF_X1%7_10 6.45333e-18
C_x_PM_DFF_X1%7_c18 VSS x_PM_DFF_X1%7_9 4.20096e-17
C_x_PM_DFF_X1%7_c19 VSS x_PM_DFF_X1%7_8 7.99027e-18
C_x_PM_DFF_X1%7_c20 VSS x_PM_DFF_X1%7_7 5.84899e-17
C_x_PM_DFF_X1%7_c21 VSS N_7_M14_g 1.27596e-16
R_x_PM_DFF_X1%7_r22 x_PM_DFF_X1%7_68 x_PM_DFF_X1%7_66 1.82
R_x_PM_DFF_X1%7_r23 N_7_M20_s x_PM_DFF_X1%7_53 0.154375
R_x_PM_DFF_X1%7_r24 x_PM_DFF_X1%7_52 x_PM_DFF_X1%7_50 0.347287
R_x_PM_DFF_X1%7_r25 x_PM_DFF_X1%7_66 x_PM_DFF_X1%7_50 25.0012
R_x_PM_DFF_X1%7_r26 x_PM_DFF_X1%7_65 x_PM_DFF_X1%7_49 4.7687
R_x_PM_DFF_X1%7_r27 x_PM_DFF_X1%7_49 x_PM_DFF_X1%7_47 25.0012
R_x_PM_DFF_X1%7_r28 x_PM_DFF_X1%7_47 x_PM_DFF_X1%7_46 0.123913
R_x_PM_DFF_X1%7_r29 x_PM_DFF_X1%7_52 x_PM_DFF_X1%7_45 0.214089
R_x_PM_DFF_X1%7_r30 x_PM_DFF_X1%7_47 x_PM_DFF_X1%7_45 1.24739
R_x_PM_DFF_X1%7_r31 x_PM_DFF_X1%7_58 x_PM_DFF_X1%7_44 0.0533096
R_x_PM_DFF_X1%7_r32 x_PM_DFF_X1%7_46 x_PM_DFF_X1%7_43 0.229077
R_x_PM_DFF_X1%7_r33 x_PM_DFF_X1%7_44 x_PM_DFF_X1%7_43 1.87286
R_x_PM_DFF_X1%7_r34 x_PM_DFF_X1%7_58 x_PM_DFF_X1%7_39 0.14772
R_x_PM_DFF_X1%7_r35 N_7_M6_s x_PM_DFF_X1%7_39 0.19
R_x_PM_DFF_X1%7_r36 x_PM_DFF_X1%7_58 x_PM_DFF_X1%7_38 0.14772
R_x_PM_DFF_X1%7_r37 x_PM_DFF_X1%7_37 N_7_M20_s 0.327552
R_x_PM_DFF_X1%7_r38 x_PM_DFF_X1%7_38 x_PM_DFF_X1%7_37 3.01286
R_x_PM_DFF_X1%7_r39 x_PM_DFF_X1%7_35 x_PM_DFF_X1%7_59 6.5
R_x_PM_DFF_X1%7_r40 x_PM_DFF_X1%7_35 x_PM_DFF_X1%7_33 25.0012
R_x_PM_DFF_X1%7_r41 x_PM_DFF_X1%7_53 x_PM_DFF_X1%7_32 0.095
R_x_PM_DFF_X1%7_r42 x_PM_DFF_X1%7_33 x_PM_DFF_X1%7_32 0.637857
R_x_PM_DFF_X1%7_r43 x_PM_DFF_X1%7_68 x_PM_DFF_X1%7_25 1.95
R_x_PM_DFF_X1%7_r44 N_7_M23_g x_PM_DFF_X1%7_25 22.62
R_x_PM_DFF_X1%7_r45 N_7_M8_g x_PM_DFF_X1%7_65 32.76
R_x_PM_DFF_X1%7_r46 x_PM_DFF_X1%7_29 x_PM_DFF_X1%7_20 3.30287
R_x_PM_DFF_X1%7_r47 x_PM_DFF_X1%7_59 x_PM_DFF_X1%7_19 1.95
R_x_PM_DFF_X1%7_r48 x_PM_DFF_X1%7_20 x_PM_DFF_X1%7_19 69.42
R_x_PM_DFF_X1%7_r49 x_PM_DFF_X1%7_29 x_PM_DFF_X1%7_15 0.858359
R_x_PM_DFF_X1%7_r50 N_7_M17_g x_PM_DFF_X1%7_15 33.54
R_x_PM_DFF_X1%7_r51 N_7_M2_g x_PM_DFF_X1%7_11 28.86
R_x_PM_DFF_X1%7_r52 x_PM_DFF_X1%7_11 x_PM_DFF_X1%7_9 4.35808
R_x_PM_DFF_X1%7_r53 x_PM_DFF_X1%7_10 x_PM_DFF_X1%7_9 51.48
R_x_PM_DFF_X1%7_r54 x_PM_DFF_X1%7_29 x_PM_DFF_X1%7_7 3.30287
R_x_PM_DFF_X1%7_r55 x_PM_DFF_X1%7_8 x_PM_DFF_X1%7_7 83.46
R_x_PM_DFF_X1%7_r56 N_7_M0_g N_7_M14_g 126.36
R_x_PM_DFF_X1%7_r57 x_PM_DFF_X1%7_10 x_PM_DFF_X1%7_2 4.35808
R_x_PM_DFF_X1%7_r58 N_7_M0_g x_PM_DFF_X1%7_2 21.84
R_x_PM_DFF_X1%7_r59 x_PM_DFF_X1%7_8 x_PM_DFF_X1%7_VSS 4.35808
R_x_PM_DFF_X1%7_r60 N_7_M14_g x_PM_DFF_X1%7_VSS 33.54
C_x_PM_DFF_X1%CK_c0 VSS x_PM_DFF_X1%CK_17 1.48126e-17
C_x_PM_DFF_X1%CK_c1 VSS x_PM_DFF_X1%CK_11 1.42908e-17
C_x_PM_DFF_X1%CK_c2 VSS x_PM_DFF_X1%CK_9 1.67963e-16
C_x_PM_DFF_X1%CK_c3 VSS N_CK_M6_g 5.77276e-17
C_x_PM_DFF_X1%CK_c4 VSS N_CK_M20_g 3.22344e-17
R_x_PM_DFF_X1%CK_r5 x_PM_DFF_X1%CK_17 x_PM_DFF_X1%CK_23 2.34
R_x_PM_DFF_X1%CK_r6 x_PM_DFF_X1%CK_17 x_PM_DFF_X1%CK_15 25.0012
R_x_PM_DFF_X1%CK_r7 x_PM_DFF_X1%CK_15 CK 0.612222
R_x_PM_DFF_X1%CK_r8 x_PM_DFF_X1%CK_11 x_PM_DFF_X1%CK_19 2.86
R_x_PM_DFF_X1%CK_r9 x_PM_DFF_X1%CK_11 x_PM_DFF_X1%CK_9 25.0012
R_x_PM_DFF_X1%CK_r10 CK x_PM_DFF_X1%CK_9 0.26037
R_x_PM_DFF_X1%CK_r11 x_PM_DFF_X1%CK_23 x_PM_DFF_X1%CK_5 1.95
R_x_PM_DFF_X1%CK_r12 N_CK_M6_g x_PM_DFF_X1%CK_5 47.58
R_x_PM_DFF_X1%CK_r13 x_PM_DFF_X1%CK_19 x_PM_DFF_X1%CK_VSS 1.95
R_x_PM_DFF_X1%CK_r14 N_CK_M20_g x_PM_DFF_X1%CK_VSS 21.84
C_x_PM_DFF_X1%9_c0 VSS x_PM_DFF_X1%9_37 1.23164e-17
C_x_PM_DFF_X1%9_c1 VSS x_PM_DFF_X1%9_34 7.91194e-18
C_x_PM_DFF_X1%9_c2 VSS x_PM_DFF_X1%9_33 5.81793e-17
C_x_PM_DFF_X1%9_c3 VSS x_PM_DFF_X1%9_30 2.57048e-17
C_x_PM_DFF_X1%9_c4 VSS x_PM_DFF_X1%9_28 7.49512e-17
C_x_PM_DFF_X1%9_c5 VSS x_PM_DFF_X1%9_23 5.40716e-17
C_x_PM_DFF_X1%9_c6 VSS x_PM_DFF_X1%9_19 1.0805e-16
C_x_PM_DFF_X1%9_c7 VSS N_9_M27_g 1.337e-16
C_x_PM_DFF_X1%9_c8 VSS x_PM_DFF_X1%9_10 5.20068e-18
C_x_PM_DFF_X1%9_c9 VSS x_PM_DFF_X1%9_9 6.35386e-17
C_x_PM_DFF_X1%9_c10 VSS N_9_M11_g 5.75353e-17
C_x_PM_DFF_X1%9_c11 VSS N_9_M25_g 7.78802e-17
R_x_PM_DFF_X1%9_r12 x_PM_DFF_X1%9_37 x_PM_DFF_X1%9_35 3.9
R_x_PM_DFF_X1%9_r13 x_PM_DFF_X1%9_34 x_PM_DFF_X1%9_33 0.0272847
R_x_PM_DFF_X1%9_r14 x_PM_DFF_X1%9_33 x_PM_DFF_X1%9_31 0.488028
R_x_PM_DFF_X1%9_r15 x_PM_DFF_X1%9_35 x_PM_DFF_X1%9_31 25.0012
R_x_PM_DFF_X1%9_r16 x_PM_DFF_X1%9_34 x_PM_DFF_X1%9_29 0.266978
R_x_PM_DFF_X1%9_r17 x_PM_DFF_X1%9_30 x_PM_DFF_X1%9_29 1.57429
R_x_PM_DFF_X1%9_r18 x_PM_DFF_X1%9_34 x_PM_DFF_X1%9_28 0.266978
R_x_PM_DFF_X1%9_r19 x_PM_DFF_X1%9_28 x_PM_DFF_X1%9_27 2.55143
R_x_PM_DFF_X1%9_r20 x_PM_DFF_X1%9_30 x_PM_DFF_X1%9_23 0.212317
R_x_PM_DFF_X1%9_r21 N_9_M8_d x_PM_DFF_X1%9_23 0.909286
R_x_PM_DFF_X1%9_r22 x_PM_DFF_X1%9_27 x_PM_DFF_X1%9_19 0.212317
R_x_PM_DFF_X1%9_r23 N_9_M22_d x_PM_DFF_X1%9_19 0.936429
R_x_PM_DFF_X1%9_r24 N_9_M13_g N_9_M27_g 137.67
R_x_PM_DFF_X1%9_r25 N_9_M13_g x_PM_DFF_X1%9_11 30.03
R_x_PM_DFF_X1%9_r26 x_PM_DFF_X1%9_11 x_PM_DFF_X1%9_9 4.35808
R_x_PM_DFF_X1%9_r27 x_PM_DFF_X1%9_10 x_PM_DFF_X1%9_9 78
R_x_PM_DFF_X1%9_r28 x_PM_DFF_X1%9_10 x_PM_DFF_X1%9_6 4.35808
R_x_PM_DFF_X1%9_r29 N_9_M11_g x_PM_DFF_X1%9_6 26.52
R_x_PM_DFF_X1%9_r30 x_PM_DFF_X1%9_37 x_PM_DFF_X1%9_5 1.95
R_x_PM_DFF_X1%9_r31 N_9_M11_g x_PM_DFF_X1%9_5 53.82
R_x_PM_DFF_X1%9_r32 x_PM_DFF_X1%9_37 x_PM_DFF_X1%9_VSS 1.95
R_x_PM_DFF_X1%9_r33 N_9_M25_g x_PM_DFF_X1%9_VSS 70.98
C_x_PM_DFF_X1%10_c0 VSS x_PM_DFF_X1%10_33 3.51813e-17
C_x_PM_DFF_X1%10_c1 VSS N_10_M11_d 1.18342e-16
C_x_PM_DFF_X1%10_c2 VSS N_10_M25_d 5.98372e-17
C_x_PM_DFF_X1%10_c3 VSS x_PM_DFF_X1%10_23 6.20083e-17
C_x_PM_DFF_X1%10_c4 VSS x_PM_DFF_X1%10_22 1.42221e-17
C_x_PM_DFF_X1%10_c5 VSS x_PM_DFF_X1%10_18 4.44552e-18
C_x_PM_DFF_X1%10_c6 VSS x_PM_DFF_X1%10_17 2.93018e-17
C_x_PM_DFF_X1%10_c7 VSS N_10_M12_g 8.30819e-17
C_x_PM_DFF_X1%10_c8 VSS N_10_M26_g 3.83442e-17
C_x_PM_DFF_X1%10_c9 VSS N_10_M10_g 7.44006e-17
C_x_PM_DFF_X1%10_c10 VSS N_10_M24_g 3.95716e-17
R_x_PM_DFF_X1%10_r11 x_PM_DFF_X1%10_35 x_PM_DFF_X1%10_33 25.0012
R_x_PM_DFF_X1%10_r12 x_PM_DFF_X1%10_33 x_PM_DFF_X1%10_28 0.266978
R_x_PM_DFF_X1%10_r13 N_10_M11_d x_PM_DFF_X1%10_28 3.135
R_x_PM_DFF_X1%10_r14 x_PM_DFF_X1%10_33 x_PM_DFF_X1%10_24 0.266978
R_x_PM_DFF_X1%10_r15 N_10_M25_d x_PM_DFF_X1%10_24 1.09929
R_x_PM_DFF_X1%10_r16 x_PM_DFF_X1%10_33 x_PM_DFF_X1%10_23 0.0272847
R_x_PM_DFF_X1%10_r17 x_PM_DFF_X1%10_22 x_PM_DFF_X1%10_37 5.46
R_x_PM_DFF_X1%10_r18 x_PM_DFF_X1%10_23 x_PM_DFF_X1%10_21 0.488028
R_x_PM_DFF_X1%10_r19 x_PM_DFF_X1%10_22 x_PM_DFF_X1%10_21 25.0012
R_x_PM_DFF_X1%10_r20 x_PM_DFF_X1%10_35 x_PM_DFF_X1%10_17 20.54
R_x_PM_DFF_X1%10_r21 x_PM_DFF_X1%10_18 x_PM_DFF_X1%10_17 0.043368
R_x_PM_DFF_X1%10_r22 x_PM_DFF_X1%10_18 x_PM_DFF_X1%10_13 4.56151
R_x_PM_DFF_X1%10_r23 N_10_M12_g x_PM_DFF_X1%10_13 92.43
R_x_PM_DFF_X1%10_r24 x_PM_DFF_X1%10_18 x_PM_DFF_X1%10_9 4.56151
R_x_PM_DFF_X1%10_r25 N_10_M26_g x_PM_DFF_X1%10_9 33.54
R_x_PM_DFF_X1%10_r26 x_PM_DFF_X1%10_37 x_PM_DFF_X1%10_5 1.95
R_x_PM_DFF_X1%10_r27 N_10_M10_g x_PM_DFF_X1%10_5 95.94
R_x_PM_DFF_X1%10_r28 x_PM_DFF_X1%10_37 x_PM_DFF_X1%10_VSS 1.95
R_x_PM_DFF_X1%10_r29 N_10_M24_g x_PM_DFF_X1%10_VSS 42.9
C_x_PM_DFF_X1%Q_c0 VSS N_Q_M26_s 2.02266e-16
R_x_PM_DFF_X1%Q_r1 N_Q_M12_s Q 2.04529
R_x_PM_DFF_X1%Q_r2 Q N_Q_M26_s 1.73235
C_x_PM_DFF_X1%QN_c0 VSS N_QN_M27_d 1.11506e-16
R_x_PM_DFF_X1%QN_r1 N_QN_M13_d QN 2.38687
R_x_PM_DFF_X1%QN_r2 QN N_QN_M27_d 1.84063
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DFF_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DFF_X2 VSS VDD D CK Q QN
*.PININFO VSS:B VDD:B D:I CK:I Q:O QN:O
M_M14 N_VDD_M0_d N_7_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M15 13 N_4_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M16 N_5_M2_d N_7_M2_g 13 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M17 14 N_3_M3_g N_5_M2_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M18 N_VDD_M4_d N_D_M4_g 14 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M19 N_4_M5_d N_5_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M20 N_VDD_M6_d N_CK_M6_g N_7_M6_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 15 N_5_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_9_M8_d N_7_M8_g 15 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 16 N_3_M9_g N_9_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 N_VDD_M10_d N_10_M10_g 16 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M25 N_10_M11_d N_9_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 N_VDD_M12_d N_10_M12_g N_Q_M12_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 N_QN_M13_d N_9_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M14_d N_7_M14_g N_3_M14_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 17 N_4_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_5_M16_d N_3_M16_g 17 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 18 N_7_M17_g N_5_M16_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M18_d N_D_M18_g 18 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_4_M19_d N_5_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M20_d N_CK_M20_g N_7_M20_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 19 N_5_M21_g N_VSS_M20_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_9_M22_d N_3_M22_g 19 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 20 N_7_M23_g N_9_M22_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_VSS_M24_d N_10_M24_g 20 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_10_M25_d N_9_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M12 N_VSS_M26_d N_10_M26_g N_Q_M26_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M13 N_QN_M27_d N_9_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_DFF_X2%VSS_c0 VSS N_VSS_M26_d 5.07542e-17
C_x_PM_DFF_X2%VSS_c1 VSS x_PM_DFF_X2%VSS_31 2.78406e-17
C_x_PM_DFF_X2%VSS_c2 VSS x_PM_DFF_X2%VSS_24 3.01403e-17
C_x_PM_DFF_X2%VSS_c3 VSS x_PM_DFF_X2%VSS_23 4.92179e-18
C_x_PM_DFF_X2%VSS_c4 VSS x_PM_DFF_X2%VSS_22 2.77515e-17
C_x_PM_DFF_X2%VSS_c5 VSS x_PM_DFF_X2%VSS_18 4.80536e-17
C_x_PM_DFF_X2%VSS_c6 VSS x_PM_DFF_X2%VSS_16 1.05555e-16
C_x_PM_DFF_X2%VSS_c7 VSS x_PM_DFF_X2%VSS_14 7.63339e-17
C_x_PM_DFF_X2%VSS_c8 VSS x_PM_DFF_X2%VSS_13 5.76523e-17
C_x_PM_DFF_X2%VSS_c9 VSS x_PM_DFF_X2%VSS_10 5.17333e-17
C_x_PM_DFF_X2%VSS_c10 VSS x_PM_DFF_X2%VSS_9 4.55192e-17
R_x_PM_DFF_X2%VSS_r11 N_VSS_M24_d x_PM_DFF_X2%VSS_31 0.471481
R_x_PM_DFF_X2%VSS_r12 N_VSS_M20_d VSS 0.00703704
R_x_PM_DFF_X2%VSS_r13 VSS x_PM_DFF_X2%VSS_24 0.464444
R_x_PM_DFF_X2%VSS_r14 x_PM_DFF_X2%VSS_31 x_PM_DFF_X2%VSS_19 0.095
R_x_PM_DFF_X2%VSS_r15 x_PM_DFF_X2%VSS_18 N_VSS_M26_d 0.140674
R_x_PM_DFF_X2%VSS_r16 x_PM_DFF_X2%VSS_19 x_PM_DFF_X2%VSS_18 0.927647
R_x_PM_DFF_X2%VSS_r17 x_PM_DFF_X2%VSS_24 x_PM_DFF_X2%VSS_17 0.095
R_x_PM_DFF_X2%VSS_r18 x_PM_DFF_X2%VSS_31 x_PM_DFF_X2%VSS_16 0.095
R_x_PM_DFF_X2%VSS_r19 x_PM_DFF_X2%VSS_17 x_PM_DFF_X2%VSS_16 1.40824
R_x_PM_DFF_X2%VSS_r20 x_PM_DFF_X2%VSS_23 x_PM_DFF_X2%VSS_15 0.132285
R_x_PM_DFF_X2%VSS_r21 x_PM_DFF_X2%VSS_24 x_PM_DFF_X2%VSS_14 0.095
R_x_PM_DFF_X2%VSS_r22 x_PM_DFF_X2%VSS_15 x_PM_DFF_X2%VSS_14 0.961176
R_x_PM_DFF_X2%VSS_r23 x_PM_DFF_X2%VSS_23 x_PM_DFF_X2%VSS_13 0.0680382
R_x_PM_DFF_X2%VSS_r24 x_PM_DFF_X2%VSS_13 N_VSS_M18_d 0.656916
R_x_PM_DFF_X2%VSS_r25 x_PM_DFF_X2%VSS_22 x_PM_DFF_X2%VSS_11 0.132285
R_x_PM_DFF_X2%VSS_r26 x_PM_DFF_X2%VSS_23 x_PM_DFF_X2%VSS_10 0.132285
R_x_PM_DFF_X2%VSS_r27 x_PM_DFF_X2%VSS_11 x_PM_DFF_X2%VSS_10 1.39706
R_x_PM_DFF_X2%VSS_r28 x_PM_DFF_X2%VSS_22 x_PM_DFF_X2%VSS_9 0.0680382
R_x_PM_DFF_X2%VSS_r29 x_PM_DFF_X2%VSS_9 N_VSS_M14_d 0.628768
C_x_PM_DFF_X2%VDD_c0 VSS x_PM_DFF_X2%VDD_40 3.59235e-17
C_x_PM_DFF_X2%VDD_c1 VSS x_PM_DFF_X2%VDD_39 6.43997e-18
C_x_PM_DFF_X2%VDD_c2 VSS x_PM_DFF_X2%VDD_38 8.86015e-18
C_x_PM_DFF_X2%VDD_c3 VSS x_PM_DFF_X2%VDD_37 8.86015e-18
C_x_PM_DFF_X2%VDD_c4 VSS x_PM_DFF_X2%VDD_36 2.71306e-17
C_x_PM_DFF_X2%VDD_c5 VSS N_VDD_M12_d 8.18971e-17
C_x_PM_DFF_X2%VDD_c6 VSS x_PM_DFF_X2%VDD_28 4.29631e-17
C_x_PM_DFF_X2%VDD_c7 VSS N_VDD_M10_d 4.86515e-17
C_x_PM_DFF_X2%VDD_c8 VSS x_PM_DFF_X2%VDD_22 5.89297e-17
C_x_PM_DFF_X2%VDD_c9 VSS N_VDD_M6_d 3.89467e-17
C_x_PM_DFF_X2%VDD_c10 VSS x_PM_DFF_X2%VDD_14 4.71907e-17
C_x_PM_DFF_X2%VDD_c11 VSS x_PM_DFF_X2%VDD_13 6.44262e-17
C_x_PM_DFF_X2%VDD_c12 VSS x_PM_DFF_X2%VDD_10 1.25317e-16
C_x_PM_DFF_X2%VDD_c13 VSS x_PM_DFF_X2%VDD_9 6.8144e-17
R_x_PM_DFF_X2%VDD_r14 x_PM_DFF_X2%VDD_40 x_PM_DFF_X2%VDD_30 0.0680382
R_x_PM_DFF_X2%VDD_r15 N_VDD_M12_d x_PM_DFF_X2%VDD_30 0.471481
R_x_PM_DFF_X2%VDD_r16 x_PM_DFF_X2%VDD_39 x_PM_DFF_X2%VDD_29 0.132285
R_x_PM_DFF_X2%VDD_r17 x_PM_DFF_X2%VDD_40 x_PM_DFF_X2%VDD_28 0.132285
R_x_PM_DFF_X2%VDD_r18 x_PM_DFF_X2%VDD_29 x_PM_DFF_X2%VDD_28 0.927647
R_x_PM_DFF_X2%VDD_r19 x_PM_DFF_X2%VDD_39 x_PM_DFF_X2%VDD_24 0.0680382
R_x_PM_DFF_X2%VDD_r20 N_VDD_M10_d x_PM_DFF_X2%VDD_24 0.978148
R_x_PM_DFF_X2%VDD_r21 x_PM_DFF_X2%VDD_38 x_PM_DFF_X2%VDD_23 0.132285
R_x_PM_DFF_X2%VDD_r22 x_PM_DFF_X2%VDD_39 x_PM_DFF_X2%VDD_22 0.132285
R_x_PM_DFF_X2%VDD_r23 x_PM_DFF_X2%VDD_23 x_PM_DFF_X2%VDD_22 1.41941
R_x_PM_DFF_X2%VDD_r24 VDD N_VDD_M6_d 0.0492593
R_x_PM_DFF_X2%VDD_r25 x_PM_DFF_X2%VDD_38 x_PM_DFF_X2%VDD_16 0.0680382
R_x_PM_DFF_X2%VDD_r26 VDD x_PM_DFF_X2%VDD_16 0.422222
R_x_PM_DFF_X2%VDD_r27 x_PM_DFF_X2%VDD_37 x_PM_DFF_X2%VDD_15 0.132285
R_x_PM_DFF_X2%VDD_r28 x_PM_DFF_X2%VDD_38 x_PM_DFF_X2%VDD_14 0.132285
R_x_PM_DFF_X2%VDD_r29 x_PM_DFF_X2%VDD_15 x_PM_DFF_X2%VDD_14 0.938824
R_x_PM_DFF_X2%VDD_r30 x_PM_DFF_X2%VDD_37 x_PM_DFF_X2%VDD_13 0.0680382
R_x_PM_DFF_X2%VDD_r31 x_PM_DFF_X2%VDD_13 N_VDD_M4_d 0.403583
R_x_PM_DFF_X2%VDD_r32 x_PM_DFF_X2%VDD_36 x_PM_DFF_X2%VDD_11 0.132285
R_x_PM_DFF_X2%VDD_r33 x_PM_DFF_X2%VDD_37 x_PM_DFF_X2%VDD_10 0.132285
R_x_PM_DFF_X2%VDD_r34 x_PM_DFF_X2%VDD_11 x_PM_DFF_X2%VDD_10 1.40824
R_x_PM_DFF_X2%VDD_r35 x_PM_DFF_X2%VDD_36 x_PM_DFF_X2%VDD_9 0.0680382
R_x_PM_DFF_X2%VDD_r36 x_PM_DFF_X2%VDD_9 N_VDD_M0_d 0.614694
C_x_PM_DFF_X2%3_c0 VSS x_PM_DFF_X2%3_38 4.13795e-18
C_x_PM_DFF_X2%3_c1 VSS x_PM_DFF_X2%3_35 8.5671e-17
C_x_PM_DFF_X2%3_c2 VSS N_3_M0_s 2.74146e-17
C_x_PM_DFF_X2%3_c3 VSS N_3_M14_s 3.17019e-17
C_x_PM_DFF_X2%3_c4 VSS N_3_M9_g 7.6141e-17
C_x_PM_DFF_X2%3_c5 VSS x_PM_DFF_X2%3_18 6.45975e-18
C_x_PM_DFF_X2%3_c6 VSS x_PM_DFF_X2%3_17 1.97721e-17
C_x_PM_DFF_X2%3_c7 VSS N_3_M22_g 5.21285e-17
C_x_PM_DFF_X2%3_c8 VSS x_PM_DFF_X2%3_12 6.25709e-18
C_x_PM_DFF_X2%3_c9 VSS x_PM_DFF_X2%3_11 1.6058e-16
C_x_PM_DFF_X2%3_c10 VSS N_3_M3_g 7.51828e-17
C_x_PM_DFF_X2%3_c11 VSS x_PM_DFF_X2%3_5 2.66192e-17
C_x_PM_DFF_X2%3_c12 VSS N_3_M16_g 3.76008e-17
C_x_PM_DFF_X2%3_c13 VSS x_PM_DFF_X2%3_VSS 4.18653e-18
R_x_PM_DFF_X2%3_r14 x_PM_DFF_X2%3_36 x_PM_DFF_X2%3_35 25.0012
R_x_PM_DFF_X2%3_r15 x_PM_DFF_X2%3_38 x_PM_DFF_X2%3_33 0.0272847
R_x_PM_DFF_X2%3_r16 x_PM_DFF_X2%3_35 x_PM_DFF_X2%3_33 1.25963
R_x_PM_DFF_X2%3_r17 x_PM_DFF_X2%3_38 x_PM_DFF_X2%3_29 0.266978
R_x_PM_DFF_X2%3_r18 N_3_M0_s x_PM_DFF_X2%3_29 1.34357
R_x_PM_DFF_X2%3_r19 x_PM_DFF_X2%3_38 x_PM_DFF_X2%3_25 0.266978
R_x_PM_DFF_X2%3_r20 N_3_M14_s x_PM_DFF_X2%3_25 1.20786
R_x_PM_DFF_X2%3_r21 N_3_M9_g x_PM_DFF_X2%3_20 54.6
R_x_PM_DFF_X2%3_r22 N_3_M9_g x_PM_DFF_X2%3_19 63.96
R_x_PM_DFF_X2%3_r23 x_PM_DFF_X2%3_19 x_PM_DFF_X2%3_17 4.35808
R_x_PM_DFF_X2%3_r24 x_PM_DFF_X2%3_18 x_PM_DFF_X2%3_17 21.84
R_x_PM_DFF_X2%3_r25 x_PM_DFF_X2%3_18 x_PM_DFF_X2%3_13 4.35808
R_x_PM_DFF_X2%3_r26 N_3_M22_g x_PM_DFF_X2%3_13 50.7
R_x_PM_DFF_X2%3_r27 x_PM_DFF_X2%3_20 x_PM_DFF_X2%3_11 4.35808
R_x_PM_DFF_X2%3_r28 x_PM_DFF_X2%3_12 x_PM_DFF_X2%3_11 198.12
R_x_PM_DFF_X2%3_r29 x_PM_DFF_X2%3_12 x_PM_DFF_X2%3_8 4.35808
R_x_PM_DFF_X2%3_r30 N_3_M3_g x_PM_DFF_X2%3_8 47.58
R_x_PM_DFF_X2%3_r31 N_3_M3_g x_PM_DFF_X2%3_7 49.14
R_x_PM_DFF_X2%3_r32 x_PM_DFF_X2%3_36 x_PM_DFF_X2%3_6 0.917744
R_x_PM_DFF_X2%3_r33 x_PM_DFF_X2%3_7 x_PM_DFF_X2%3_5 4.58872
R_x_PM_DFF_X2%3_r34 x_PM_DFF_X2%3_6 x_PM_DFF_X2%3_5 14.56
R_x_PM_DFF_X2%3_r35 x_PM_DFF_X2%3_36 x_PM_DFF_X2%3_VSS 3.67098
R_x_PM_DFF_X2%3_r36 N_3_M16_g x_PM_DFF_X2%3_VSS 42.9
C_x_PM_DFF_X2%4_c0 VSS x_PM_DFF_X2%4_36 1.90171e-17
C_x_PM_DFF_X2%4_c1 VSS x_PM_DFF_X2%4_34 6.68746e-17
C_x_PM_DFF_X2%4_c2 VSS x_PM_DFF_X2%4_29 2.64069e-17
C_x_PM_DFF_X2%4_c3 VSS x_PM_DFF_X2%4_27 7.75208e-18
C_x_PM_DFF_X2%4_c4 VSS x_PM_DFF_X2%4_24 1.37914e-16
C_x_PM_DFF_X2%4_c5 VSS N_4_M5_d 3.67734e-17
C_x_PM_DFF_X2%4_c6 VSS x_PM_DFF_X2%4_18 1.98483e-17
C_x_PM_DFF_X2%4_c7 VSS x_PM_DFF_X2%4_17 4.33932e-17
C_x_PM_DFF_X2%4_c8 VSS x_PM_DFF_X2%4_16 2.17678e-17
C_x_PM_DFF_X2%4_c9 VSS x_PM_DFF_X2%4_14 3.61988e-17
C_x_PM_DFF_X2%4_c10 VSS x_PM_DFF_X2%4_13 1.35681e-16
C_x_PM_DFF_X2%4_c11 VSS x_PM_DFF_X2%4_12 4.20046e-17
C_x_PM_DFF_X2%4_c12 VSS N_4_M1_g 2.74198e-17
C_x_PM_DFF_X2%4_c13 VSS N_4_M15_g 6.30135e-17
R_x_PM_DFF_X2%4_r14 x_PM_DFF_X2%4_39 x_PM_DFF_X2%4_27 4.7687
R_x_PM_DFF_X2%4_r15 x_PM_DFF_X2%4_38 x_PM_DFF_X2%4_27 4.7687
R_x_PM_DFF_X2%4_r16 x_PM_DFF_X2%4_27 x_PM_DFF_X2%4_25 25.0012
R_x_PM_DFF_X2%4_r17 x_PM_DFF_X2%4_29 x_PM_DFF_X2%4_25 0.312143
R_x_PM_DFF_X2%4_r18 x_PM_DFF_X2%4_36 x_PM_DFF_X2%4_24 0.126857
R_x_PM_DFF_X2%4_r19 x_PM_DFF_X2%4_34 x_PM_DFF_X2%4_23 0.095
R_x_PM_DFF_X2%4_r20 x_PM_DFF_X2%4_24 x_PM_DFF_X2%4_23 2.90429
R_x_PM_DFF_X2%4_r21 x_PM_DFF_X2%4_36 x_PM_DFF_X2%4_19 0.126857
R_x_PM_DFF_X2%4_r22 N_4_M5_d x_PM_DFF_X2%4_19 0.338696
R_x_PM_DFF_X2%4_r23 x_PM_DFF_X2%4_36 x_PM_DFF_X2%4_17 0.0735989
R_x_PM_DFF_X2%4_r24 x_PM_DFF_X2%4_18 x_PM_DFF_X2%4_17 1.57429
R_x_PM_DFF_X2%4_r25 x_PM_DFF_X2%4_18 x_PM_DFF_X2%4_15 0.212317
R_x_PM_DFF_X2%4_r26 x_PM_DFF_X2%4_16 x_PM_DFF_X2%4_15 0.787143
R_x_PM_DFF_X2%4_r27 x_PM_DFF_X2%4_16 x_PM_DFF_X2%4_13 0.212317
R_x_PM_DFF_X2%4_r28 x_PM_DFF_X2%4_14 x_PM_DFF_X2%4_13 1.92714
R_x_PM_DFF_X2%4_r29 x_PM_DFF_X2%4_14 x_PM_DFF_X2%4_12 0.212317
R_x_PM_DFF_X2%4_r30 x_PM_DFF_X2%4_29 x_PM_DFF_X2%4_11 0.095
R_x_PM_DFF_X2%4_r31 x_PM_DFF_X2%4_12 x_PM_DFF_X2%4_11 1.52
R_x_PM_DFF_X2%4_r32 x_PM_DFF_X2%4_34 N_4_M19_d 0.133704
R_x_PM_DFF_X2%4_r33 N_4_M1_g x_PM_DFF_X2%4_39 26.52
R_x_PM_DFF_X2%4_r34 N_4_M15_g x_PM_DFF_X2%4_38 74.88
C_x_PM_DFF_X2%5_c0 VSS x_PM_DFF_X2%5_40 4.27778e-18
C_x_PM_DFF_X2%5_c1 VSS x_PM_DFF_X2%5_39 1.6844e-17
C_x_PM_DFF_X2%5_c2 VSS x_PM_DFF_X2%5_36 1.13644e-16
C_x_PM_DFF_X2%5_c3 VSS x_PM_DFF_X2%5_33 6.18571e-17
C_x_PM_DFF_X2%5_c4 VSS x_PM_DFF_X2%5_31 1.15161e-17
C_x_PM_DFF_X2%5_c5 VSS x_PM_DFF_X2%5_26 4.89962e-17
C_x_PM_DFF_X2%5_c6 VSS x_PM_DFF_X2%5_22 2.08287e-17
C_x_PM_DFF_X2%5_c7 VSS x_PM_DFF_X2%5_19 6.84439e-18
C_x_PM_DFF_X2%5_c8 VSS N_5_M7_g 7.29282e-17
C_x_PM_DFF_X2%5_c9 VSS N_5_M21_g 4.63103e-17
C_x_PM_DFF_X2%5_c10 VSS x_PM_DFF_X2%5_9 6.77995e-17
C_x_PM_DFF_X2%5_c11 VSS N_5_M5_g 7.1432e-17
C_x_PM_DFF_X2%5_c12 VSS N_5_M19_g 3.18171e-17
R_x_PM_DFF_X2%5_r13 x_PM_DFF_X2%5_40 x_PM_DFF_X2%5_36 25.0012
R_x_PM_DFF_X2%5_r14 x_PM_DFF_X2%5_39 x_PM_DFF_X2%5_34 0.0272847
R_x_PM_DFF_X2%5_r15 x_PM_DFF_X2%5_36 x_PM_DFF_X2%5_34 1.07667
R_x_PM_DFF_X2%5_r16 x_PM_DFF_X2%5_39 x_PM_DFF_X2%5_32 0.266978
R_x_PM_DFF_X2%5_r17 x_PM_DFF_X2%5_33 x_PM_DFF_X2%5_32 2.09
R_x_PM_DFF_X2%5_r18 x_PM_DFF_X2%5_39 x_PM_DFF_X2%5_31 0.266978
R_x_PM_DFF_X2%5_r19 x_PM_DFF_X2%5_31 x_PM_DFF_X2%5_30 0.624286
R_x_PM_DFF_X2%5_r20 x_PM_DFF_X2%5_33 x_PM_DFF_X2%5_26 0.212317
R_x_PM_DFF_X2%5_r21 N_5_M2_d x_PM_DFF_X2%5_26 0.149286
R_x_PM_DFF_X2%5_r22 x_PM_DFF_X2%5_30 x_PM_DFF_X2%5_22 0.212317
R_x_PM_DFF_X2%5_r23 N_5_M16_d x_PM_DFF_X2%5_22 0.149286
R_x_PM_DFF_X2%5_r24 x_PM_DFF_X2%5_19 x_PM_DFF_X2%5_15 5.4228
R_x_PM_DFF_X2%5_r25 N_5_M7_g x_PM_DFF_X2%5_15 67.86
R_x_PM_DFF_X2%5_r26 x_PM_DFF_X2%5_19 x_PM_DFF_X2%5_11 5.4228
R_x_PM_DFF_X2%5_r27 N_5_M21_g x_PM_DFF_X2%5_11 53.82
R_x_PM_DFF_X2%5_r28 x_PM_DFF_X2%5_40 x_PM_DFF_X2%5_10 0.530495
R_x_PM_DFF_X2%5_r29 x_PM_DFF_X2%5_19 x_PM_DFF_X2%5_9 0.530495
R_x_PM_DFF_X2%5_r30 x_PM_DFF_X2%5_10 x_PM_DFF_X2%5_9 41.8737
R_x_PM_DFF_X2%5_r31 x_PM_DFF_X2%5_40 x_PM_DFF_X2%5_5 5.4228
R_x_PM_DFF_X2%5_r32 N_5_M5_g x_PM_DFF_X2%5_5 81.9
R_x_PM_DFF_X2%5_r33 x_PM_DFF_X2%5_40 x_PM_DFF_X2%5_VSS 5.4228
R_x_PM_DFF_X2%5_r34 N_5_M19_g x_PM_DFF_X2%5_VSS 26.52
C_x_PM_DFF_X2%D_c0 VSS D 7.41924e-17
C_x_PM_DFF_X2%D_c1 VSS x_PM_DFF_X2%D_11 8.65361e-18
C_x_PM_DFF_X2%D_c2 VSS N_D_M4_g 4.9371e-17
C_x_PM_DFF_X2%D_c3 VSS N_D_M18_g 5.08051e-17
R_x_PM_DFF_X2%D_r4 x_PM_DFF_X2%D_18 x_PM_DFF_X2%D_11 4.7687
R_x_PM_DFF_X2%D_r5 x_PM_DFF_X2%D_17 x_PM_DFF_X2%D_11 4.7687
R_x_PM_DFF_X2%D_r6 x_PM_DFF_X2%D_11 x_PM_DFF_X2%D_9 25.0012
R_x_PM_DFF_X2%D_r7 D x_PM_DFF_X2%D_9 0.4085
R_x_PM_DFF_X2%D_r8 N_D_M4_g x_PM_DFF_X2%D_18 35.88
R_x_PM_DFF_X2%D_r9 N_D_M18_g x_PM_DFF_X2%D_17 49.14
C_x_PM_DFF_X2%7_c0 VSS x_PM_DFF_X2%7_62 1.72439e-17
C_x_PM_DFF_X2%7_c1 VSS x_PM_DFF_X2%7_58 1.17646e-17
C_x_PM_DFF_X2%7_c2 VSS x_PM_DFF_X2%7_52 1.64245e-17
C_x_PM_DFF_X2%7_c3 VSS x_PM_DFF_X2%7_50 5.97331e-17
C_x_PM_DFF_X2%7_c4 VSS x_PM_DFF_X2%7_45 9.40907e-17
C_x_PM_DFF_X2%7_c5 VSS x_PM_DFF_X2%7_41 7.91499e-17
C_x_PM_DFF_X2%7_c6 VSS N_7_M20_s 2.24392e-16
C_x_PM_DFF_X2%7_c7 VSS x_PM_DFF_X2%7_38 2.18834e-17
C_x_PM_DFF_X2%7_c8 VSS x_PM_DFF_X2%7_32 8.17065e-17
C_x_PM_DFF_X2%7_c9 VSS x_PM_DFF_X2%7_29 4.84614e-18
C_x_PM_DFF_X2%7_c10 VSS N_7_M23_g 2.6014e-17
C_x_PM_DFF_X2%7_c11 VSS N_7_M8_g 3.63474e-17
C_x_PM_DFF_X2%7_c12 VSS x_PM_DFF_X2%7_19 5.98797e-17
C_x_PM_DFF_X2%7_c13 VSS N_7_M17_g 4.49412e-17
C_x_PM_DFF_X2%7_c14 VSS N_7_M2_g 3.09873e-17
C_x_PM_DFF_X2%7_c15 VSS x_PM_DFF_X2%7_10 7.81819e-18
C_x_PM_DFF_X2%7_c16 VSS x_PM_DFF_X2%7_9 4.29509e-17
C_x_PM_DFF_X2%7_c17 VSS x_PM_DFF_X2%7_8 9.89834e-18
C_x_PM_DFF_X2%7_c18 VSS x_PM_DFF_X2%7_7 6.38453e-17
C_x_PM_DFF_X2%7_c19 VSS N_7_M14_g 1.21496e-16
R_x_PM_DFF_X2%7_r20 x_PM_DFF_X2%7_62 x_PM_DFF_X2%7_60 5.46
R_x_PM_DFF_X2%7_r21 x_PM_DFF_X2%7_50 x_PM_DFF_X2%7_48 0.570339
R_x_PM_DFF_X2%7_r22 x_PM_DFF_X2%7_60 x_PM_DFF_X2%7_48 25.0012
R_x_PM_DFF_X2%7_r23 x_PM_DFF_X2%7_58 x_PM_DFF_X2%7_47 3.38
R_x_PM_DFF_X2%7_r24 x_PM_DFF_X2%7_47 x_PM_DFF_X2%7_45 25.0012
R_x_PM_DFF_X2%7_r25 x_PM_DFF_X2%7_45 x_PM_DFF_X2%7_44 0.719286
R_x_PM_DFF_X2%7_r26 x_PM_DFF_X2%7_50 x_PM_DFF_X2%7_43 0.212317
R_x_PM_DFF_X2%7_r27 x_PM_DFF_X2%7_45 x_PM_DFF_X2%7_43 2.53786
R_x_PM_DFF_X2%7_r28 N_7_M6_s x_PM_DFF_X2%7_42 0.197151
R_x_PM_DFF_X2%7_r29 x_PM_DFF_X2%7_44 x_PM_DFF_X2%7_41 0.212317
R_x_PM_DFF_X2%7_r30 x_PM_DFF_X2%7_42 x_PM_DFF_X2%7_41 2.00857
R_x_PM_DFF_X2%7_r31 N_7_M6_s x_PM_DFF_X2%7_38 0.0151655
R_x_PM_DFF_X2%7_r32 N_7_M20_s x_PM_DFF_X2%7_38 3.97643
R_x_PM_DFF_X2%7_r33 N_7_M20_s x_PM_DFF_X2%7_37 0.0407143
R_x_PM_DFF_X2%7_r34 x_PM_DFF_X2%7_35 x_PM_DFF_X2%7_52 5.2
R_x_PM_DFF_X2%7_r35 x_PM_DFF_X2%7_35 x_PM_DFF_X2%7_33 25.0012
R_x_PM_DFF_X2%7_r36 x_PM_DFF_X2%7_37 x_PM_DFF_X2%7_32 0.212317
R_x_PM_DFF_X2%7_r37 x_PM_DFF_X2%7_33 x_PM_DFF_X2%7_32 0.556429
R_x_PM_DFF_X2%7_r38 x_PM_DFF_X2%7_62 x_PM_DFF_X2%7_25 1.95
R_x_PM_DFF_X2%7_r39 N_7_M23_g x_PM_DFF_X2%7_25 17.16
R_x_PM_DFF_X2%7_r40 x_PM_DFF_X2%7_58 x_PM_DFF_X2%7_21 1.95
R_x_PM_DFF_X2%7_r41 N_7_M8_g x_PM_DFF_X2%7_21 28.86
R_x_PM_DFF_X2%7_r42 x_PM_DFF_X2%7_29 x_PM_DFF_X2%7_20 2.32903
R_x_PM_DFF_X2%7_r43 x_PM_DFF_X2%7_52 x_PM_DFF_X2%7_19 1.95
R_x_PM_DFF_X2%7_r44 x_PM_DFF_X2%7_20 x_PM_DFF_X2%7_19 47.32
R_x_PM_DFF_X2%7_r45 x_PM_DFF_X2%7_29 x_PM_DFF_X2%7_15 1.81308
R_x_PM_DFF_X2%7_r46 N_7_M17_g x_PM_DFF_X2%7_15 33.54
R_x_PM_DFF_X2%7_r47 N_7_M2_g x_PM_DFF_X2%7_11 26.52
R_x_PM_DFF_X2%7_r48 x_PM_DFF_X2%7_11 x_PM_DFF_X2%7_9 4.35808
R_x_PM_DFF_X2%7_r49 x_PM_DFF_X2%7_10 x_PM_DFF_X2%7_9 51.48
R_x_PM_DFF_X2%7_r50 x_PM_DFF_X2%7_29 x_PM_DFF_X2%7_7 2.32903
R_x_PM_DFF_X2%7_r51 x_PM_DFF_X2%7_8 x_PM_DFF_X2%7_7 54.08
R_x_PM_DFF_X2%7_r52 N_7_M0_g N_7_M14_g 110.76
R_x_PM_DFF_X2%7_r53 x_PM_DFF_X2%7_10 x_PM_DFF_X2%7_2 4.35808
R_x_PM_DFF_X2%7_r54 N_7_M0_g x_PM_DFF_X2%7_2 33.54
R_x_PM_DFF_X2%7_r55 x_PM_DFF_X2%7_8 x_PM_DFF_X2%7_VSS 4.58872
R_x_PM_DFF_X2%7_r56 N_7_M14_g x_PM_DFF_X2%7_VSS 21.84
C_x_PM_DFF_X2%CK_c0 VSS x_PM_DFF_X2%CK_17 1.48788e-17
C_x_PM_DFF_X2%CK_c1 VSS x_PM_DFF_X2%CK_11 1.6424e-17
C_x_PM_DFF_X2%CK_c2 VSS x_PM_DFF_X2%CK_9 2.02829e-16
C_x_PM_DFF_X2%CK_c3 VSS N_CK_M6_g 4.45001e-17
C_x_PM_DFF_X2%CK_c4 VSS N_CK_M20_g 3.25349e-17
R_x_PM_DFF_X2%CK_r5 x_PM_DFF_X2%CK_17 x_PM_DFF_X2%CK_23 3.9
R_x_PM_DFF_X2%CK_r6 x_PM_DFF_X2%CK_17 x_PM_DFF_X2%CK_15 25.0012
R_x_PM_DFF_X2%CK_r7 x_PM_DFF_X2%CK_15 CK 0.555926
R_x_PM_DFF_X2%CK_r8 x_PM_DFF_X2%CK_11 x_PM_DFF_X2%CK_19 3.9
R_x_PM_DFF_X2%CK_r9 x_PM_DFF_X2%CK_11 x_PM_DFF_X2%CK_9 25.0012
R_x_PM_DFF_X2%CK_r10 CK x_PM_DFF_X2%CK_9 0.654444
R_x_PM_DFF_X2%CK_r11 x_PM_DFF_X2%CK_23 x_PM_DFF_X2%CK_5 1.95
R_x_PM_DFF_X2%CK_r12 N_CK_M6_g x_PM_DFF_X2%CK_5 28.86
R_x_PM_DFF_X2%CK_r13 x_PM_DFF_X2%CK_19 x_PM_DFF_X2%CK_VSS 1.95
R_x_PM_DFF_X2%CK_r14 N_CK_M20_g x_PM_DFF_X2%CK_VSS 21.84
C_x_PM_DFF_X2%9_c0 VSS x_PM_DFF_X2%9_35 9.87375e-18
C_x_PM_DFF_X2%9_c1 VSS x_PM_DFF_X2%9_34 2.47526e-18
C_x_PM_DFF_X2%9_c2 VSS x_PM_DFF_X2%9_33 8.58757e-17
C_x_PM_DFF_X2%9_c3 VSS x_PM_DFF_X2%9_30 6.05626e-17
C_x_PM_DFF_X2%9_c4 VSS x_PM_DFF_X2%9_28 2.8026e-17
C_x_PM_DFF_X2%9_c5 VSS x_PM_DFF_X2%9_27 1.2818e-17
C_x_PM_DFF_X2%9_c6 VSS N_9_M8_d 5.37407e-17
C_x_PM_DFF_X2%9_c7 VSS x_PM_DFF_X2%9_19 1.05297e-16
C_x_PM_DFF_X2%9_c8 VSS N_9_M27_g 1.42261e-16
C_x_PM_DFF_X2%9_c9 VSS x_PM_DFF_X2%9_10 5.11954e-18
C_x_PM_DFF_X2%9_c10 VSS x_PM_DFF_X2%9_9 6.38306e-17
C_x_PM_DFF_X2%9_c11 VSS N_9_M11_g 6.06031e-17
C_x_PM_DFF_X2%9_c12 VSS N_9_M25_g 6.9122e-17
R_x_PM_DFF_X2%9_r13 x_PM_DFF_X2%9_36 x_PM_DFF_X2%9_35 4.7687
R_x_PM_DFF_X2%9_r14 x_PM_DFF_X2%9_34 x_PM_DFF_X2%9_33 0.102612
R_x_PM_DFF_X2%9_r15 x_PM_DFF_X2%9_33 x_PM_DFF_X2%9_31 0.541269
R_x_PM_DFF_X2%9_r16 x_PM_DFF_X2%9_35 x_PM_DFF_X2%9_31 25.0012
R_x_PM_DFF_X2%9_r17 x_PM_DFF_X2%9_34 x_PM_DFF_X2%9_30 0.101508
R_x_PM_DFF_X2%9_r18 x_PM_DFF_X2%9_30 x_PM_DFF_X2%9_29 2.28
R_x_PM_DFF_X2%9_r19 x_PM_DFF_X2%9_34 x_PM_DFF_X2%9_27 0.102612
R_x_PM_DFF_X2%9_r20 x_PM_DFF_X2%9_28 x_PM_DFF_X2%9_27 0.54
R_x_PM_DFF_X2%9_r21 x_PM_DFF_X2%9_28 x_PM_DFF_X2%9_23 0.218718
R_x_PM_DFF_X2%9_r22 N_9_M8_d x_PM_DFF_X2%9_23 0.936429
R_x_PM_DFF_X2%9_r23 x_PM_DFF_X2%9_29 x_PM_DFF_X2%9_19 0.212317
R_x_PM_DFF_X2%9_r24 N_9_M22_d x_PM_DFF_X2%9_19 0.936429
R_x_PM_DFF_X2%9_r25 N_9_M13_g N_9_M27_g 135.72
R_x_PM_DFF_X2%9_r26 N_9_M13_g x_PM_DFF_X2%9_11 40.56
R_x_PM_DFF_X2%9_r27 x_PM_DFF_X2%9_11 x_PM_DFF_X2%9_9 4.35808
R_x_PM_DFF_X2%9_r28 x_PM_DFF_X2%9_10 x_PM_DFF_X2%9_9 78
R_x_PM_DFF_X2%9_r29 x_PM_DFF_X2%9_10 x_PM_DFF_X2%9_6 4.35808
R_x_PM_DFF_X2%9_r30 N_9_M11_g x_PM_DFF_X2%9_6 54.6
R_x_PM_DFF_X2%9_r31 x_PM_DFF_X2%9_5 x_PM_DFF_X2%9_35 4.7687
R_x_PM_DFF_X2%9_r32 N_9_M11_g x_PM_DFF_X2%9_5 33.54
R_x_PM_DFF_X2%9_r33 N_9_M25_g x_PM_DFF_X2%9_36 63.18
C_x_PM_DFF_X2%10_c0 VSS N_10_M11_d 4.48715e-17
C_x_PM_DFF_X2%10_c1 VSS x_PM_DFF_X2%10_33 3.25939e-17
C_x_PM_DFF_X2%10_c2 VSS x_PM_DFF_X2%10_31 9.01378e-17
C_x_PM_DFF_X2%10_c3 VSS N_10_M25_d 3.86263e-17
C_x_PM_DFF_X2%10_c4 VSS x_PM_DFF_X2%10_23 7.45965e-17
C_x_PM_DFF_X2%10_c5 VSS x_PM_DFF_X2%10_22 1.37919e-17
C_x_PM_DFF_X2%10_c6 VSS x_PM_DFF_X2%10_18 4.55339e-18
C_x_PM_DFF_X2%10_c7 VSS x_PM_DFF_X2%10_17 2.91392e-17
C_x_PM_DFF_X2%10_c8 VSS N_10_M12_g 7.6541e-17
C_x_PM_DFF_X2%10_c9 VSS N_10_M26_g 5.84845e-17
C_x_PM_DFF_X2%10_c10 VSS N_10_M10_g 5.67763e-17
C_x_PM_DFF_X2%10_c11 VSS N_10_M24_g 4.02738e-17
R_x_PM_DFF_X2%10_r12 x_PM_DFF_X2%10_38 x_PM_DFF_X2%10_31 25.0012
R_x_PM_DFF_X2%10_r13 x_PM_DFF_X2%10_29 N_10_M11_d 0.2538
R_x_PM_DFF_X2%10_r14 x_PM_DFF_X2%10_31 x_PM_DFF_X2%10_29 1.44176
R_x_PM_DFF_X2%10_r15 x_PM_DFF_X2%10_33 x_PM_DFF_X2%10_28 0.204957
R_x_PM_DFF_X2%10_r16 x_PM_DFF_X2%10_31 x_PM_DFF_X2%10_28 0.0335294
R_x_PM_DFF_X2%10_r17 x_PM_DFF_X2%10_33 x_PM_DFF_X2%10_24 0.204957
R_x_PM_DFF_X2%10_r18 N_10_M25_d x_PM_DFF_X2%10_24 0.206522
R_x_PM_DFF_X2%10_r19 x_PM_DFF_X2%10_33 x_PM_DFF_X2%10_23 0.00896237
R_x_PM_DFF_X2%10_r20 x_PM_DFF_X2%10_22 x_PM_DFF_X2%10_40 5.46
R_x_PM_DFF_X2%10_r21 x_PM_DFF_X2%10_23 x_PM_DFF_X2%10_21 0.473954
R_x_PM_DFF_X2%10_r22 x_PM_DFF_X2%10_22 x_PM_DFF_X2%10_21 25.0012
R_x_PM_DFF_X2%10_r23 x_PM_DFF_X2%10_38 x_PM_DFF_X2%10_17 20.54
R_x_PM_DFF_X2%10_r24 x_PM_DFF_X2%10_18 x_PM_DFF_X2%10_17 0.043368
R_x_PM_DFF_X2%10_r25 x_PM_DFF_X2%10_18 x_PM_DFF_X2%10_13 4.56151
R_x_PM_DFF_X2%10_r26 N_10_M12_g x_PM_DFF_X2%10_13 70.2
R_x_PM_DFF_X2%10_r27 x_PM_DFF_X2%10_18 x_PM_DFF_X2%10_9 4.56151
R_x_PM_DFF_X2%10_r28 N_10_M26_g x_PM_DFF_X2%10_9 53.82
R_x_PM_DFF_X2%10_r29 x_PM_DFF_X2%10_40 x_PM_DFF_X2%10_5 1.95
R_x_PM_DFF_X2%10_r30 N_10_M10_g x_PM_DFF_X2%10_5 67.86
R_x_PM_DFF_X2%10_r31 x_PM_DFF_X2%10_40 x_PM_DFF_X2%10_VSS 1.95
R_x_PM_DFF_X2%10_r32 N_10_M24_g x_PM_DFF_X2%10_VSS 42.9
C_x_PM_DFF_X2%Q_c0 VSS N_Q_M26_s 2.57279e-16
R_x_PM_DFF_X2%Q_r1 N_Q_M12_s Q 1.95278
R_x_PM_DFF_X2%Q_r2 Q N_Q_M26_s 1.67833
C_x_PM_DFF_X2%QN_c0 VSS x_PM_DFF_X2%QN_15 4.04671e-18
C_x_PM_DFF_X2%QN_c1 VSS N_QN_M13_d 6.5342e-17
C_x_PM_DFF_X2%QN_c2 VSS N_QN_M27_d 3.38002e-17
C_x_PM_DFF_X2%QN_c3 VSS x_PM_DFF_X2%QN_3 3.21683e-17
R_x_PM_DFF_X2%QN_r4 x_PM_DFF_X2%QN_15 x_PM_DFF_X2%QN_11 0.273842
R_x_PM_DFF_X2%QN_r5 N_QN_M13_d x_PM_DFF_X2%QN_11 2.89071
R_x_PM_DFF_X2%QN_r6 x_PM_DFF_X2%QN_15 x_PM_DFF_X2%QN_7 0.273842
R_x_PM_DFF_X2%QN_r7 N_QN_M27_d x_PM_DFF_X2%QN_7 1.01786
R_x_PM_DFF_X2%QN_r8 x_PM_DFF_X2%QN_15 x_PM_DFF_X2%QN_3 0.0307623
R_x_PM_DFF_X2%QN_r9 QN x_PM_DFF_X2%QN_3 0.339286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X1 VSS VDD G D Q
*.PININFO VSS:B VDD:B G:I D:I Q:O
M_M8 N_VDD_M0_d N_G_M0_g N_3_M0_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M9 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M10 10 N_D_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M11 N_7_M3_d N_3_M3_g 10 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M12 11 N_5_M4_g N_7_M3_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M13 N_VDD_M5_d N_8_M5_g 11 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M14 N_VDD_M6_d N_7_M6_g N_8_M6_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M15 N_Q_M7_d N_7_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M8_d N_G_M8_g N_3_M8_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 12 N_D_M10_g N_VSS_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M11_d N_5_M11_g 12 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 13 N_3_M12_g N_7_M11_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M13_d N_8_M13_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M14_d N_7_M14_g N_8_M14_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_Q_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DLH_X1%VSS_c0 VSS x_PM_DLH_X1%VSS_34 4.15832e-17
C_x_PM_DLH_X1%VSS_c1 VSS x_PM_DLH_X1%VSS_33 2.44332e-17
C_x_PM_DLH_X1%VSS_c2 VSS x_PM_DLH_X1%VSS_28 2.39648e-17
C_x_PM_DLH_X1%VSS_c3 VSS x_PM_DLH_X1%VSS_21 7.46739e-17
C_x_PM_DLH_X1%VSS_c4 VSS N_VSS_M14_d 2.61304e-17
C_x_PM_DLH_X1%VSS_c5 VSS x_PM_DLH_X1%VSS_13 2.26072e-17
C_x_PM_DLH_X1%VSS_c6 VSS x_PM_DLH_X1%VSS_10 2.48189e-17
C_x_PM_DLH_X1%VSS_c7 VSS x_PM_DLH_X1%VSS_9 6.9147e-17
R_x_PM_DLH_X1%VSS_r8 x_PM_DLH_X1%VSS_33 N_VSS_M13_d 0.140674
R_x_PM_DLH_X1%VSS_r9 x_PM_DLH_X1%VSS_28 N_VSS_M10_s 0.140674
R_x_PM_DLH_X1%VSS_r10 N_VSS_M8_d x_PM_DLH_X1%VSS_21 0.429259
R_x_PM_DLH_X1%VSS_r11 x_PM_DLH_X1%VSS_34 x_PM_DLH_X1%VSS_15 0.0680382
R_x_PM_DLH_X1%VSS_r12 N_VSS_M14_d x_PM_DLH_X1%VSS_15 0.330741
R_x_PM_DLH_X1%VSS_r13 x_PM_DLH_X1%VSS_34 x_PM_DLH_X1%VSS_13 0.132285
R_x_PM_DLH_X1%VSS_r14 x_PM_DLH_X1%VSS_33 x_PM_DLH_X1%VSS_13 0.536471
R_x_PM_DLH_X1%VSS_r15 x_PM_DLH_X1%VSS_10 N_VSS_M10_s 0.140674
R_x_PM_DLH_X1%VSS_r16 VSS x_PM_DLH_X1%VSS_10 0.76
R_x_PM_DLH_X1%VSS_r17 x_PM_DLH_X1%VSS_9 N_VSS_M13_d 0.140674
R_x_PM_DLH_X1%VSS_r18 VSS x_PM_DLH_X1%VSS_9 0.625882
R_x_PM_DLH_X1%VSS_r19 x_PM_DLH_X1%VSS_21 x_PM_DLH_X1%VSS_8 0.095
R_x_PM_DLH_X1%VSS_r20 x_PM_DLH_X1%VSS_8 x_PM_DLH_X1%VSS_28 0.469412
C_x_PM_DLH_X1%VDD_c0 VSS x_PM_DLH_X1%VDD_35 3.65527e-17
C_x_PM_DLH_X1%VDD_c1 VSS N_VDD_M6_d 2.16257e-17
C_x_PM_DLH_X1%VDD_c2 VSS x_PM_DLH_X1%VDD_31 6.34178e-18
C_x_PM_DLH_X1%VDD_c3 VSS x_PM_DLH_X1%VDD_30 6.34178e-18
C_x_PM_DLH_X1%VDD_c4 VSS x_PM_DLH_X1%VDD_29 5.79763e-18
C_x_PM_DLH_X1%VDD_c5 VSS x_PM_DLH_X1%VDD_25 2.13832e-17
C_x_PM_DLH_X1%VDD_c6 VSS N_VDD_M5_d 2.64179e-17
C_x_PM_DLH_X1%VDD_c7 VSS x_PM_DLH_X1%VDD_19 6.09278e-17
C_x_PM_DLH_X1%VDD_c8 VSS N_VDD_M2_s 4.52317e-17
C_x_PM_DLH_X1%VDD_c9 VSS x_PM_DLH_X1%VDD_13 1.52522e-17
C_x_PM_DLH_X1%VDD_c10 VSS N_VDD_M0_d 3.01565e-17
C_x_PM_DLH_X1%VDD_c11 VSS x_PM_DLH_X1%VDD_5 2.73425e-17
R_x_PM_DLH_X1%VDD_r12 x_PM_DLH_X1%VDD_35 N_VDD_M6_d 0.443333
R_x_PM_DLH_X1%VDD_r13 x_PM_DLH_X1%VDD_31 x_PM_DLH_X1%VDD_26 0.132285
R_x_PM_DLH_X1%VDD_r14 x_PM_DLH_X1%VDD_35 x_PM_DLH_X1%VDD_25 0.095
R_x_PM_DLH_X1%VDD_r15 x_PM_DLH_X1%VDD_26 x_PM_DLH_X1%VDD_25 0.536471
R_x_PM_DLH_X1%VDD_r16 x_PM_DLH_X1%VDD_31 x_PM_DLH_X1%VDD_21 0.0680382
R_x_PM_DLH_X1%VDD_r17 N_VDD_M5_d x_PM_DLH_X1%VDD_21 0.11963
R_x_PM_DLH_X1%VDD_r18 x_PM_DLH_X1%VDD_30 x_PM_DLH_X1%VDD_20 0.132285
R_x_PM_DLH_X1%VDD_r19 x_PM_DLH_X1%VDD_31 x_PM_DLH_X1%VDD_19 0.132285
R_x_PM_DLH_X1%VDD_r20 x_PM_DLH_X1%VDD_20 x_PM_DLH_X1%VDD_19 1.38588
R_x_PM_DLH_X1%VDD_r21 x_PM_DLH_X1%VDD_30 x_PM_DLH_X1%VDD_15 0.0680382
R_x_PM_DLH_X1%VDD_r22 N_VDD_M2_s x_PM_DLH_X1%VDD_15 0.11963
R_x_PM_DLH_X1%VDD_r23 x_PM_DLH_X1%VDD_29 x_PM_DLH_X1%VDD_14 0.132285
R_x_PM_DLH_X1%VDD_r24 x_PM_DLH_X1%VDD_30 x_PM_DLH_X1%VDD_13 0.132285
R_x_PM_DLH_X1%VDD_r25 x_PM_DLH_X1%VDD_14 x_PM_DLH_X1%VDD_13 0.480588
R_x_PM_DLH_X1%VDD_r26 x_PM_DLH_X1%VDD_29 x_PM_DLH_X1%VDD_9 0.0680382
R_x_PM_DLH_X1%VDD_r27 N_VDD_M0_d x_PM_DLH_X1%VDD_9 0.11963
R_x_PM_DLH_X1%VDD_r28 x_PM_DLH_X1%VDD_29 x_PM_DLH_X1%VDD_5 0.132285
R_x_PM_DLH_X1%VDD_r29 VDD x_PM_DLH_X1%VDD_5 0.245882
C_x_PM_DLH_X1%3_c0 VSS x_PM_DLH_X1%3_43 3.12566e-18
C_x_PM_DLH_X1%3_c1 VSS x_PM_DLH_X1%3_40 1.82374e-17
C_x_PM_DLH_X1%3_c2 VSS x_PM_DLH_X1%3_33 4.77768e-17
C_x_PM_DLH_X1%3_c3 VSS x_PM_DLH_X1%3_31 2.69545e-17
C_x_PM_DLH_X1%3_c4 VSS x_PM_DLH_X1%3_30 4.97471e-17
C_x_PM_DLH_X1%3_c5 VSS x_PM_DLH_X1%3_29 1.38608e-17
C_x_PM_DLH_X1%3_c6 VSS x_PM_DLH_X1%3_28 1.71407e-17
C_x_PM_DLH_X1%3_c7 VSS N_3_M0_s 5.08672e-17
C_x_PM_DLH_X1%3_c8 VSS x_PM_DLH_X1%3_21 3.52193e-18
C_x_PM_DLH_X1%3_c9 VSS N_3_M12_g 6.51762e-17
C_x_PM_DLH_X1%3_c10 VSS x_PM_DLH_X1%3_15 2.16492e-17
C_x_PM_DLH_X1%3_c11 VSS N_3_M3_g 7.30837e-17
C_x_PM_DLH_X1%3_c12 VSS x_PM_DLH_X1%3_9 5.71939e-17
C_x_PM_DLH_X1%3_c13 VSS N_3_M1_g 6.76186e-17
C_x_PM_DLH_X1%3_c14 VSS N_3_M9_g 6.15949e-17
R_x_PM_DLH_X1%3_r15 x_PM_DLH_X1%3_43 x_PM_DLH_X1%3_40 25.0012
R_x_PM_DLH_X1%3_r16 x_PM_DLH_X1%3_40 x_PM_DLH_X1%3_38 0.447857
R_x_PM_DLH_X1%3_r17 x_PM_DLH_X1%3_38 x_PM_DLH_X1%3_33 0.095
R_x_PM_DLH_X1%3_r18 x_PM_DLH_X1%3_33 x_PM_DLH_X1%3_32 1.79143
R_x_PM_DLH_X1%3_r19 x_PM_DLH_X1%3_31 N_3_M8_s 0.297071
R_x_PM_DLH_X1%3_r20 x_PM_DLH_X1%3_32 x_PM_DLH_X1%3_30 0.212317
R_x_PM_DLH_X1%3_r21 x_PM_DLH_X1%3_31 x_PM_DLH_X1%3_30 0.597143
R_x_PM_DLH_X1%3_r22 x_PM_DLH_X1%3_38 x_PM_DLH_X1%3_28 0.19
R_x_PM_DLH_X1%3_r23 x_PM_DLH_X1%3_29 x_PM_DLH_X1%3_28 0.76
R_x_PM_DLH_X1%3_r24 x_PM_DLH_X1%3_29 x_PM_DLH_X1%3_24 0.212317
R_x_PM_DLH_X1%3_r25 N_3_M0_s x_PM_DLH_X1%3_24 2.21214
R_x_PM_DLH_X1%3_r26 N_3_M12_g x_PM_DLH_X1%3_17 72.54
R_x_PM_DLH_X1%3_r27 x_PM_DLH_X1%3_21 x_PM_DLH_X1%3_16 2.32903
R_x_PM_DLH_X1%3_r28 x_PM_DLH_X1%3_17 x_PM_DLH_X1%3_15 4.58872
R_x_PM_DLH_X1%3_r29 x_PM_DLH_X1%3_16 x_PM_DLH_X1%3_15 14.56
R_x_PM_DLH_X1%3_r30 x_PM_DLH_X1%3_21 x_PM_DLH_X1%3_11 1.81308
R_x_PM_DLH_X1%3_r31 N_3_M3_g x_PM_DLH_X1%3_11 63.96
R_x_PM_DLH_X1%3_r32 x_PM_DLH_X1%3_43 x_PM_DLH_X1%3_10 0.043368
R_x_PM_DLH_X1%3_r33 x_PM_DLH_X1%3_21 x_PM_DLH_X1%3_9 2.32903
R_x_PM_DLH_X1%3_r34 x_PM_DLH_X1%3_10 x_PM_DLH_X1%3_9 50.44
R_x_PM_DLH_X1%3_r35 x_PM_DLH_X1%3_43 x_PM_DLH_X1%3_5 4.56151
R_x_PM_DLH_X1%3_r36 N_3_M1_g x_PM_DLH_X1%3_5 63.96
R_x_PM_DLH_X1%3_r37 x_PM_DLH_X1%3_43 x_PM_DLH_X1%3_VSS 4.56151
R_x_PM_DLH_X1%3_r38 N_3_M9_g x_PM_DLH_X1%3_VSS 68.64
C_x_PM_DLH_X1%G_c0 VSS x_PM_DLH_X1%G_14 7.35984e-18
C_x_PM_DLH_X1%G_c1 VSS x_PM_DLH_X1%G_12 6.49301e-17
C_x_PM_DLH_X1%G_c2 VSS N_G_M0_g 9.12693e-17
C_x_PM_DLH_X1%G_c3 VSS N_G_M8_g 4.07677e-17
R_x_PM_DLH_X1%G_r4 x_PM_DLH_X1%G_18 x_PM_DLH_X1%G_14 4.7687
R_x_PM_DLH_X1%G_r5 x_PM_DLH_X1%G_17 x_PM_DLH_X1%G_14 4.7687
R_x_PM_DLH_X1%G_r6 x_PM_DLH_X1%G_14 x_PM_DLH_X1%G_12 25.0012
R_x_PM_DLH_X1%G_r7 x_PM_DLH_X1%G_12 G 0.2375
R_x_PM_DLH_X1%G_r8 N_G_M0_g x_PM_DLH_X1%G_18 93.6
R_x_PM_DLH_X1%G_r9 N_G_M8_g x_PM_DLH_X1%G_17 39
C_x_PM_DLH_X1%5_c0 VSS x_PM_DLH_X1%5_34 1.40147e-17
C_x_PM_DLH_X1%5_c1 VSS x_PM_DLH_X1%5_32 1.10291e-17
C_x_PM_DLH_X1%5_c2 VSS x_PM_DLH_X1%5_30 5.77352e-17
C_x_PM_DLH_X1%5_c3 VSS x_PM_DLH_X1%5_29 1.34941e-17
C_x_PM_DLH_X1%5_c4 VSS x_PM_DLH_X1%5_28 6.11264e-18
C_x_PM_DLH_X1%5_c5 VSS x_PM_DLH_X1%5_25 7.14429e-17
C_x_PM_DLH_X1%5_c6 VSS x_PM_DLH_X1%5_23 1.30066e-16
C_x_PM_DLH_X1%5_c7 VSS x_PM_DLH_X1%5_16 4.48719e-17
C_x_PM_DLH_X1%5_c8 VSS x_PM_DLH_X1%5_12 1.35388e-17
C_x_PM_DLH_X1%5_c9 VSS x_PM_DLH_X1%5_9 5.4551e-17
C_x_PM_DLH_X1%5_c10 VSS N_5_M4_g 5.10959e-17
C_x_PM_DLH_X1%5_c11 VSS N_5_M11_g 4.62665e-17
R_x_PM_DLH_X1%5_r12 x_PM_DLH_X1%5_39 x_PM_DLH_X1%5_32 4.7687
R_x_PM_DLH_X1%5_r13 x_PM_DLH_X1%5_32 x_PM_DLH_X1%5_30 25.0012
R_x_PM_DLH_X1%5_r14 x_PM_DLH_X1%5_30 x_PM_DLH_X1%5_29 0.963571
R_x_PM_DLH_X1%5_r15 x_PM_DLH_X1%5_29 x_PM_DLH_X1%5_27 0.212317
R_x_PM_DLH_X1%5_r16 x_PM_DLH_X1%5_28 x_PM_DLH_X1%5_27 0.38
R_x_PM_DLH_X1%5_r17 x_PM_DLH_X1%5_34 x_PM_DLH_X1%5_26 0.151873
R_x_PM_DLH_X1%5_r18 x_PM_DLH_X1%5_28 x_PM_DLH_X1%5_25 0.212317
R_x_PM_DLH_X1%5_r19 x_PM_DLH_X1%5_26 x_PM_DLH_X1%5_25 1.27571
R_x_PM_DLH_X1%5_r20 x_PM_DLH_X1%5_35 x_PM_DLH_X1%5_23 25.0012
R_x_PM_DLH_X1%5_r21 x_PM_DLH_X1%5_34 x_PM_DLH_X1%5_21 0.0495914
R_x_PM_DLH_X1%5_r22 x_PM_DLH_X1%5_23 x_PM_DLH_X1%5_21 2.42929
R_x_PM_DLH_X1%5_r23 x_PM_DLH_X1%5_23 x_PM_DLH_X1%5_20 1.15357
R_x_PM_DLH_X1%5_r24 x_PM_DLH_X1%5_20 x_PM_DLH_X1%5_16 0.212317
R_x_PM_DLH_X1%5_r25 N_5_M9_d x_PM_DLH_X1%5_16 0.339286
R_x_PM_DLH_X1%5_r26 x_PM_DLH_X1%5_34 x_PM_DLH_X1%5_12 0.151873
R_x_PM_DLH_X1%5_r27 N_5_M1_d x_PM_DLH_X1%5_12 0.320625
R_x_PM_DLH_X1%5_r28 x_PM_DLH_X1%5_35 x_PM_DLH_X1%5_9 32.5
R_x_PM_DLH_X1%5_r29 N_5_M4_g x_PM_DLH_X1%5_39 35.88
R_x_PM_DLH_X1%5_r30 x_PM_DLH_X1%5_9 x_PM_DLH_X1%5_VSS 4.58872
R_x_PM_DLH_X1%5_r31 N_5_M11_g x_PM_DLH_X1%5_VSS 45.24
C_x_PM_DLH_X1%D_c0 VSS D 6.41594e-17
C_x_PM_DLH_X1%D_c1 VSS x_PM_DLH_X1%D_16 1.29757e-17
C_x_PM_DLH_X1%D_c2 VSS x_PM_DLH_X1%D_12 1.29211e-17
C_x_PM_DLH_X1%D_c3 VSS x_PM_DLH_X1%D_10 1.21364e-16
C_x_PM_DLH_X1%D_c4 VSS N_D_M2_g 5.56676e-17
C_x_PM_DLH_X1%D_c5 VSS N_D_M10_g 3.08262e-17
R_x_PM_DLH_X1%D_r6 D x_PM_DLH_X1%D_18 0.366429
R_x_PM_DLH_X1%D_r7 x_PM_DLH_X1%D_23 x_PM_DLH_X1%D_16 4.7687
R_x_PM_DLH_X1%D_r8 x_PM_DLH_X1%D_16 x_PM_DLH_X1%D_14 25.0012
R_x_PM_DLH_X1%D_r9 x_PM_DLH_X1%D_18 x_PM_DLH_X1%D_14 0.00678571
R_x_PM_DLH_X1%D_r10 x_PM_DLH_X1%D_27 x_PM_DLH_X1%D_12 4.7687
R_x_PM_DLH_X1%D_r11 x_PM_DLH_X1%D_12 x_PM_DLH_X1%D_10 25.0012
R_x_PM_DLH_X1%D_r12 x_PM_DLH_X1%D_18 x_PM_DLH_X1%D_9 0.095
R_x_PM_DLH_X1%D_r13 x_PM_DLH_X1%D_10 x_PM_DLH_X1%D_9 2.23929
R_x_PM_DLH_X1%D_r14 N_D_M2_g x_PM_DLH_X1%D_27 40.56
R_x_PM_DLH_X1%D_r15 N_D_M10_g x_PM_DLH_X1%D_23 21.84
C_x_PM_DLH_X1%7_c0 VSS x_PM_DLH_X1%7_41 2.30901e-17
C_x_PM_DLH_X1%7_c1 VSS x_PM_DLH_X1%7_40 8.54975e-17
C_x_PM_DLH_X1%7_c2 VSS x_PM_DLH_X1%7_37 4.68164e-17
C_x_PM_DLH_X1%7_c3 VSS x_PM_DLH_X1%7_35 3.28173e-17
C_x_PM_DLH_X1%7_c4 VSS x_PM_DLH_X1%7_34 3.72948e-17
C_x_PM_DLH_X1%7_c5 VSS x_PM_DLH_X1%7_33 8.52083e-18
C_x_PM_DLH_X1%7_c6 VSS x_PM_DLH_X1%7_32 1.48037e-17
C_x_PM_DLH_X1%7_c7 VSS N_7_M3_d 3.06783e-17
C_x_PM_DLH_X1%7_c8 VSS N_7_M11_d 4.98696e-17
C_x_PM_DLH_X1%7_c9 VSS x_PM_DLH_X1%7_21 8.06682e-18
C_x_PM_DLH_X1%7_c10 VSS x_PM_DLH_X1%7_20 2.03445e-18
C_x_PM_DLH_X1%7_c11 VSS x_PM_DLH_X1%7_19 2.79489e-17
C_x_PM_DLH_X1%7_c12 VSS N_7_M7_g 6.91522e-17
C_x_PM_DLH_X1%7_c13 VSS N_7_M15_g 3.53941e-17
C_x_PM_DLH_X1%7_c14 VSS x_PM_DLH_X1%7_9 1.00249e-17
C_x_PM_DLH_X1%7_c15 VSS N_7_M6_g 6.86766e-17
C_x_PM_DLH_X1%7_c16 VSS N_7_M14_g 3.34467e-17
R_x_PM_DLH_X1%7_r17 x_PM_DLH_X1%7_41 x_PM_DLH_X1%7_40 0.115915
R_x_PM_DLH_X1%7_r18 x_PM_DLH_X1%7_40 x_PM_DLH_X1%7_38 0.347287
R_x_PM_DLH_X1%7_r19 x_PM_DLH_X1%7_42 x_PM_DLH_X1%7_38 25.0012
R_x_PM_DLH_X1%7_r20 x_PM_DLH_X1%7_41 x_PM_DLH_X1%7_36 0.0855182
R_x_PM_DLH_X1%7_r21 x_PM_DLH_X1%7_37 x_PM_DLH_X1%7_36 2.00857
R_x_PM_DLH_X1%7_r22 x_PM_DLH_X1%7_37 x_PM_DLH_X1%7_34 0.212317
R_x_PM_DLH_X1%7_r23 x_PM_DLH_X1%7_35 x_PM_DLH_X1%7_34 0.95
R_x_PM_DLH_X1%7_r24 x_PM_DLH_X1%7_41 x_PM_DLH_X1%7_32 0.115915
R_x_PM_DLH_X1%7_r25 x_PM_DLH_X1%7_33 x_PM_DLH_X1%7_32 0.95
R_x_PM_DLH_X1%7_r26 x_PM_DLH_X1%7_35 x_PM_DLH_X1%7_28 0.212317
R_x_PM_DLH_X1%7_r27 N_7_M3_d x_PM_DLH_X1%7_28 0.746429
R_x_PM_DLH_X1%7_r28 x_PM_DLH_X1%7_33 x_PM_DLH_X1%7_24 0.212317
R_x_PM_DLH_X1%7_r29 N_7_M11_d x_PM_DLH_X1%7_24 1.20786
R_x_PM_DLH_X1%7_r30 x_PM_DLH_X1%7_42 x_PM_DLH_X1%7_19 17.94
R_x_PM_DLH_X1%7_r31 x_PM_DLH_X1%7_20 x_PM_DLH_X1%7_19 1.95
R_x_PM_DLH_X1%7_r32 x_PM_DLH_X1%7_21 x_PM_DLH_X1%7_15 4.56151
R_x_PM_DLH_X1%7_r33 N_7_M7_g x_PM_DLH_X1%7_15 101.79
R_x_PM_DLH_X1%7_r34 x_PM_DLH_X1%7_21 x_PM_DLH_X1%7_11 4.56151
R_x_PM_DLH_X1%7_r35 N_7_M15_g x_PM_DLH_X1%7_11 42.9
R_x_PM_DLH_X1%7_r36 x_PM_DLH_X1%7_20 x_PM_DLH_X1%7_10 1.95
R_x_PM_DLH_X1%7_r37 x_PM_DLH_X1%7_21 x_PM_DLH_X1%7_9 0.043368
R_x_PM_DLH_X1%7_r38 x_PM_DLH_X1%7_10 x_PM_DLH_X1%7_9 14.56
R_x_PM_DLH_X1%7_r39 x_PM_DLH_X1%7_20 x_PM_DLH_X1%7_5 1.95
R_x_PM_DLH_X1%7_r40 N_7_M6_g x_PM_DLH_X1%7_5 84.24
R_x_PM_DLH_X1%7_r41 x_PM_DLH_X1%7_20 x_PM_DLH_X1%7_VSS 1.95
R_x_PM_DLH_X1%7_r42 N_7_M14_g x_PM_DLH_X1%7_VSS 35.88
C_x_PM_DLH_X1%8_c0 VSS N_8_M6_s 1.01049e-16
C_x_PM_DLH_X1%8_c1 VSS x_PM_DLH_X1%8_16 1.2994e-17
C_x_PM_DLH_X1%8_c2 VSS x_PM_DLH_X1%8_14 7.88752e-18
C_x_PM_DLH_X1%8_c3 VSS x_PM_DLH_X1%8_11 8.24926e-17
C_x_PM_DLH_X1%8_c4 VSS N_8_M5_g 1.09557e-16
C_x_PM_DLH_X1%8_c5 VSS N_8_M13_g 2.95228e-17
R_x_PM_DLH_X1%8_r6 N_8_M6_s x_PM_DLH_X1%8_16 3.84071
R_x_PM_DLH_X1%8_r7 x_PM_DLH_X1%8_23 x_PM_DLH_X1%8_14 4.7687
R_x_PM_DLH_X1%8_r8 x_PM_DLH_X1%8_22 x_PM_DLH_X1%8_14 4.7687
R_x_PM_DLH_X1%8_r9 x_PM_DLH_X1%8_14 x_PM_DLH_X1%8_12 25.0012
R_x_PM_DLH_X1%8_r10 x_PM_DLH_X1%8_12 x_PM_DLH_X1%8_11 0.85087
R_x_PM_DLH_X1%8_r11 N_8_M14_s x_PM_DLH_X1%8_16 0.184869
R_x_PM_DLH_X1%8_r12 N_8_M14_s x_PM_DLH_X1%8_11 0.0442079
R_x_PM_DLH_X1%8_r13 N_8_M5_g x_PM_DLH_X1%8_23 114.66
R_x_PM_DLH_X1%8_r14 N_8_M13_g x_PM_DLH_X1%8_22 21.84
C_x_PM_DLH_X1%Q_c0 VSS x_PM_DLH_X1%Q_15 4.02884e-18
C_x_PM_DLH_X1%Q_c1 VSS N_Q_M7_d 6.52517e-17
C_x_PM_DLH_X1%Q_c2 VSS N_Q_M15_d 5.77653e-17
C_x_PM_DLH_X1%Q_c3 VSS x_PM_DLH_X1%Q_3 2.81053e-17
R_x_PM_DLH_X1%Q_r4 x_PM_DLH_X1%Q_15 x_PM_DLH_X1%Q_11 0.273842
R_x_PM_DLH_X1%Q_r5 N_Q_M7_d x_PM_DLH_X1%Q_11 2.61929
R_x_PM_DLH_X1%Q_r6 x_PM_DLH_X1%Q_15 x_PM_DLH_X1%Q_7 0.273842
R_x_PM_DLH_X1%Q_r7 N_Q_M15_d x_PM_DLH_X1%Q_7 1.85929
R_x_PM_DLH_X1%Q_r8 x_PM_DLH_X1%Q_15 x_PM_DLH_X1%Q_3 0.0307623
R_x_PM_DLH_X1%Q_r9 Q x_PM_DLH_X1%Q_3 0.298571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLH_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLH_X2 VSS VDD G D Q
*.PININFO VSS:B VDD:B G:I D:I Q:O
M_M8 N_VDD_M0_d N_G_M0_g N_3_M0_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M9 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M10 10 N_D_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M11 N_7_M3_d N_3_M3_g 10 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M12 11 N_5_M4_g N_7_M3_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M13 N_VDD_M5_d N_8_M5_g 11 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M14 N_VDD_M6_d N_7_M6_g N_8_M6_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M15 N_Q_M7_d N_7_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M8_d N_G_M8_g N_3_M8_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 12 N_D_M10_g N_VSS_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M11_d N_5_M11_g 12 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 13 N_3_M12_g N_7_M11_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M13_d N_8_M13_g 13 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_VSS_M14_d N_7_M14_g N_8_M14_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_Q_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_DLH_X2%VSS_c0 VSS x_PM_DLH_X2%VSS_30 4.66629e-17
C_x_PM_DLH_X2%VSS_c1 VSS x_PM_DLH_X2%VSS_29 2.96451e-17
C_x_PM_DLH_X2%VSS_c2 VSS x_PM_DLH_X2%VSS_25 2.71388e-18
C_x_PM_DLH_X2%VSS_c3 VSS N_VSS_M8_d 3.53119e-17
C_x_PM_DLH_X2%VSS_c4 VSS x_PM_DLH_X2%VSS_17 2.8428e-17
C_x_PM_DLH_X2%VSS_c5 VSS x_PM_DLH_X2%VSS_13 7.07179e-17
C_x_PM_DLH_X2%VSS_c6 VSS N_VSS_M10_s 1.26437e-17
C_x_PM_DLH_X2%VSS_c7 VSS x_PM_DLH_X2%VSS_8 2.27089e-17
C_x_PM_DLH_X2%VSS_c8 VSS x_PM_DLH_X2%VSS_7 2.81812e-17
R_x_PM_DLH_X2%VSS_r9 N_VSS_M14_d x_PM_DLH_X2%VSS_30 0.49963
R_x_PM_DLH_X2%VSS_r10 x_PM_DLH_X2%VSS_29 N_VSS_M13_d 0.140674
R_x_PM_DLH_X2%VSS_r11 x_PM_DLH_X2%VSS_30 x_PM_DLH_X2%VSS_17 0.095
R_x_PM_DLH_X2%VSS_r12 x_PM_DLH_X2%VSS_29 x_PM_DLH_X2%VSS_17 0.592353
R_x_PM_DLH_X2%VSS_r13 x_PM_DLH_X2%VSS_25 x_PM_DLH_X2%VSS_14 0.0731438
R_x_PM_DLH_X2%VSS_r14 VSS x_PM_DLH_X2%VSS_14 0.804706
R_x_PM_DLH_X2%VSS_r15 x_PM_DLH_X2%VSS_13 N_VSS_M13_d 0.140674
R_x_PM_DLH_X2%VSS_r16 VSS x_PM_DLH_X2%VSS_13 0.659412
R_x_PM_DLH_X2%VSS_r17 x_PM_DLH_X2%VSS_25 x_PM_DLH_X2%VSS_9 0.145286
R_x_PM_DLH_X2%VSS_r18 N_VSS_M10_s x_PM_DLH_X2%VSS_9 0.230714
R_x_PM_DLH_X2%VSS_r19 x_PM_DLH_X2%VSS_8 N_VSS_M8_d 0.140674
R_x_PM_DLH_X2%VSS_r20 x_PM_DLH_X2%VSS_25 x_PM_DLH_X2%VSS_7 0.0731438
R_x_PM_DLH_X2%VSS_r21 x_PM_DLH_X2%VSS_8 x_PM_DLH_X2%VSS_7 0.525294
C_x_PM_DLH_X2%VDD_c0 VSS x_PM_DLH_X2%VDD_32 3.12702e-17
C_x_PM_DLH_X2%VDD_c1 VSS x_PM_DLH_X2%VDD_31 6.34178e-18
C_x_PM_DLH_X2%VDD_c2 VSS x_PM_DLH_X2%VDD_30 2.05415e-17
C_x_PM_DLH_X2%VDD_c3 VSS x_PM_DLH_X2%VDD_26 1.96865e-17
C_x_PM_DLH_X2%VDD_c4 VSS x_PM_DLH_X2%VDD_20 2.51332e-17
C_x_PM_DLH_X2%VDD_c5 VSS x_PM_DLH_X2%VDD_17 2.25624e-17
C_x_PM_DLH_X2%VDD_c6 VSS N_VDD_M5_d 2.56077e-17
C_x_PM_DLH_X2%VDD_c7 VSS x_PM_DLH_X2%VDD_11 6.80784e-17
C_x_PM_DLH_X2%VDD_c8 VSS x_PM_DLH_X2%VDD_9 2.21292e-17
C_x_PM_DLH_X2%VDD_c9 VSS x_PM_DLH_X2%VDD_5 3.11372e-17
R_x_PM_DLH_X2%VDD_r10 x_PM_DLH_X2%VDD_30 N_VDD_M2_s 0.140674
R_x_PM_DLH_X2%VDD_r11 x_PM_DLH_X2%VDD_26 N_VDD_M0_d 0.140674
R_x_PM_DLH_X2%VDD_r12 x_PM_DLH_X2%VDD_32 x_PM_DLH_X2%VDD_20 0.0680382
R_x_PM_DLH_X2%VDD_r13 x_PM_DLH_X2%VDD_20 N_VDD_M6_d 0.305065
R_x_PM_DLH_X2%VDD_r14 x_PM_DLH_X2%VDD_31 x_PM_DLH_X2%VDD_18 0.132285
R_x_PM_DLH_X2%VDD_r15 x_PM_DLH_X2%VDD_32 x_PM_DLH_X2%VDD_17 0.132285
R_x_PM_DLH_X2%VDD_r16 x_PM_DLH_X2%VDD_18 x_PM_DLH_X2%VDD_17 0.592353
R_x_PM_DLH_X2%VDD_r17 x_PM_DLH_X2%VDD_31 x_PM_DLH_X2%VDD_13 0.0680382
R_x_PM_DLH_X2%VDD_r18 N_VDD_M5_d x_PM_DLH_X2%VDD_13 0.11963
R_x_PM_DLH_X2%VDD_r19 x_PM_DLH_X2%VDD_31 x_PM_DLH_X2%VDD_11 0.132285
R_x_PM_DLH_X2%VDD_r20 x_PM_DLH_X2%VDD_30 x_PM_DLH_X2%VDD_11 1.38588
R_x_PM_DLH_X2%VDD_r21 x_PM_DLH_X2%VDD_9 N_VDD_M2_s 0.140674
R_x_PM_DLH_X2%VDD_r22 x_PM_DLH_X2%VDD_26 x_PM_DLH_X2%VDD_9 0.458235
R_x_PM_DLH_X2%VDD_r23 x_PM_DLH_X2%VDD_5 N_VDD_M0_d 0.140674
R_x_PM_DLH_X2%VDD_r24 VDD x_PM_DLH_X2%VDD_5 0.273824
C_x_PM_DLH_X2%3_c0 VSS N_3_M8_s 3.36448e-17
C_x_PM_DLH_X2%3_c1 VSS x_PM_DLH_X2%3_35 1.41574e-16
C_x_PM_DLH_X2%3_c2 VSS x_PM_DLH_X2%3_31 9.95573e-18
C_x_PM_DLH_X2%3_c3 VSS x_PM_DLH_X2%3_30 3.18552e-17
C_x_PM_DLH_X2%3_c4 VSS x_PM_DLH_X2%3_28 3.57208e-17
C_x_PM_DLH_X2%3_c5 VSS N_3_M0_s 1.97297e-17
C_x_PM_DLH_X2%3_c6 VSS x_PM_DLH_X2%3_21 3.17022e-18
C_x_PM_DLH_X2%3_c7 VSS N_3_M12_g 6.7911e-17
C_x_PM_DLH_X2%3_c8 VSS x_PM_DLH_X2%3_15 2.31556e-17
C_x_PM_DLH_X2%3_c9 VSS N_3_M3_g 6.75677e-17
C_x_PM_DLH_X2%3_c10 VSS x_PM_DLH_X2%3_10 7.0789e-18
C_x_PM_DLH_X2%3_c11 VSS x_PM_DLH_X2%3_9 5.83397e-17
C_x_PM_DLH_X2%3_c12 VSS N_3_M1_g 6.52243e-17
C_x_PM_DLH_X2%3_c13 VSS N_3_M9_g 6.86882e-17
R_x_PM_DLH_X2%3_r14 x_PM_DLH_X2%3_44 x_PM_DLH_X2%3_42 3.9
R_x_PM_DLH_X2%3_r15 x_PM_DLH_X2%3_40 N_3_M8_s 0.330741
R_x_PM_DLH_X2%3_r16 x_PM_DLH_X2%3_42 x_PM_DLH_X2%3_35 25.0012
R_x_PM_DLH_X2%3_r17 x_PM_DLH_X2%3_35 x_PM_DLH_X2%3_33 1.28929
R_x_PM_DLH_X2%3_r18 x_PM_DLH_X2%3_35 x_PM_DLH_X2%3_32 1.77786
R_x_PM_DLH_X2%3_r19 x_PM_DLH_X2%3_33 x_PM_DLH_X2%3_30 0.212317
R_x_PM_DLH_X2%3_r20 x_PM_DLH_X2%3_31 x_PM_DLH_X2%3_30 0.76
R_x_PM_DLH_X2%3_r21 x_PM_DLH_X2%3_40 x_PM_DLH_X2%3_29 0.095
R_x_PM_DLH_X2%3_r22 x_PM_DLH_X2%3_32 x_PM_DLH_X2%3_28 0.212317
R_x_PM_DLH_X2%3_r23 x_PM_DLH_X2%3_29 x_PM_DLH_X2%3_28 0.76
R_x_PM_DLH_X2%3_r24 x_PM_DLH_X2%3_31 x_PM_DLH_X2%3_24 0.241334
R_x_PM_DLH_X2%3_r25 N_3_M0_s x_PM_DLH_X2%3_24 0.302593
R_x_PM_DLH_X2%3_r26 N_3_M12_g x_PM_DLH_X2%3_17 77.22
R_x_PM_DLH_X2%3_r27 x_PM_DLH_X2%3_21 x_PM_DLH_X2%3_16 2.32903
R_x_PM_DLH_X2%3_r28 x_PM_DLH_X2%3_17 x_PM_DLH_X2%3_15 4.58872
R_x_PM_DLH_X2%3_r29 x_PM_DLH_X2%3_16 x_PM_DLH_X2%3_15 14.56
R_x_PM_DLH_X2%3_r30 x_PM_DLH_X2%3_21 x_PM_DLH_X2%3_11 1.81308
R_x_PM_DLH_X2%3_r31 N_3_M3_g x_PM_DLH_X2%3_11 59.28
R_x_PM_DLH_X2%3_r32 x_PM_DLH_X2%3_44 x_PM_DLH_X2%3_10 2.6
R_x_PM_DLH_X2%3_r33 x_PM_DLH_X2%3_21 x_PM_DLH_X2%3_9 2.32903
R_x_PM_DLH_X2%3_r34 x_PM_DLH_X2%3_10 x_PM_DLH_X2%3_9 49.92
R_x_PM_DLH_X2%3_r35 x_PM_DLH_X2%3_44 x_PM_DLH_X2%3_5 1.95
R_x_PM_DLH_X2%3_r36 N_3_M1_g x_PM_DLH_X2%3_5 59.28
R_x_PM_DLH_X2%3_r37 x_PM_DLH_X2%3_44 x_PM_DLH_X2%3_VSS 1.95
R_x_PM_DLH_X2%3_r38 N_3_M9_g x_PM_DLH_X2%3_VSS 77.22
C_x_PM_DLH_X2%G_c0 VSS x_PM_DLH_X2%G_14 6.07227e-18
C_x_PM_DLH_X2%G_c1 VSS x_PM_DLH_X2%G_12 3.86703e-17
C_x_PM_DLH_X2%G_c2 VSS N_G_M0_g 6.8883e-17
C_x_PM_DLH_X2%G_c3 VSS N_G_M8_g 5.58834e-17
R_x_PM_DLH_X2%G_r4 x_PM_DLH_X2%G_18 x_PM_DLH_X2%G_14 4.7687
R_x_PM_DLH_X2%G_r5 x_PM_DLH_X2%G_17 x_PM_DLH_X2%G_14 4.7687
R_x_PM_DLH_X2%G_r6 x_PM_DLH_X2%G_14 x_PM_DLH_X2%G_12 25.0012
R_x_PM_DLH_X2%G_r7 x_PM_DLH_X2%G_12 G 0.291786
R_x_PM_DLH_X2%G_r8 N_G_M0_g x_PM_DLH_X2%G_18 72.54
R_x_PM_DLH_X2%G_r9 N_G_M8_g x_PM_DLH_X2%G_17 63.96
C_x_PM_DLH_X2%5_c0 VSS x_PM_DLH_X2%5_36 5.43595e-18
C_x_PM_DLH_X2%5_c1 VSS x_PM_DLH_X2%5_32 4.43592e-17
C_x_PM_DLH_X2%5_c2 VSS x_PM_DLH_X2%5_29 1.19945e-17
C_x_PM_DLH_X2%5_c3 VSS x_PM_DLH_X2%5_27 6.107e-17
C_x_PM_DLH_X2%5_c4 VSS x_PM_DLH_X2%5_26 1.92262e-17
C_x_PM_DLH_X2%5_c5 VSS x_PM_DLH_X2%5_25 1.10541e-17
C_x_PM_DLH_X2%5_c6 VSS x_PM_DLH_X2%5_22 4.76488e-17
C_x_PM_DLH_X2%5_c7 VSS N_5_M1_d 1.89019e-17
C_x_PM_DLH_X2%5_c8 VSS x_PM_DLH_X2%5_17 1.07848e-16
C_x_PM_DLH_X2%5_c9 VSS N_5_M9_d 5.98382e-17
C_x_PM_DLH_X2%5_c10 VSS x_PM_DLH_X2%5_9 5.40225e-17
C_x_PM_DLH_X2%5_c11 VSS N_5_M4_g 5.1072e-17
C_x_PM_DLH_X2%5_c12 VSS N_5_M11_g 4.55896e-17
R_x_PM_DLH_X2%5_r13 x_PM_DLH_X2%5_35 x_PM_DLH_X2%5_32 0.277735
R_x_PM_DLH_X2%5_r14 x_PM_DLH_X2%5_34 x_PM_DLH_X2%5_32 0.277735
R_x_PM_DLH_X2%5_r15 x_PM_DLH_X2%5_37 x_PM_DLH_X2%5_32 25.0012
R_x_PM_DLH_X2%5_r16 x_PM_DLH_X2%5_41 x_PM_DLH_X2%5_29 4.7687
R_x_PM_DLH_X2%5_r17 x_PM_DLH_X2%5_29 x_PM_DLH_X2%5_27 25.0012
R_x_PM_DLH_X2%5_r18 x_PM_DLH_X2%5_27 x_PM_DLH_X2%5_26 1.15357
R_x_PM_DLH_X2%5_r19 x_PM_DLH_X2%5_26 x_PM_DLH_X2%5_24 0.212317
R_x_PM_DLH_X2%5_r20 x_PM_DLH_X2%5_25 x_PM_DLH_X2%5_24 0.624286
R_x_PM_DLH_X2%5_r21 x_PM_DLH_X2%5_36 x_PM_DLH_X2%5_23 0.0418175
R_x_PM_DLH_X2%5_r22 x_PM_DLH_X2%5_25 x_PM_DLH_X2%5_22 0.212317
R_x_PM_DLH_X2%5_r23 x_PM_DLH_X2%5_23 x_PM_DLH_X2%5_22 1.60143
R_x_PM_DLH_X2%5_r24 x_PM_DLH_X2%5_36 x_PM_DLH_X2%5_18 0.160909
R_x_PM_DLH_X2%5_r25 N_5_M1_d x_PM_DLH_X2%5_18 0.230714
R_x_PM_DLH_X2%5_r26 x_PM_DLH_X2%5_36 x_PM_DLH_X2%5_17 0.160909
R_x_PM_DLH_X2%5_r27 x_PM_DLH_X2%5_17 x_PM_DLH_X2%5_35 2.38857
R_x_PM_DLH_X2%5_r28 N_5_M9_d x_PM_DLH_X2%5_34 1.12643
R_x_PM_DLH_X2%5_r29 x_PM_DLH_X2%5_37 x_PM_DLH_X2%5_9 36.14
R_x_PM_DLH_X2%5_r30 N_5_M4_g x_PM_DLH_X2%5_41 35.88
R_x_PM_DLH_X2%5_r31 x_PM_DLH_X2%5_9 x_PM_DLH_X2%5_VSS 4.58872
R_x_PM_DLH_X2%5_r32 N_5_M11_g x_PM_DLH_X2%5_VSS 45.24
C_x_PM_DLH_X2%D_c0 VSS x_PM_DLH_X2%D_23 1.63295e-17
C_x_PM_DLH_X2%D_c1 VSS D 6.03593e-17
C_x_PM_DLH_X2%D_c2 VSS x_PM_DLH_X2%D_12 1.09808e-17
C_x_PM_DLH_X2%D_c3 VSS x_PM_DLH_X2%D_10 5.17344e-17
C_x_PM_DLH_X2%D_c4 VSS N_D_M2_g 5.33159e-17
C_x_PM_DLH_X2%D_c5 VSS N_D_M10_g 3.24502e-17
R_x_PM_DLH_X2%D_r6 x_PM_DLH_X2%D_23 x_PM_DLH_X2%D_19 4.94
R_x_PM_DLH_X2%D_r7 x_PM_DLH_X2%D_19 x_PM_DLH_X2%D_17 25.0012
R_x_PM_DLH_X2%D_r8 x_PM_DLH_X2%D_17 D 0.26037
R_x_PM_DLH_X2%D_r9 x_PM_DLH_X2%D_16 D 0.284786
R_x_PM_DLH_X2%D_r10 x_PM_DLH_X2%D_26 x_PM_DLH_X2%D_12 4.7687
R_x_PM_DLH_X2%D_r11 x_PM_DLH_X2%D_12 x_PM_DLH_X2%D_10 25.0012
R_x_PM_DLH_X2%D_r12 x_PM_DLH_X2%D_10 x_PM_DLH_X2%D_16 1.85929
R_x_PM_DLH_X2%D_r13 x_PM_DLH_X2%D_23 x_PM_DLH_X2%D_5 1.95
R_x_PM_DLH_X2%D_r14 N_D_M2_g x_PM_DLH_X2%D_5 35.88
R_x_PM_DLH_X2%D_r15 N_D_M10_g x_PM_DLH_X2%D_26 21.84
C_x_PM_DLH_X2%7_c0 VSS x_PM_DLH_X2%7_41 2.31368e-17
C_x_PM_DLH_X2%7_c1 VSS x_PM_DLH_X2%7_40 9.14977e-17
C_x_PM_DLH_X2%7_c2 VSS x_PM_DLH_X2%7_37 4.62917e-17
C_x_PM_DLH_X2%7_c3 VSS x_PM_DLH_X2%7_35 2.52794e-17
C_x_PM_DLH_X2%7_c4 VSS x_PM_DLH_X2%7_34 3.79067e-17
C_x_PM_DLH_X2%7_c5 VSS x_PM_DLH_X2%7_33 8.40897e-18
C_x_PM_DLH_X2%7_c6 VSS x_PM_DLH_X2%7_32 1.48748e-17
C_x_PM_DLH_X2%7_c7 VSS N_7_M3_d 3.4352e-17
C_x_PM_DLH_X2%7_c8 VSS N_7_M11_d 4.1892e-17
C_x_PM_DLH_X2%7_c9 VSS x_PM_DLH_X2%7_21 6.61384e-18
C_x_PM_DLH_X2%7_c10 VSS x_PM_DLH_X2%7_20 6.72026e-19
C_x_PM_DLH_X2%7_c11 VSS x_PM_DLH_X2%7_19 2.97519e-17
C_x_PM_DLH_X2%7_c12 VSS N_7_M7_g 6.26658e-17
C_x_PM_DLH_X2%7_c13 VSS N_7_M15_g 3.42576e-17
C_x_PM_DLH_X2%7_c14 VSS x_PM_DLH_X2%7_9 6.61581e-18
C_x_PM_DLH_X2%7_c15 VSS N_7_M6_g 7.26294e-17
C_x_PM_DLH_X2%7_c16 VSS N_7_M14_g 3.41139e-17
R_x_PM_DLH_X2%7_r17 x_PM_DLH_X2%7_41 x_PM_DLH_X2%7_40 0.115915
R_x_PM_DLH_X2%7_r18 x_PM_DLH_X2%7_40 x_PM_DLH_X2%7_38 0.417657
R_x_PM_DLH_X2%7_r19 x_PM_DLH_X2%7_42 x_PM_DLH_X2%7_38 25.0012
R_x_PM_DLH_X2%7_r20 x_PM_DLH_X2%7_41 x_PM_DLH_X2%7_36 0.0855182
R_x_PM_DLH_X2%7_r21 x_PM_DLH_X2%7_37 x_PM_DLH_X2%7_36 2.03571
R_x_PM_DLH_X2%7_r22 x_PM_DLH_X2%7_37 x_PM_DLH_X2%7_34 0.212317
R_x_PM_DLH_X2%7_r23 x_PM_DLH_X2%7_35 x_PM_DLH_X2%7_34 0.95
R_x_PM_DLH_X2%7_r24 x_PM_DLH_X2%7_41 x_PM_DLH_X2%7_32 0.115915
R_x_PM_DLH_X2%7_r25 x_PM_DLH_X2%7_33 x_PM_DLH_X2%7_32 0.95
R_x_PM_DLH_X2%7_r26 x_PM_DLH_X2%7_35 x_PM_DLH_X2%7_28 0.212317
R_x_PM_DLH_X2%7_r27 N_7_M3_d x_PM_DLH_X2%7_28 0.746429
R_x_PM_DLH_X2%7_r28 x_PM_DLH_X2%7_33 x_PM_DLH_X2%7_24 0.212317
R_x_PM_DLH_X2%7_r29 N_7_M11_d x_PM_DLH_X2%7_24 1.20786
R_x_PM_DLH_X2%7_r30 x_PM_DLH_X2%7_42 x_PM_DLH_X2%7_19 20.54
R_x_PM_DLH_X2%7_r31 x_PM_DLH_X2%7_20 x_PM_DLH_X2%7_19 1.95
R_x_PM_DLH_X2%7_r32 x_PM_DLH_X2%7_21 x_PM_DLH_X2%7_15 4.56151
R_x_PM_DLH_X2%7_r33 N_7_M7_g x_PM_DLH_X2%7_15 81.9
R_x_PM_DLH_X2%7_r34 x_PM_DLH_X2%7_21 x_PM_DLH_X2%7_11 4.56151
R_x_PM_DLH_X2%7_r35 N_7_M15_g x_PM_DLH_X2%7_11 39.78
R_x_PM_DLH_X2%7_r36 x_PM_DLH_X2%7_20 x_PM_DLH_X2%7_10 1.95
R_x_PM_DLH_X2%7_r37 x_PM_DLH_X2%7_21 x_PM_DLH_X2%7_9 0.043368
R_x_PM_DLH_X2%7_r38 x_PM_DLH_X2%7_10 x_PM_DLH_X2%7_9 14.56
R_x_PM_DLH_X2%7_r39 x_PM_DLH_X2%7_20 x_PM_DLH_X2%7_5 1.95
R_x_PM_DLH_X2%7_r40 N_7_M6_g x_PM_DLH_X2%7_5 88.92
R_x_PM_DLH_X2%7_r41 x_PM_DLH_X2%7_20 x_PM_DLH_X2%7_VSS 1.95
R_x_PM_DLH_X2%7_r42 N_7_M14_g x_PM_DLH_X2%7_VSS 39.78
C_x_PM_DLH_X2%8_c0 VSS N_8_M6_s 1.04251e-16
C_x_PM_DLH_X2%8_c1 VSS x_PM_DLH_X2%8_16 1.77343e-17
C_x_PM_DLH_X2%8_c2 VSS x_PM_DLH_X2%8_14 7.87189e-18
C_x_PM_DLH_X2%8_c3 VSS x_PM_DLH_X2%8_11 1.01171e-16
C_x_PM_DLH_X2%8_c4 VSS N_8_M5_g 1.1092e-16
C_x_PM_DLH_X2%8_c5 VSS N_8_M13_g 2.86518e-17
R_x_PM_DLH_X2%8_r6 N_8_M6_s x_PM_DLH_X2%8_16 4.00357
R_x_PM_DLH_X2%8_r7 x_PM_DLH_X2%8_23 x_PM_DLH_X2%8_14 4.7687
R_x_PM_DLH_X2%8_r8 x_PM_DLH_X2%8_22 x_PM_DLH_X2%8_14 4.7687
R_x_PM_DLH_X2%8_r9 x_PM_DLH_X2%8_14 x_PM_DLH_X2%8_12 25.0012
R_x_PM_DLH_X2%8_r10 x_PM_DLH_X2%8_12 x_PM_DLH_X2%8_11 0.766786
R_x_PM_DLH_X2%8_r11 N_8_M14_s x_PM_DLH_X2%8_16 0.149444
R_x_PM_DLH_X2%8_r12 N_8_M14_s x_PM_DLH_X2%8_11 0.0951005
R_x_PM_DLH_X2%8_r13 N_8_M5_g x_PM_DLH_X2%8_23 114.66
R_x_PM_DLH_X2%8_r14 N_8_M13_g x_PM_DLH_X2%8_22 21.84
C_x_PM_DLH_X2%Q_c0 VSS N_Q_M15_d 9.36954e-17
R_x_PM_DLH_X2%Q_r1 N_Q_M7_d Q 1.94071
R_x_PM_DLH_X2%Q_r2 Q N_Q_M15_d 2.64643
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X1 VSS VDD GN D Q
*.PININFO VSS:B VDD:B GN:I D:I Q:O
M_M8 N_VDD_M0_d N_GN_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M9 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M10 10 N_D_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 N_7_M3_d N_5_M3_g 10 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 11 N_3_M4_g N_7_M3_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M13 N_VDD_M5_d N_8_M5_g 11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M14 N_VDD_M6_d N_7_M6_g N_8_M6_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M15 N_Q_M7_d N_7_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M8_d N_GN_M8_g N_3_M8_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 12 N_D_M10_g N_VSS_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M11_d N_3_M11_g 12 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 13 N_5_M12_g N_7_M11_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 N_VSS_M13_d N_8_M13_g 13 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M14_d N_7_M14_g N_8_M14_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_Q_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_DLL_X1%VSS_c0 VSS x_PM_DLL_X1%VSS_32 3.7499e-17
C_x_PM_DLL_X1%VSS_c1 VSS x_PM_DLL_X1%VSS_30 4.6069e-18
C_x_PM_DLL_X1%VSS_c2 VSS x_PM_DLL_X1%VSS_25 6.78716e-17
C_x_PM_DLL_X1%VSS_c3 VSS N_VSS_M14_d 5.20398e-17
C_x_PM_DLL_X1%VSS_c4 VSS x_PM_DLL_X1%VSS_18 3.58508e-17
C_x_PM_DLL_X1%VSS_c5 VSS x_PM_DLL_X1%VSS_13 5.72767e-17
C_x_PM_DLL_X1%VSS_c6 VSS N_VSS_M10_s 2.83786e-17
C_x_PM_DLL_X1%VSS_c7 VSS x_PM_DLL_X1%VSS_7 2.90723e-17
R_x_PM_DLL_X1%VSS_r8 x_PM_DLL_X1%VSS_32 x_PM_DLL_X1%VSS_31 0.547647
R_x_PM_DLL_X1%VSS_r9 N_VSS_M8_d x_PM_DLL_X1%VSS_25 0.49963
R_x_PM_DLL_X1%VSS_r10 x_PM_DLL_X1%VSS_32 x_PM_DLL_X1%VSS_19 0.095
R_x_PM_DLL_X1%VSS_r11 N_VSS_M14_d x_PM_DLL_X1%VSS_19 0.964074
R_x_PM_DLL_X1%VSS_r12 x_PM_DLL_X1%VSS_31 x_PM_DLL_X1%VSS_18 0.095
R_x_PM_DLL_X1%VSS_r13 x_PM_DLL_X1%VSS_18 N_VSS_M13_d 0.403583
R_x_PM_DLL_X1%VSS_r14 x_PM_DLL_X1%VSS_30 x_PM_DLL_X1%VSS_14 0.0731438
R_x_PM_DLL_X1%VSS_r15 VSS x_PM_DLL_X1%VSS_14 0.692941
R_x_PM_DLL_X1%VSS_r16 x_PM_DLL_X1%VSS_31 x_PM_DLL_X1%VSS_13 0.150882
R_x_PM_DLL_X1%VSS_r17 VSS x_PM_DLL_X1%VSS_13 0.804706
R_x_PM_DLL_X1%VSS_r18 x_PM_DLL_X1%VSS_30 x_PM_DLL_X1%VSS_9 0.145286
R_x_PM_DLL_X1%VSS_r19 N_VSS_M10_s x_PM_DLL_X1%VSS_9 0.909286
R_x_PM_DLL_X1%VSS_r20 x_PM_DLL_X1%VSS_25 x_PM_DLL_X1%VSS_8 0.095
R_x_PM_DLL_X1%VSS_r21 x_PM_DLL_X1%VSS_30 x_PM_DLL_X1%VSS_7 0.0731438
R_x_PM_DLL_X1%VSS_r22 x_PM_DLL_X1%VSS_8 x_PM_DLL_X1%VSS_7 0.536471
C_x_PM_DLL_X1%VDD_c0 VSS x_PM_DLL_X1%VDD_28 3.84024e-17
C_x_PM_DLL_X1%VDD_c1 VSS x_PM_DLL_X1%VDD_26 8.86015e-18
C_x_PM_DLL_X1%VDD_c2 VSS x_PM_DLL_X1%VDD_25 5.4003e-18
C_x_PM_DLL_X1%VDD_c3 VSS N_VDD_M6_d 5.33398e-17
C_x_PM_DLL_X1%VDD_c4 VSS x_PM_DLL_X1%VDD_18 3.67197e-17
C_x_PM_DLL_X1%VDD_c5 VSS x_PM_DLL_X1%VDD_15 6.48549e-17
C_x_PM_DLL_X1%VDD_c6 VSS x_PM_DLL_X1%VDD_14 3.42199e-17
C_x_PM_DLL_X1%VDD_c7 VSS x_PM_DLL_X1%VDD_11 1.87289e-17
C_x_PM_DLL_X1%VDD_c8 VSS x_PM_DLL_X1%VDD_10 3.23008e-17
C_x_PM_DLL_X1%VDD_c9 VSS x_PM_DLL_X1%VDD_5 2.12802e-17
R_x_PM_DLL_X1%VDD_r10 x_PM_DLL_X1%VDD_28 x_PM_DLL_X1%VDD_27 0.57
R_x_PM_DLL_X1%VDD_r11 x_PM_DLL_X1%VDD_28 x_PM_DLL_X1%VDD_19 0.095
R_x_PM_DLL_X1%VDD_r12 N_VDD_M6_d x_PM_DLL_X1%VDD_19 0.95
R_x_PM_DLL_X1%VDD_r13 x_PM_DLL_X1%VDD_27 x_PM_DLL_X1%VDD_18 0.095
R_x_PM_DLL_X1%VDD_r14 x_PM_DLL_X1%VDD_18 N_VDD_M5_d 0.403583
R_x_PM_DLL_X1%VDD_r15 x_PM_DLL_X1%VDD_26 x_PM_DLL_X1%VDD_16 0.132285
R_x_PM_DLL_X1%VDD_r16 x_PM_DLL_X1%VDD_27 x_PM_DLL_X1%VDD_15 0.150882
R_x_PM_DLL_X1%VDD_r17 x_PM_DLL_X1%VDD_16 x_PM_DLL_X1%VDD_15 1.38588
R_x_PM_DLL_X1%VDD_r18 x_PM_DLL_X1%VDD_26 x_PM_DLL_X1%VDD_14 0.0680382
R_x_PM_DLL_X1%VDD_r19 x_PM_DLL_X1%VDD_14 N_VDD_M2_s 0.403583
R_x_PM_DLL_X1%VDD_r20 x_PM_DLL_X1%VDD_25 x_PM_DLL_X1%VDD_12 0.132285
R_x_PM_DLL_X1%VDD_r21 x_PM_DLL_X1%VDD_26 x_PM_DLL_X1%VDD_11 0.132285
R_x_PM_DLL_X1%VDD_r22 x_PM_DLL_X1%VDD_12 x_PM_DLL_X1%VDD_11 0.469412
R_x_PM_DLL_X1%VDD_r23 x_PM_DLL_X1%VDD_25 x_PM_DLL_X1%VDD_10 0.0680382
R_x_PM_DLL_X1%VDD_r24 x_PM_DLL_X1%VDD_10 N_VDD_M0_d 0.544324
R_x_PM_DLL_X1%VDD_r25 x_PM_DLL_X1%VDD_25 x_PM_DLL_X1%VDD_5 0.132285
R_x_PM_DLL_X1%VDD_r26 VDD x_PM_DLL_X1%VDD_5 0.217941
C_x_PM_DLL_X1%3_c0 VSS x_PM_DLL_X1%3_43 1.22451e-17
C_x_PM_DLL_X1%3_c1 VSS N_3_M8_s 1.55728e-17
C_x_PM_DLL_X1%3_c2 VSS x_PM_DLL_X1%3_34 1.32733e-16
C_x_PM_DLL_X1%3_c3 VSS x_PM_DLL_X1%3_30 7.70902e-18
C_x_PM_DLL_X1%3_c4 VSS x_PM_DLL_X1%3_29 3.99636e-17
C_x_PM_DLL_X1%3_c5 VSS x_PM_DLL_X1%3_27 5.53496e-17
C_x_PM_DLL_X1%3_c6 VSS N_3_M0_s 2.36794e-17
C_x_PM_DLL_X1%3_c7 VSS N_3_M4_g 2.83119e-17
C_x_PM_DLL_X1%3_c8 VSS N_3_M11_g 3.53082e-17
C_x_PM_DLL_X1%3_c9 VSS x_PM_DLL_X1%3_12 5.20068e-18
C_x_PM_DLL_X1%3_c10 VSS x_PM_DLL_X1%3_11 8.58414e-17
C_x_PM_DLL_X1%3_c11 VSS x_PM_DLL_X1%3_10 6.87376e-18
C_x_PM_DLL_X1%3_c12 VSS x_PM_DLL_X1%3_9 6.30195e-17
C_x_PM_DLL_X1%3_c13 VSS N_3_M1_g 9.03527e-17
C_x_PM_DLL_X1%3_c14 VSS N_3_M9_g 2.76431e-17
R_x_PM_DLL_X1%3_r15 x_PM_DLL_X1%3_43 x_PM_DLL_X1%3_41 3.9
R_x_PM_DLL_X1%3_r16 x_PM_DLL_X1%3_39 N_3_M8_s 0.176429
R_x_PM_DLL_X1%3_r17 x_PM_DLL_X1%3_41 x_PM_DLL_X1%3_34 25.0012
R_x_PM_DLL_X1%3_r18 x_PM_DLL_X1%3_34 x_PM_DLL_X1%3_32 2.26643
R_x_PM_DLL_X1%3_r19 x_PM_DLL_X1%3_34 x_PM_DLL_X1%3_31 0.312143
R_x_PM_DLL_X1%3_r20 x_PM_DLL_X1%3_32 x_PM_DLL_X1%3_29 0.212317
R_x_PM_DLL_X1%3_r21 x_PM_DLL_X1%3_30 x_PM_DLL_X1%3_29 0.922857
R_x_PM_DLL_X1%3_r22 x_PM_DLL_X1%3_39 x_PM_DLL_X1%3_28 0.095
R_x_PM_DLL_X1%3_r23 x_PM_DLL_X1%3_31 x_PM_DLL_X1%3_27 0.212317
R_x_PM_DLL_X1%3_r24 x_PM_DLL_X1%3_28 x_PM_DLL_X1%3_27 0.922857
R_x_PM_DLL_X1%3_r25 x_PM_DLL_X1%3_30 x_PM_DLL_X1%3_23 0.212317
R_x_PM_DLL_X1%3_r26 N_3_M0_s x_PM_DLL_X1%3_23 0.800714
R_x_PM_DLL_X1%3_r27 N_3_M4_g x_PM_DLL_X1%3_17 26.52
R_x_PM_DLL_X1%3_r28 N_3_M11_g x_PM_DLL_X1%3_13 33.54
R_x_PM_DLL_X1%3_r29 x_PM_DLL_X1%3_17 x_PM_DLL_X1%3_11 4.35808
R_x_PM_DLL_X1%3_r30 x_PM_DLL_X1%3_12 x_PM_DLL_X1%3_11 104.52
R_x_PM_DLL_X1%3_r31 x_PM_DLL_X1%3_13 x_PM_DLL_X1%3_9 4.35808
R_x_PM_DLL_X1%3_r32 x_PM_DLL_X1%3_10 x_PM_DLL_X1%3_9 74.88
R_x_PM_DLL_X1%3_r33 x_PM_DLL_X1%3_12 x_PM_DLL_X1%3_6 4.35808
R_x_PM_DLL_X1%3_r34 N_3_M1_g x_PM_DLL_X1%3_6 41.34
R_x_PM_DLL_X1%3_r35 x_PM_DLL_X1%3_43 x_PM_DLL_X1%3_5 1.95
R_x_PM_DLL_X1%3_r36 N_3_M1_g x_PM_DLL_X1%3_5 93.6
R_x_PM_DLL_X1%3_r37 x_PM_DLL_X1%3_43 x_PM_DLL_X1%3_2 1.95
R_x_PM_DLL_X1%3_r38 N_3_M9_g x_PM_DLL_X1%3_2 21.84
R_x_PM_DLL_X1%3_r39 x_PM_DLL_X1%3_10 x_PM_DLL_X1%3_VSS 4.35808
R_x_PM_DLL_X1%3_r40 N_3_M9_g x_PM_DLL_X1%3_VSS 21.84
C_x_PM_DLL_X1%GN_c0 VSS x_PM_DLL_X1%GN_14 7.32049e-18
C_x_PM_DLL_X1%GN_c1 VSS x_PM_DLL_X1%GN_12 5.07695e-17
C_x_PM_DLL_X1%GN_c2 VSS N_GN_M0_g 5.79897e-17
C_x_PM_DLL_X1%GN_c3 VSS N_GN_M8_g 4.88974e-17
R_x_PM_DLL_X1%GN_r4 x_PM_DLL_X1%GN_18 x_PM_DLL_X1%GN_14 4.74714
R_x_PM_DLL_X1%GN_r5 x_PM_DLL_X1%GN_17 x_PM_DLL_X1%GN_14 4.74714
R_x_PM_DLL_X1%GN_r6 x_PM_DLL_X1%GN_14 x_PM_DLL_X1%GN_12 25.0012
R_x_PM_DLL_X1%GN_r7 x_PM_DLL_X1%GN_12 GN 0.156071
R_x_PM_DLL_X1%GN_r8 N_GN_M0_g x_PM_DLL_X1%GN_18 57.72
R_x_PM_DLL_X1%GN_r9 N_GN_M8_g x_PM_DLL_X1%GN_17 50.7
C_x_PM_DLL_X1%5_c0 VSS x_PM_DLL_X1%5_21 8.51346e-17
C_x_PM_DLL_X1%5_c1 VSS x_PM_DLL_X1%5_17 6.66179e-17
C_x_PM_DLL_X1%5_c2 VSS N_5_M9_d 1.5583e-16
C_x_PM_DLL_X1%5_c3 VSS x_PM_DLL_X1%5_13 9.94476e-18
C_x_PM_DLL_X1%5_c4 VSS N_5_M12_g 5.36801e-17
C_x_PM_DLL_X1%5_c5 VSS x_PM_DLL_X1%5_5 2.62033e-17
C_x_PM_DLL_X1%5_c6 VSS N_5_M3_g 4.7638e-17
C_x_PM_DLL_X1%5_c7 VSS x_PM_DLL_X1%5_VSS 7.85748e-18
R_x_PM_DLL_X1%5_r8 x_PM_DLL_X1%5_22 x_PM_DLL_X1%5_21 25.0012
R_x_PM_DLL_X1%5_r9 x_PM_DLL_X1%5_21 x_PM_DLL_X1%5_19 1.50643
R_x_PM_DLL_X1%5_r10 N_5_M1_d x_PM_DLL_X1%5_18 0.106158
R_x_PM_DLL_X1%5_r11 x_PM_DLL_X1%5_19 x_PM_DLL_X1%5_17 0.212317
R_x_PM_DLL_X1%5_r12 x_PM_DLL_X1%5_18 x_PM_DLL_X1%5_17 1.92714
R_x_PM_DLL_X1%5_r13 N_5_M1_d x_PM_DLL_X1%5_13 0.106158
R_x_PM_DLL_X1%5_r14 N_5_M9_d x_PM_DLL_X1%5_13 3.65071
R_x_PM_DLL_X1%5_r15 N_5_M12_g x_PM_DLL_X1%5_7 59.28
R_x_PM_DLL_X1%5_r16 x_PM_DLL_X1%5_22 x_PM_DLL_X1%5_6 1.96659
R_x_PM_DLL_X1%5_r17 x_PM_DLL_X1%5_7 x_PM_DLL_X1%5_5 4.58872
R_x_PM_DLL_X1%5_r18 x_PM_DLL_X1%5_6 x_PM_DLL_X1%5_5 16.12
R_x_PM_DLL_X1%5_r19 x_PM_DLL_X1%5_22 x_PM_DLL_X1%5_VSS 2.62213
R_x_PM_DLL_X1%5_r20 N_5_M3_g x_PM_DLL_X1%5_VSS 52.26
C_x_PM_DLL_X1%D_c0 VSS x_PM_DLL_X1%D_14 7.89461e-18
C_x_PM_DLL_X1%D_c1 VSS x_PM_DLL_X1%D_12 5.46655e-17
C_x_PM_DLL_X1%D_c2 VSS N_D_M2_g 5.14748e-17
C_x_PM_DLL_X1%D_c3 VSS N_D_M10_g 5.98948e-17
R_x_PM_DLL_X1%D_r4 x_PM_DLL_X1%D_18 x_PM_DLL_X1%D_14 4.7687
R_x_PM_DLL_X1%D_r5 x_PM_DLL_X1%D_17 x_PM_DLL_X1%D_14 4.7687
R_x_PM_DLL_X1%D_r6 x_PM_DLL_X1%D_14 x_PM_DLL_X1%D_12 25.0012
R_x_PM_DLL_X1%D_r7 x_PM_DLL_X1%D_12 D 0.128929
R_x_PM_DLL_X1%D_r8 N_D_M2_g x_PM_DLL_X1%D_18 43.68
R_x_PM_DLL_X1%D_r9 N_D_M10_g x_PM_DLL_X1%D_17 60.84
C_x_PM_DLL_X1%7_c0 VSS x_PM_DLL_X1%7_39 3.98756e-17
C_x_PM_DLL_X1%7_c1 VSS N_7_M3_d 2.81471e-17
C_x_PM_DLL_X1%7_c2 VSS N_7_M11_d 2.20681e-17
C_x_PM_DLL_X1%7_c3 VSS x_PM_DLL_X1%7_30 6.42183e-17
C_x_PM_DLL_X1%7_c4 VSS x_PM_DLL_X1%7_27 6.25834e-17
C_x_PM_DLL_X1%7_c5 VSS x_PM_DLL_X1%7_25 1.57046e-17
C_x_PM_DLL_X1%7_c6 VSS x_PM_DLL_X1%7_21 6.7376e-18
C_x_PM_DLL_X1%7_c7 VSS x_PM_DLL_X1%7_20 6.72026e-19
C_x_PM_DLL_X1%7_c8 VSS x_PM_DLL_X1%7_19 2.91737e-17
C_x_PM_DLL_X1%7_c9 VSS N_7_M7_g 3.72875e-17
C_x_PM_DLL_X1%7_c10 VSS N_7_M15_g 2.82042e-17
C_x_PM_DLL_X1%7_c11 VSS x_PM_DLL_X1%7_9 7.50352e-18
C_x_PM_DLL_X1%7_c12 VSS N_7_M6_g 3.03886e-17
C_x_PM_DLL_X1%7_c13 VSS N_7_M14_g 2.66839e-17
R_x_PM_DLL_X1%7_r14 x_PM_DLL_X1%7_39 x_PM_DLL_X1%7_30 0.0272847
R_x_PM_DLL_X1%7_r15 x_PM_DLL_X1%7_30 x_PM_DLL_X1%7_28 0.642842
R_x_PM_DLL_X1%7_r16 x_PM_DLL_X1%7_40 x_PM_DLL_X1%7_28 25.0012
R_x_PM_DLL_X1%7_r17 x_PM_DLL_X1%7_27 N_7_M3_d 0.297071
R_x_PM_DLL_X1%7_r18 x_PM_DLL_X1%7_39 x_PM_DLL_X1%7_26 0.266978
R_x_PM_DLL_X1%7_r19 x_PM_DLL_X1%7_27 x_PM_DLL_X1%7_26 1.81857
R_x_PM_DLL_X1%7_r20 x_PM_DLL_X1%7_39 x_PM_DLL_X1%7_25 0.266978
R_x_PM_DLL_X1%7_r21 x_PM_DLL_X1%7_24 N_7_M11_d 0.29113
R_x_PM_DLL_X1%7_r22 x_PM_DLL_X1%7_25 x_PM_DLL_X1%7_24 1.00429
R_x_PM_DLL_X1%7_r23 x_PM_DLL_X1%7_40 x_PM_DLL_X1%7_19 20.54
R_x_PM_DLL_X1%7_r24 x_PM_DLL_X1%7_20 x_PM_DLL_X1%7_19 1.95
R_x_PM_DLL_X1%7_r25 x_PM_DLL_X1%7_21 x_PM_DLL_X1%7_15 4.56151
R_x_PM_DLL_X1%7_r26 N_7_M7_g x_PM_DLL_X1%7_15 43.29
R_x_PM_DLL_X1%7_r27 x_PM_DLL_X1%7_21 x_PM_DLL_X1%7_11 4.56151
R_x_PM_DLL_X1%7_r28 N_7_M15_g x_PM_DLL_X1%7_11 31.98
R_x_PM_DLL_X1%7_r29 x_PM_DLL_X1%7_20 x_PM_DLL_X1%7_10 1.95
R_x_PM_DLL_X1%7_r30 x_PM_DLL_X1%7_21 x_PM_DLL_X1%7_9 0.043368
R_x_PM_DLL_X1%7_r31 x_PM_DLL_X1%7_10 x_PM_DLL_X1%7_9 14.56
R_x_PM_DLL_X1%7_r32 x_PM_DLL_X1%7_20 x_PM_DLL_X1%7_5 1.95
R_x_PM_DLL_X1%7_r33 N_7_M6_g x_PM_DLL_X1%7_5 39.78
R_x_PM_DLL_X1%7_r34 x_PM_DLL_X1%7_20 x_PM_DLL_X1%7_VSS 1.95
R_x_PM_DLL_X1%7_r35 N_7_M14_g x_PM_DLL_X1%7_VSS 31.98
C_x_PM_DLL_X1%8_c0 VSS N_8_M6_s 7.31254e-17
C_x_PM_DLL_X1%8_c1 VSS x_PM_DLL_X1%8_21 2.99825e-17
C_x_PM_DLL_X1%8_c2 VSS x_PM_DLL_X1%8_19 9.27363e-18
C_x_PM_DLL_X1%8_c3 VSS x_PM_DLL_X1%8_16 3.21426e-17
C_x_PM_DLL_X1%8_c4 VSS x_PM_DLL_X1%8_14 8.62106e-18
C_x_PM_DLL_X1%8_c5 VSS x_PM_DLL_X1%8_11 5.30706e-17
C_x_PM_DLL_X1%8_c6 VSS N_8_M13_g 2.16441e-17
C_x_PM_DLL_X1%8_c7 VSS N_8_M5_g 2.16594e-17
R_x_PM_DLL_X1%8_r8 N_8_M6_s x_PM_DLL_X1%8_22 0.035625
R_x_PM_DLL_X1%8_r9 N_8_M6_s x_PM_DLL_X1%8_21 2.41062
R_x_PM_DLL_X1%8_r10 x_PM_DLL_X1%8_30 x_PM_DLL_X1%8_19 4.7687
R_x_PM_DLL_X1%8_r11 x_PM_DLL_X1%8_19 x_PM_DLL_X1%8_17 25.0012
R_x_PM_DLL_X1%8_r12 x_PM_DLL_X1%8_17 x_PM_DLL_X1%8_16 0.51
R_x_PM_DLL_X1%8_r13 x_PM_DLL_X1%8_28 x_PM_DLL_X1%8_14 4.7687
R_x_PM_DLL_X1%8_r14 x_PM_DLL_X1%8_14 x_PM_DLL_X1%8_12 25.0012
R_x_PM_DLL_X1%8_r15 x_PM_DLL_X1%8_22 x_PM_DLL_X1%8_11 0.213547
R_x_PM_DLL_X1%8_r16 x_PM_DLL_X1%8_12 x_PM_DLL_X1%8_11 0.773571
R_x_PM_DLL_X1%8_r17 N_8_M14_s x_PM_DLL_X1%8_21 0.0857409
R_x_PM_DLL_X1%8_r18 N_8_M14_s x_PM_DLL_X1%8_16 0.128611
R_x_PM_DLL_X1%8_r19 N_8_M13_g x_PM_DLL_X1%8_30 14.82
R_x_PM_DLL_X1%8_r20 N_8_M5_g x_PM_DLL_X1%8_28 14.82
C_x_PM_DLL_X1%Q_c0 VSS N_Q_M15_d 7.18478e-17
R_x_PM_DLL_X1%Q_r1 N_Q_M7_d Q 1.68467
R_x_PM_DLL_X1%Q_r2 Q N_Q_M15_d 0.95
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   DLL_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT DLL_X2 VSS VDD GN D Q
*.PININFO VSS:B VDD:B GN:I D:I Q:O
M_M8 N_VDD_M0_d N_GN_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M9 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M10 10 N_D_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 N_7_M3_d N_5_M3_g 10 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 11 N_3_M4_g N_7_M3_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M13 N_VDD_M5_d N_8_M5_g 11 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M14 N_VDD_M6_d N_7_M6_g N_8_M6_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M15 N_Q_M7_d N_7_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M8_d N_GN_M8_g N_3_M8_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 12 N_D_M10_g N_VSS_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M11_d N_3_M11_g 12 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 13 N_5_M12_g N_7_M11_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 N_VSS_M13_d N_8_M13_g 13 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M14_d N_7_M14_g N_8_M14_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_Q_M15_d N_7_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_DLL_X2%VSS_c0 VSS x_PM_DLL_X2%VSS_32 4.04499e-17
C_x_PM_DLL_X2%VSS_c1 VSS x_PM_DLL_X2%VSS_30 4.6069e-18
C_x_PM_DLL_X2%VSS_c2 VSS x_PM_DLL_X2%VSS_25 6.78352e-17
C_x_PM_DLL_X2%VSS_c3 VSS N_VSS_M14_d 4.53187e-17
C_x_PM_DLL_X2%VSS_c4 VSS x_PM_DLL_X2%VSS_18 2.50827e-17
C_x_PM_DLL_X2%VSS_c5 VSS x_PM_DLL_X2%VSS_13 5.6374e-17
C_x_PM_DLL_X2%VSS_c6 VSS N_VSS_M10_s 2.74931e-17
C_x_PM_DLL_X2%VSS_c7 VSS x_PM_DLL_X2%VSS_7 2.95625e-17
R_x_PM_DLL_X2%VSS_r8 x_PM_DLL_X2%VSS_32 x_PM_DLL_X2%VSS_31 0.564412
R_x_PM_DLL_X2%VSS_r9 N_VSS_M8_d x_PM_DLL_X2%VSS_25 0.49963
R_x_PM_DLL_X2%VSS_r10 x_PM_DLL_X2%VSS_32 x_PM_DLL_X2%VSS_19 0.095
R_x_PM_DLL_X2%VSS_r11 N_VSS_M14_d x_PM_DLL_X2%VSS_19 1.83214
R_x_PM_DLL_X2%VSS_r12 x_PM_DLL_X2%VSS_31 x_PM_DLL_X2%VSS_18 0.095
R_x_PM_DLL_X2%VSS_r13 x_PM_DLL_X2%VSS_18 N_VSS_M13_d 0.403583
R_x_PM_DLL_X2%VSS_r14 x_PM_DLL_X2%VSS_30 x_PM_DLL_X2%VSS_14 0.0731438
R_x_PM_DLL_X2%VSS_r15 VSS x_PM_DLL_X2%VSS_14 0.681765
R_x_PM_DLL_X2%VSS_r16 x_PM_DLL_X2%VSS_31 x_PM_DLL_X2%VSS_13 0.150882
R_x_PM_DLL_X2%VSS_r17 VSS x_PM_DLL_X2%VSS_13 0.804706
R_x_PM_DLL_X2%VSS_r18 x_PM_DLL_X2%VSS_30 x_PM_DLL_X2%VSS_9 0.145286
R_x_PM_DLL_X2%VSS_r19 N_VSS_M10_s x_PM_DLL_X2%VSS_9 0.909286
R_x_PM_DLL_X2%VSS_r20 x_PM_DLL_X2%VSS_25 x_PM_DLL_X2%VSS_8 0.095
R_x_PM_DLL_X2%VSS_r21 x_PM_DLL_X2%VSS_30 x_PM_DLL_X2%VSS_7 0.0731438
R_x_PM_DLL_X2%VSS_r22 x_PM_DLL_X2%VSS_8 x_PM_DLL_X2%VSS_7 0.547647
C_x_PM_DLL_X2%VDD_c0 VSS x_PM_DLL_X2%VDD_30 4.32563e-17
C_x_PM_DLL_X2%VDD_c1 VSS x_PM_DLL_X2%VDD_28 4.6069e-18
C_x_PM_DLL_X2%VDD_c2 VSS x_PM_DLL_X2%VDD_27 5.42824e-18
C_x_PM_DLL_X2%VDD_c3 VSS N_VDD_M6_d 5.1382e-17
C_x_PM_DLL_X2%VDD_c4 VSS x_PM_DLL_X2%VDD_20 2.80123e-17
C_x_PM_DLL_X2%VDD_c5 VSS x_PM_DLL_X2%VDD_17 6.71907e-17
C_x_PM_DLL_X2%VDD_c6 VSS N_VDD_M2_s 3.12432e-17
C_x_PM_DLL_X2%VDD_c7 VSS x_PM_DLL_X2%VDD_11 2.24324e-17
C_x_PM_DLL_X2%VDD_c8 VSS x_PM_DLL_X2%VDD_10 3.44572e-17
C_x_PM_DLL_X2%VDD_c9 VSS x_PM_DLL_X2%VDD_5 2.04985e-17
R_x_PM_DLL_X2%VDD_r10 x_PM_DLL_X2%VDD_30 x_PM_DLL_X2%VDD_29 0.597941
R_x_PM_DLL_X2%VDD_r11 x_PM_DLL_X2%VDD_30 x_PM_DLL_X2%VDD_21 0.095
R_x_PM_DLL_X2%VDD_r12 N_VDD_M6_d x_PM_DLL_X2%VDD_21 1.83214
R_x_PM_DLL_X2%VDD_r13 x_PM_DLL_X2%VDD_29 x_PM_DLL_X2%VDD_20 0.095
R_x_PM_DLL_X2%VDD_r14 x_PM_DLL_X2%VDD_20 N_VDD_M5_d 0.403583
R_x_PM_DLL_X2%VDD_r15 x_PM_DLL_X2%VDD_28 x_PM_DLL_X2%VDD_18 0.0731438
R_x_PM_DLL_X2%VDD_r16 x_PM_DLL_X2%VDD_29 x_PM_DLL_X2%VDD_17 0.150882
R_x_PM_DLL_X2%VDD_r17 x_PM_DLL_X2%VDD_18 x_PM_DLL_X2%VDD_17 1.46412
R_x_PM_DLL_X2%VDD_r18 x_PM_DLL_X2%VDD_28 x_PM_DLL_X2%VDD_13 0.145286
R_x_PM_DLL_X2%VDD_r19 N_VDD_M2_s x_PM_DLL_X2%VDD_13 0.909286
R_x_PM_DLL_X2%VDD_r20 x_PM_DLL_X2%VDD_27 x_PM_DLL_X2%VDD_12 0.132285
R_x_PM_DLL_X2%VDD_r21 x_PM_DLL_X2%VDD_28 x_PM_DLL_X2%VDD_11 0.0731438
R_x_PM_DLL_X2%VDD_r22 x_PM_DLL_X2%VDD_12 x_PM_DLL_X2%VDD_11 0.547647
R_x_PM_DLL_X2%VDD_r23 x_PM_DLL_X2%VDD_27 x_PM_DLL_X2%VDD_10 0.0680382
R_x_PM_DLL_X2%VDD_r24 x_PM_DLL_X2%VDD_10 N_VDD_M0_d 0.670991
R_x_PM_DLL_X2%VDD_r25 x_PM_DLL_X2%VDD_27 x_PM_DLL_X2%VDD_5 0.132285
R_x_PM_DLL_X2%VDD_r26 VDD x_PM_DLL_X2%VDD_5 0.217941
C_x_PM_DLL_X2%3_c0 VSS x_PM_DLL_X2%3_43 1.26292e-17
C_x_PM_DLL_X2%3_c1 VSS N_3_M8_s 2.24095e-17
C_x_PM_DLL_X2%3_c2 VSS x_PM_DLL_X2%3_34 1.07543e-16
C_x_PM_DLL_X2%3_c3 VSS x_PM_DLL_X2%3_30 5.78446e-18
C_x_PM_DLL_X2%3_c4 VSS x_PM_DLL_X2%3_29 3.38957e-17
C_x_PM_DLL_X2%3_c5 VSS x_PM_DLL_X2%3_27 6.39346e-17
C_x_PM_DLL_X2%3_c6 VSS N_3_M0_s 2.54057e-17
C_x_PM_DLL_X2%3_c7 VSS N_3_M4_g 2.82378e-17
C_x_PM_DLL_X2%3_c8 VSS N_3_M11_g 3.53672e-17
C_x_PM_DLL_X2%3_c9 VSS x_PM_DLL_X2%3_12 5.20068e-18
C_x_PM_DLL_X2%3_c10 VSS x_PM_DLL_X2%3_11 8.83927e-17
C_x_PM_DLL_X2%3_c11 VSS x_PM_DLL_X2%3_10 6.92459e-18
C_x_PM_DLL_X2%3_c12 VSS x_PM_DLL_X2%3_9 6.31553e-17
C_x_PM_DLL_X2%3_c13 VSS N_3_M1_g 6.39022e-17
C_x_PM_DLL_X2%3_c14 VSS N_3_M9_g 5.6478e-17
R_x_PM_DLL_X2%3_r15 x_PM_DLL_X2%3_43 x_PM_DLL_X2%3_41 4.42
R_x_PM_DLL_X2%3_r16 x_PM_DLL_X2%3_39 N_3_M8_s 0.176429
R_x_PM_DLL_X2%3_r17 x_PM_DLL_X2%3_41 x_PM_DLL_X2%3_34 25.0012
R_x_PM_DLL_X2%3_r18 x_PM_DLL_X2%3_34 x_PM_DLL_X2%3_32 0.366429
R_x_PM_DLL_X2%3_r19 x_PM_DLL_X2%3_34 x_PM_DLL_X2%3_31 1.805
R_x_PM_DLL_X2%3_r20 x_PM_DLL_X2%3_32 x_PM_DLL_X2%3_29 0.212317
R_x_PM_DLL_X2%3_r21 x_PM_DLL_X2%3_30 x_PM_DLL_X2%3_29 0.895714
R_x_PM_DLL_X2%3_r22 x_PM_DLL_X2%3_39 x_PM_DLL_X2%3_28 0.095
R_x_PM_DLL_X2%3_r23 x_PM_DLL_X2%3_31 x_PM_DLL_X2%3_27 0.212317
R_x_PM_DLL_X2%3_r24 x_PM_DLL_X2%3_28 x_PM_DLL_X2%3_27 0.895714
R_x_PM_DLL_X2%3_r25 x_PM_DLL_X2%3_30 x_PM_DLL_X2%3_23 0.212317
R_x_PM_DLL_X2%3_r26 N_3_M0_s x_PM_DLL_X2%3_23 0.963571
R_x_PM_DLL_X2%3_r27 N_3_M4_g x_PM_DLL_X2%3_17 26.52
R_x_PM_DLL_X2%3_r28 N_3_M11_g x_PM_DLL_X2%3_13 33.54
R_x_PM_DLL_X2%3_r29 x_PM_DLL_X2%3_17 x_PM_DLL_X2%3_11 4.35808
R_x_PM_DLL_X2%3_r30 x_PM_DLL_X2%3_12 x_PM_DLL_X2%3_11 105.3
R_x_PM_DLL_X2%3_r31 x_PM_DLL_X2%3_13 x_PM_DLL_X2%3_9 4.35808
R_x_PM_DLL_X2%3_r32 x_PM_DLL_X2%3_10 x_PM_DLL_X2%3_9 74.88
R_x_PM_DLL_X2%3_r33 x_PM_DLL_X2%3_12 x_PM_DLL_X2%3_6 4.35808
R_x_PM_DLL_X2%3_r34 N_3_M1_g x_PM_DLL_X2%3_6 48.36
R_x_PM_DLL_X2%3_r35 x_PM_DLL_X2%3_43 x_PM_DLL_X2%3_5 1.95
R_x_PM_DLL_X2%3_r36 N_3_M1_g x_PM_DLL_X2%3_5 43.68
R_x_PM_DLL_X2%3_r37 x_PM_DLL_X2%3_43 x_PM_DLL_X2%3_2 1.95
R_x_PM_DLL_X2%3_r38 N_3_M9_g x_PM_DLL_X2%3_2 64.74
R_x_PM_DLL_X2%3_r39 x_PM_DLL_X2%3_10 x_PM_DLL_X2%3_VSS 4.35808
R_x_PM_DLL_X2%3_r40 N_3_M9_g x_PM_DLL_X2%3_VSS 21.84
C_x_PM_DLL_X2%GN_c0 VSS x_PM_DLL_X2%GN_14 7.47979e-18
C_x_PM_DLL_X2%GN_c1 VSS x_PM_DLL_X2%GN_12 6.51139e-17
C_x_PM_DLL_X2%GN_c2 VSS N_GN_M0_g 6.53652e-17
C_x_PM_DLL_X2%GN_c3 VSS N_GN_M8_g 3.89317e-17
R_x_PM_DLL_X2%GN_r4 x_PM_DLL_X2%GN_18 x_PM_DLL_X2%GN_14 4.7687
R_x_PM_DLL_X2%GN_r5 x_PM_DLL_X2%GN_17 x_PM_DLL_X2%GN_14 4.7687
R_x_PM_DLL_X2%GN_r6 x_PM_DLL_X2%GN_14 x_PM_DLL_X2%GN_12 25.0012
R_x_PM_DLL_X2%GN_r7 x_PM_DLL_X2%GN_12 GN 0.2375
R_x_PM_DLL_X2%GN_r8 N_GN_M0_g x_PM_DLL_X2%GN_18 67.08
R_x_PM_DLL_X2%GN_r9 N_GN_M8_g x_PM_DLL_X2%GN_17 34.32
C_x_PM_DLL_X2%5_c0 VSS x_PM_DLL_X2%5_21 8.39884e-17
C_x_PM_DLL_X2%5_c1 VSS x_PM_DLL_X2%5_17 6.49819e-17
C_x_PM_DLL_X2%5_c2 VSS N_5_M9_d 1.36391e-16
C_x_PM_DLL_X2%5_c3 VSS x_PM_DLL_X2%5_13 8.2321e-18
C_x_PM_DLL_X2%5_c4 VSS N_5_M12_g 5.09254e-17
C_x_PM_DLL_X2%5_c5 VSS x_PM_DLL_X2%5_5 2.76398e-17
C_x_PM_DLL_X2%5_c6 VSS N_5_M3_g 5.62248e-17
C_x_PM_DLL_X2%5_c7 VSS x_PM_DLL_X2%5_VSS 6.91011e-18
R_x_PM_DLL_X2%5_r8 x_PM_DLL_X2%5_22 x_PM_DLL_X2%5_21 25.0012
R_x_PM_DLL_X2%5_r9 x_PM_DLL_X2%5_21 x_PM_DLL_X2%5_19 1.50643
R_x_PM_DLL_X2%5_r10 N_5_M1_d x_PM_DLL_X2%5_18 0.198162
R_x_PM_DLL_X2%5_r11 x_PM_DLL_X2%5_19 x_PM_DLL_X2%5_17 0.212317
R_x_PM_DLL_X2%5_r12 x_PM_DLL_X2%5_18 x_PM_DLL_X2%5_17 1.92714
R_x_PM_DLL_X2%5_r13 N_5_M1_d x_PM_DLL_X2%5_13 0.0141545
R_x_PM_DLL_X2%5_r14 N_5_M9_d x_PM_DLL_X2%5_13 3.59643
R_x_PM_DLL_X2%5_r15 N_5_M12_g x_PM_DLL_X2%5_7 57.72
R_x_PM_DLL_X2%5_r16 x_PM_DLL_X2%5_22 x_PM_DLL_X2%5_6 1.96659
R_x_PM_DLL_X2%5_r17 x_PM_DLL_X2%5_7 x_PM_DLL_X2%5_5 4.58872
R_x_PM_DLL_X2%5_r18 x_PM_DLL_X2%5_6 x_PM_DLL_X2%5_5 15.6
R_x_PM_DLL_X2%5_r19 x_PM_DLL_X2%5_22 x_PM_DLL_X2%5_VSS 2.62213
R_x_PM_DLL_X2%5_r20 N_5_M3_g x_PM_DLL_X2%5_VSS 53.82
C_x_PM_DLL_X2%D_c0 VSS x_PM_DLL_X2%D_14 7.73588e-18
C_x_PM_DLL_X2%D_c1 VSS x_PM_DLL_X2%D_12 5.62824e-17
C_x_PM_DLL_X2%D_c2 VSS N_D_M2_g 5.25891e-17
C_x_PM_DLL_X2%D_c3 VSS N_D_M10_g 5.96926e-17
R_x_PM_DLL_X2%D_r4 x_PM_DLL_X2%D_18 x_PM_DLL_X2%D_14 4.7687
R_x_PM_DLL_X2%D_r5 x_PM_DLL_X2%D_17 x_PM_DLL_X2%D_14 4.7687
R_x_PM_DLL_X2%D_r6 x_PM_DLL_X2%D_14 x_PM_DLL_X2%D_12 25.0012
R_x_PM_DLL_X2%D_r7 x_PM_DLL_X2%D_12 D 0.128929
R_x_PM_DLL_X2%D_r8 N_D_M2_g x_PM_DLL_X2%D_18 43.68
R_x_PM_DLL_X2%D_r9 N_D_M10_g x_PM_DLL_X2%D_17 60.84
C_x_PM_DLL_X2%7_c0 VSS x_PM_DLL_X2%7_39 3.91679e-17
C_x_PM_DLL_X2%7_c1 VSS N_7_M3_d 2.59806e-17
C_x_PM_DLL_X2%7_c2 VSS N_7_M11_d 2.11419e-17
C_x_PM_DLL_X2%7_c3 VSS x_PM_DLL_X2%7_30 5.36307e-17
C_x_PM_DLL_X2%7_c4 VSS x_PM_DLL_X2%7_27 5.68076e-17
C_x_PM_DLL_X2%7_c5 VSS x_PM_DLL_X2%7_25 2.13235e-17
C_x_PM_DLL_X2%7_c6 VSS x_PM_DLL_X2%7_21 6.80144e-18
C_x_PM_DLL_X2%7_c7 VSS x_PM_DLL_X2%7_20 6.72026e-19
C_x_PM_DLL_X2%7_c8 VSS x_PM_DLL_X2%7_19 3.52816e-17
C_x_PM_DLL_X2%7_c9 VSS N_7_M7_g 5.49006e-17
C_x_PM_DLL_X2%7_c10 VSS N_7_M15_g 4.29348e-17
C_x_PM_DLL_X2%7_c11 VSS x_PM_DLL_X2%7_9 7.72963e-18
C_x_PM_DLL_X2%7_c12 VSS N_7_M6_g 2.86032e-17
C_x_PM_DLL_X2%7_c13 VSS N_7_M14_g 2.78391e-17
R_x_PM_DLL_X2%7_r14 x_PM_DLL_X2%7_39 x_PM_DLL_X2%7_30 0.0272847
R_x_PM_DLL_X2%7_r15 x_PM_DLL_X2%7_30 x_PM_DLL_X2%7_28 0.53025
R_x_PM_DLL_X2%7_r16 x_PM_DLL_X2%7_40 x_PM_DLL_X2%7_28 25.0012
R_x_PM_DLL_X2%7_r17 x_PM_DLL_X2%7_27 N_7_M3_d 0.30478
R_x_PM_DLL_X2%7_r18 x_PM_DLL_X2%7_39 x_PM_DLL_X2%7_26 0.266978
R_x_PM_DLL_X2%7_r19 x_PM_DLL_X2%7_27 x_PM_DLL_X2%7_26 1.65571
R_x_PM_DLL_X2%7_r20 x_PM_DLL_X2%7_39 x_PM_DLL_X2%7_25 0.266978
R_x_PM_DLL_X2%7_r21 x_PM_DLL_X2%7_24 N_7_M11_d 0.29113
R_x_PM_DLL_X2%7_r22 x_PM_DLL_X2%7_25 x_PM_DLL_X2%7_24 1.11286
R_x_PM_DLL_X2%7_r23 x_PM_DLL_X2%7_40 x_PM_DLL_X2%7_19 25.74
R_x_PM_DLL_X2%7_r24 x_PM_DLL_X2%7_20 x_PM_DLL_X2%7_19 1.95
R_x_PM_DLL_X2%7_r25 x_PM_DLL_X2%7_21 x_PM_DLL_X2%7_15 4.56151
R_x_PM_DLL_X2%7_r26 N_7_M7_g x_PM_DLL_X2%7_15 50.7
R_x_PM_DLL_X2%7_r27 x_PM_DLL_X2%7_21 x_PM_DLL_X2%7_11 4.56151
R_x_PM_DLL_X2%7_r28 N_7_M15_g x_PM_DLL_X2%7_11 42.9
R_x_PM_DLL_X2%7_r29 x_PM_DLL_X2%7_20 x_PM_DLL_X2%7_10 1.95
R_x_PM_DLL_X2%7_r30 x_PM_DLL_X2%7_21 x_PM_DLL_X2%7_9 0.043368
R_x_PM_DLL_X2%7_r31 x_PM_DLL_X2%7_10 x_PM_DLL_X2%7_9 14.56
R_x_PM_DLL_X2%7_r32 x_PM_DLL_X2%7_20 x_PM_DLL_X2%7_5 1.95
R_x_PM_DLL_X2%7_r33 N_7_M6_g x_PM_DLL_X2%7_5 36.66
R_x_PM_DLL_X2%7_r34 x_PM_DLL_X2%7_20 x_PM_DLL_X2%7_VSS 1.95
R_x_PM_DLL_X2%7_r35 N_7_M14_g x_PM_DLL_X2%7_VSS 35.88
C_x_PM_DLL_X2%8_c0 VSS x_PM_DLL_X2%8_22 9.66029e-17
C_x_PM_DLL_X2%8_c1 VSS x_PM_DLL_X2%8_21 2.21626e-17
C_x_PM_DLL_X2%8_c2 VSS x_PM_DLL_X2%8_19 9.49901e-18
C_x_PM_DLL_X2%8_c3 VSS x_PM_DLL_X2%8_16 1.57449e-17
C_x_PM_DLL_X2%8_c4 VSS x_PM_DLL_X2%8_14 8.50908e-18
C_x_PM_DLL_X2%8_c5 VSS x_PM_DLL_X2%8_11 1.95813e-17
C_x_PM_DLL_X2%8_c6 VSS N_8_M13_g 2.49864e-17
C_x_PM_DLL_X2%8_c7 VSS N_8_M5_g 2.42933e-17
R_x_PM_DLL_X2%8_r8 N_8_M6_s x_PM_DLL_X2%8_22 0.0841861
R_x_PM_DLL_X2%8_r9 x_PM_DLL_X2%8_22 x_PM_DLL_X2%8_21 1.32296
R_x_PM_DLL_X2%8_r10 x_PM_DLL_X2%8_29 x_PM_DLL_X2%8_19 4.7687
R_x_PM_DLL_X2%8_r11 x_PM_DLL_X2%8_19 x_PM_DLL_X2%8_17 25.0012
R_x_PM_DLL_X2%8_r12 x_PM_DLL_X2%8_17 x_PM_DLL_X2%8_16 0.420714
R_x_PM_DLL_X2%8_r13 x_PM_DLL_X2%8_27 x_PM_DLL_X2%8_14 4.7687
R_x_PM_DLL_X2%8_r14 x_PM_DLL_X2%8_14 x_PM_DLL_X2%8_12 25.0012
R_x_PM_DLL_X2%8_r15 N_8_M6_s x_PM_DLL_X2%8_11 0.157147
R_x_PM_DLL_X2%8_r16 x_PM_DLL_X2%8_12 x_PM_DLL_X2%8_11 0.556429
R_x_PM_DLL_X2%8_r17 N_8_M14_s x_PM_DLL_X2%8_21 0.0841861
R_x_PM_DLL_X2%8_r18 N_8_M14_s x_PM_DLL_X2%8_16 0.157147
R_x_PM_DLL_X2%8_r19 N_8_M13_g x_PM_DLL_X2%8_29 21.06
R_x_PM_DLL_X2%8_r20 N_8_M5_g x_PM_DLL_X2%8_27 19.5
C_x_PM_DLL_X2%Q_c0 VSS N_Q_M15_d 1.08384e-16
R_x_PM_DLL_X2%Q_r1 N_Q_M7_d Q 1.57938
R_x_PM_DLL_X2%Q_r2 Q N_Q_M15_d 2.00688
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FA_X1 VSS VDD CO B A CI S
*.PININFO VSS:B VDD:B CO:O B:I A:I CI:I S:O
M_M14 N_VDD_M0_d N_4_M0_g N_CO_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M15 14 N_B_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M16 N_4_M2_d N_A_M2_g 14 VDD PMOS_VTL W=0.200000U L=0.050000U
M_M17 N_8_M3_d N_CI_M3_g N_4_M2_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M18 N_VDD_M4_d N_B_M4_g N_8_M3_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M19 N_8_M5_d N_A_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M20 15 N_A_M6_g N_VDD_M6_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M21 16 N_B_M7_g 15 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M22 N_10_M8_d N_CI_M8_g 16 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M23 N_11_M9_d N_4_M9_g N_10_M8_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M24 N_VDD_M10_d N_CI_M10_g N_11_M9_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M25 N_11_M11_d N_A_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M26 N_VDD_M12_d N_B_M12_g N_11_M11_d VDD PMOS_VTL W=0.200000U L=0.050000U
M_M27 N_S_M13_d N_10_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M14_d N_4_M14_g N_CO_M14_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 17 N_B_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_4_M16_d N_A_M16_g 17 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_9_M17_d N_CI_M17_g N_4_M16_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_VSS_M18_d N_B_M18_g N_9_M17_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M5 N_9_M19_d N_A_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M6 18 N_A_M20_g N_VSS_M20_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M7 19 N_B_M21_g 18 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M8 N_10_M22_d N_CI_M22_g 19 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M9 N_12_M23_d N_4_M23_g N_10_M22_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M10 N_VSS_M24_d N_CI_M24_g N_12_M23_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M11 N_12_M25_d N_A_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M12 N_VSS_M26_d N_B_M26_g N_12_M25_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M13 N_S_M27_d N_10_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_FA_X1%VSS_c0 VSS x_PM_FA_X1%VSS_44 2.69495e-17
C_x_PM_FA_X1%VSS_c1 VSS x_PM_FA_X1%VSS_43 8.93987e-18
C_x_PM_FA_X1%VSS_c2 VSS x_PM_FA_X1%VSS_42 2.95558e-18
C_x_PM_FA_X1%VSS_c3 VSS x_PM_FA_X1%VSS_41 2.84978e-18
C_x_PM_FA_X1%VSS_c4 VSS x_PM_FA_X1%VSS_40 3.98113e-17
C_x_PM_FA_X1%VSS_c5 VSS N_VSS_M26_d 3.54827e-17
C_x_PM_FA_X1%VSS_c6 VSS x_PM_FA_X1%VSS_32 2.48602e-17
C_x_PM_FA_X1%VSS_c7 VSS N_VSS_M24_d 6.58479e-17
C_x_PM_FA_X1%VSS_c8 VSS x_PM_FA_X1%VSS_24 8.43469e-17
C_x_PM_FA_X1%VSS_c9 VSS N_VSS_M20_s 4.02345e-17
C_x_PM_FA_X1%VSS_c10 VSS x_PM_FA_X1%VSS_18 3.31957e-17
C_x_PM_FA_X1%VSS_c11 VSS N_VSS_M18_d 3.45004e-17
C_x_PM_FA_X1%VSS_c12 VSS x_PM_FA_X1%VSS_12 7.54338e-17
C_x_PM_FA_X1%VSS_c13 VSS N_VSS_M14_d 4.12464e-17
R_x_PM_FA_X1%VSS_r14 x_PM_FA_X1%VSS_44 x_PM_FA_X1%VSS_34 0.145286
R_x_PM_FA_X1%VSS_r15 N_VSS_M26_d x_PM_FA_X1%VSS_34 1.58786
R_x_PM_FA_X1%VSS_r16 x_PM_FA_X1%VSS_43 x_PM_FA_X1%VSS_33 0.132285
R_x_PM_FA_X1%VSS_r17 x_PM_FA_X1%VSS_44 x_PM_FA_X1%VSS_32 0.0731438
R_x_PM_FA_X1%VSS_r18 x_PM_FA_X1%VSS_33 x_PM_FA_X1%VSS_32 0.614706
R_x_PM_FA_X1%VSS_r19 x_PM_FA_X1%VSS_43 x_PM_FA_X1%VSS_28 0.0680382
R_x_PM_FA_X1%VSS_r20 N_VSS_M24_d x_PM_FA_X1%VSS_28 0.823333
R_x_PM_FA_X1%VSS_r21 x_PM_FA_X1%VSS_42 x_PM_FA_X1%VSS_25 0.0731438
R_x_PM_FA_X1%VSS_r22 VSS x_PM_FA_X1%VSS_25 0.122941
R_x_PM_FA_X1%VSS_r23 x_PM_FA_X1%VSS_43 x_PM_FA_X1%VSS_24 0.132285
R_x_PM_FA_X1%VSS_r24 VSS x_PM_FA_X1%VSS_24 1.77706
R_x_PM_FA_X1%VSS_r25 x_PM_FA_X1%VSS_42 x_PM_FA_X1%VSS_20 0.145286
R_x_PM_FA_X1%VSS_r26 N_VSS_M20_s x_PM_FA_X1%VSS_20 1.18071
R_x_PM_FA_X1%VSS_r27 x_PM_FA_X1%VSS_41 x_PM_FA_X1%VSS_19 0.0731438
R_x_PM_FA_X1%VSS_r28 x_PM_FA_X1%VSS_42 x_PM_FA_X1%VSS_18 0.0731438
R_x_PM_FA_X1%VSS_r29 x_PM_FA_X1%VSS_19 x_PM_FA_X1%VSS_18 0.715294
R_x_PM_FA_X1%VSS_r30 x_PM_FA_X1%VSS_41 x_PM_FA_X1%VSS_14 0.145286
R_x_PM_FA_X1%VSS_r31 N_VSS_M18_d x_PM_FA_X1%VSS_14 0.420714
R_x_PM_FA_X1%VSS_r32 x_PM_FA_X1%VSS_40 x_PM_FA_X1%VSS_13 0.132285
R_x_PM_FA_X1%VSS_r33 x_PM_FA_X1%VSS_41 x_PM_FA_X1%VSS_12 0.0731438
R_x_PM_FA_X1%VSS_r34 x_PM_FA_X1%VSS_13 x_PM_FA_X1%VSS_12 1.45294
R_x_PM_FA_X1%VSS_r35 x_PM_FA_X1%VSS_40 x_PM_FA_X1%VSS_8 0.0680382
R_x_PM_FA_X1%VSS_r36 N_VSS_M14_d x_PM_FA_X1%VSS_8 0.330741
C_x_PM_FA_X1%VDD_c0 VSS x_PM_FA_X1%VDD_40 2.72767e-17
C_x_PM_FA_X1%VDD_c1 VSS x_PM_FA_X1%VDD_39 8.91963e-18
C_x_PM_FA_X1%VDD_c2 VSS x_PM_FA_X1%VDD_38 6.33099e-18
C_x_PM_FA_X1%VDD_c3 VSS N_VDD_M4_d 4.23042e-17
C_x_PM_FA_X1%VDD_c4 VSS x_PM_FA_X1%VDD_32 2.82055e-18
C_x_PM_FA_X1%VDD_c5 VSS N_VDD_M12_d 3.012e-17
C_x_PM_FA_X1%VDD_c6 VSS x_PM_FA_X1%VDD_24 1.88571e-17
C_x_PM_FA_X1%VDD_c7 VSS x_PM_FA_X1%VDD_23 5.657e-17
C_x_PM_FA_X1%VDD_c8 VSS x_PM_FA_X1%VDD_20 1.09287e-16
C_x_PM_FA_X1%VDD_c9 VSS x_PM_FA_X1%VDD_19 3.89131e-17
C_x_PM_FA_X1%VDD_c10 VSS x_PM_FA_X1%VDD_16 2.6565e-17
C_x_PM_FA_X1%VDD_c11 VSS x_PM_FA_X1%VDD_14 6.43448e-17
C_x_PM_FA_X1%VDD_c12 VSS N_VDD_M0_d 2.02345e-17
C_x_PM_FA_X1%VDD_c13 VSS x_PM_FA_X1%VDD_6 3.65469e-17
R_x_PM_FA_X1%VDD_r14 x_PM_FA_X1%VDD_36 N_VDD_M4_d 0.443333
R_x_PM_FA_X1%VDD_r15 x_PM_FA_X1%VDD_40 x_PM_FA_X1%VDD_26 0.145286
R_x_PM_FA_X1%VDD_r16 N_VDD_M12_d x_PM_FA_X1%VDD_26 1.39786
R_x_PM_FA_X1%VDD_r17 x_PM_FA_X1%VDD_39 x_PM_FA_X1%VDD_25 0.132285
R_x_PM_FA_X1%VDD_r18 x_PM_FA_X1%VDD_40 x_PM_FA_X1%VDD_24 0.0731438
R_x_PM_FA_X1%VDD_r19 x_PM_FA_X1%VDD_25 x_PM_FA_X1%VDD_24 0.614706
R_x_PM_FA_X1%VDD_r20 x_PM_FA_X1%VDD_39 x_PM_FA_X1%VDD_23 0.0680382
R_x_PM_FA_X1%VDD_r21 x_PM_FA_X1%VDD_23 N_VDD_M10_d 0.656916
R_x_PM_FA_X1%VDD_r22 x_PM_FA_X1%VDD_38 x_PM_FA_X1%VDD_21 0.132285
R_x_PM_FA_X1%VDD_r23 x_PM_FA_X1%VDD_39 x_PM_FA_X1%VDD_20 0.132285
R_x_PM_FA_X1%VDD_r24 x_PM_FA_X1%VDD_21 x_PM_FA_X1%VDD_20 1.82176
R_x_PM_FA_X1%VDD_r25 x_PM_FA_X1%VDD_38 x_PM_FA_X1%VDD_19 0.0680382
R_x_PM_FA_X1%VDD_r26 x_PM_FA_X1%VDD_19 N_VDD_M6_s 0.403583
R_x_PM_FA_X1%VDD_r27 x_PM_FA_X1%VDD_36 x_PM_FA_X1%VDD_17 0.095
R_x_PM_FA_X1%VDD_r28 x_PM_FA_X1%VDD_38 x_PM_FA_X1%VDD_16 0.132285
R_x_PM_FA_X1%VDD_r29 x_PM_FA_X1%VDD_17 x_PM_FA_X1%VDD_16 0.57
R_x_PM_FA_X1%VDD_r30 x_PM_FA_X1%VDD_32 x_PM_FA_X1%VDD_15 0.0731438
R_x_PM_FA_X1%VDD_r31 x_PM_FA_X1%VDD_36 x_PM_FA_X1%VDD_14 0.095
R_x_PM_FA_X1%VDD_r32 x_PM_FA_X1%VDD_15 x_PM_FA_X1%VDD_14 1.46412
R_x_PM_FA_X1%VDD_r33 x_PM_FA_X1%VDD_32 x_PM_FA_X1%VDD_10 0.145286
R_x_PM_FA_X1%VDD_r34 N_VDD_M0_d x_PM_FA_X1%VDD_10 0.393571
R_x_PM_FA_X1%VDD_r35 x_PM_FA_X1%VDD_32 x_PM_FA_X1%VDD_6 0.0731438
R_x_PM_FA_X1%VDD_r36 VDD x_PM_FA_X1%VDD_6 0.279412
C_x_PM_FA_X1%CO_c0 VSS N_CO_M14_s 2.09795e-16
R_x_PM_FA_X1%CO_r1 N_CO_M0_s CO 2.99929
R_x_PM_FA_X1%CO_r2 CO N_CO_M14_s 2.23929
C_x_PM_FA_X1%4_c0 VSS x_PM_FA_X1%4_51 1.20876e-17
C_x_PM_FA_X1%4_c1 VSS x_PM_FA_X1%4_41 2.76336e-17
C_x_PM_FA_X1%4_c2 VSS x_PM_FA_X1%4_40 3.52414e-18
C_x_PM_FA_X1%4_c3 VSS x_PM_FA_X1%4_39 2.12141e-17
C_x_PM_FA_X1%4_c4 VSS x_PM_FA_X1%4_38 5.51696e-17
C_x_PM_FA_X1%4_c5 VSS x_PM_FA_X1%4_37 1.07419e-17
C_x_PM_FA_X1%4_c6 VSS x_PM_FA_X1%4_34 2.48156e-16
C_x_PM_FA_X1%4_c7 VSS N_4_M2_d 2.95407e-17
C_x_PM_FA_X1%4_c8 VSS N_4_M16_d 3.67376e-17
C_x_PM_FA_X1%4_c9 VSS x_PM_FA_X1%4_25 2.75072e-17
C_x_PM_FA_X1%4_c10 VSS x_PM_FA_X1%4_24 3.0353e-17
C_x_PM_FA_X1%4_c11 VSS x_PM_FA_X1%4_23 2.72588e-17
C_x_PM_FA_X1%4_c12 VSS x_PM_FA_X1%4_22 9.87957e-17
C_x_PM_FA_X1%4_c13 VSS x_PM_FA_X1%4_21 1.20853e-17
C_x_PM_FA_X1%4_c14 VSS x_PM_FA_X1%4_19 1.29414e-16
C_x_PM_FA_X1%4_c15 VSS N_4_M23_g 8.8107e-17
C_x_PM_FA_X1%4_c16 VSS N_4_M0_g 9.75663e-17
C_x_PM_FA_X1%4_c17 VSS N_4_M14_g 3.05523e-17
R_x_PM_FA_X1%4_r18 x_PM_FA_X1%4_51 x_PM_FA_X1%4_44 25.0012
R_x_PM_FA_X1%4_r19 x_PM_FA_X1%4_44 x_PM_FA_X1%4_41 0.285
R_x_PM_FA_X1%4_r20 x_PM_FA_X1%4_41 x_PM_FA_X1%4_38 0.095
R_x_PM_FA_X1%4_r21 x_PM_FA_X1%4_39 x_PM_FA_X1%4_38 2.25286
R_x_PM_FA_X1%4_r22 x_PM_FA_X1%4_39 x_PM_FA_X1%4_37 0.212317
R_x_PM_FA_X1%4_r23 x_PM_FA_X1%4_37 x_PM_FA_X1%4_36 0.651429
R_x_PM_FA_X1%4_r24 x_PM_FA_X1%4_40 x_PM_FA_X1%4_35 0.160909
R_x_PM_FA_X1%4_r25 x_PM_FA_X1%4_36 x_PM_FA_X1%4_34 0.212317
R_x_PM_FA_X1%4_r26 x_PM_FA_X1%4_35 x_PM_FA_X1%4_34 4.72286
R_x_PM_FA_X1%4_r27 x_PM_FA_X1%4_40 x_PM_FA_X1%4_30 0.0418175
R_x_PM_FA_X1%4_r28 N_4_M2_d x_PM_FA_X1%4_30 0.773571
R_x_PM_FA_X1%4_r29 N_4_M16_d x_PM_FA_X1%4_26 0.583571
R_x_PM_FA_X1%4_r30 x_PM_FA_X1%4_40 x_PM_FA_X1%4_24 0.160909
R_x_PM_FA_X1%4_r31 x_PM_FA_X1%4_25 x_PM_FA_X1%4_24 1.95429
R_x_PM_FA_X1%4_r32 x_PM_FA_X1%4_26 x_PM_FA_X1%4_22 0.212317
R_x_PM_FA_X1%4_r33 x_PM_FA_X1%4_23 x_PM_FA_X1%4_22 1.95429
R_x_PM_FA_X1%4_r34 x_PM_FA_X1%4_21 x_PM_FA_X1%4_47 3.9
R_x_PM_FA_X1%4_r35 x_PM_FA_X1%4_21 x_PM_FA_X1%4_19 25.0012
R_x_PM_FA_X1%4_r36 x_PM_FA_X1%4_25 x_PM_FA_X1%4_18 0.212317
R_x_PM_FA_X1%4_r37 x_PM_FA_X1%4_19 x_PM_FA_X1%4_18 2.755
R_x_PM_FA_X1%4_r38 x_PM_FA_X1%4_23 x_PM_FA_X1%4_17 0.212317
R_x_PM_FA_X1%4_r39 x_PM_FA_X1%4_19 x_PM_FA_X1%4_17 0.0135714
R_x_PM_FA_X1%4_r40 N_4_M9_g N_4_M23_g 92.04
R_x_PM_FA_X1%4_r41 x_PM_FA_X1%4_9 x_PM_FA_X1%4_51 4.7687
R_x_PM_FA_X1%4_r42 N_4_M9_g x_PM_FA_X1%4_9 23.4
R_x_PM_FA_X1%4_r43 x_PM_FA_X1%4_47 x_PM_FA_X1%4_5 1.95
R_x_PM_FA_X1%4_r44 N_4_M0_g x_PM_FA_X1%4_5 121.29
R_x_PM_FA_X1%4_r45 x_PM_FA_X1%4_47 x_PM_FA_X1%4_VSS 1.95
R_x_PM_FA_X1%4_r46 N_4_M14_g x_PM_FA_X1%4_VSS 23.4
C_x_PM_FA_X1%B_c0 VSS x_PM_FA_X1%B_48 8.30893e-18
C_x_PM_FA_X1%B_c1 VSS x_PM_FA_X1%B_46 1.76183e-17
C_x_PM_FA_X1%B_c2 VSS x_PM_FA_X1%B_45 3.32618e-16
C_x_PM_FA_X1%B_c3 VSS x_PM_FA_X1%B_41 3.23931e-17
C_x_PM_FA_X1%B_c4 VSS x_PM_FA_X1%B_40 8.42442e-18
C_x_PM_FA_X1%B_c5 VSS x_PM_FA_X1%B_36 8.91632e-18
C_x_PM_FA_X1%B_c6 VSS N_B_M26_g 1.12623e-16
C_x_PM_FA_X1%B_c7 VSS x_PM_FA_X1%B_26 6.59745e-18
C_x_PM_FA_X1%B_c8 VSS x_PM_FA_X1%B_25 1.22036e-16
C_x_PM_FA_X1%B_c9 VSS N_B_M7_g 7.38692e-17
C_x_PM_FA_X1%B_c10 VSS N_B_M21_g 3.69683e-17
C_x_PM_FA_X1%B_c11 VSS N_B_M4_g 9.14736e-17
C_x_PM_FA_X1%B_c12 VSS N_B_M18_g 4.17422e-17
C_x_PM_FA_X1%B_c13 VSS N_B_M1_g 8.16428e-17
C_x_PM_FA_X1%B_c14 VSS N_B_M15_g 4.21704e-17
R_x_PM_FA_X1%B_r15 x_PM_FA_X1%B_58 x_PM_FA_X1%B_48 4.7687
R_x_PM_FA_X1%B_r16 x_PM_FA_X1%B_57 x_PM_FA_X1%B_48 4.7687
R_x_PM_FA_X1%B_r17 x_PM_FA_X1%B_48 x_PM_FA_X1%B_46 25.0012
R_x_PM_FA_X1%B_r18 x_PM_FA_X1%B_46 x_PM_FA_X1%B_44 0.246296
R_x_PM_FA_X1%B_r19 x_PM_FA_X1%B_45 x_PM_FA_X1%B_44 0.186267
R_x_PM_FA_X1%B_r20 x_PM_FA_X1%B_44 x_PM_FA_X1%B_41 0.095
R_x_PM_FA_X1%B_r21 B x_PM_FA_X1%B_41 0.19
R_x_PM_FA_X1%B_r22 x_PM_FA_X1%B_55 x_PM_FA_X1%B_40 4.7687
R_x_PM_FA_X1%B_r23 x_PM_FA_X1%B_54 x_PM_FA_X1%B_40 4.7687
R_x_PM_FA_X1%B_r24 x_PM_FA_X1%B_40 x_PM_FA_X1%B_38 25.0012
R_x_PM_FA_X1%B_r25 x_PM_FA_X1%B_38 x_PM_FA_X1%B_45 3.35214
R_x_PM_FA_X1%B_r26 x_PM_FA_X1%B_52 x_PM_FA_X1%B_36 4.74714
R_x_PM_FA_X1%B_r27 x_PM_FA_X1%B_51 x_PM_FA_X1%B_36 4.74714
R_x_PM_FA_X1%B_r28 x_PM_FA_X1%B_36 x_PM_FA_X1%B_34 25.0012
R_x_PM_FA_X1%B_r29 x_PM_FA_X1%B_38 x_PM_FA_X1%B_34 3.06714
R_x_PM_FA_X1%B_r30 N_B_M12_g N_B_M26_g 92.04
R_x_PM_FA_X1%B_r31 N_B_M26_g x_PM_FA_X1%B_27 49.14
R_x_PM_FA_X1%B_r32 x_PM_FA_X1%B_27 x_PM_FA_X1%B_25 4.35808
R_x_PM_FA_X1%B_r33 x_PM_FA_X1%B_26 x_PM_FA_X1%B_25 141.18
R_x_PM_FA_X1%B_r34 N_B_M7_g x_PM_FA_X1%B_58 76.44
R_x_PM_FA_X1%B_r35 N_B_M21_g x_PM_FA_X1%B_57 21.84
R_x_PM_FA_X1%B_r36 x_PM_FA_X1%B_26 x_PM_FA_X1%B_17 4.35808
R_x_PM_FA_X1%B_r37 N_B_M21_g x_PM_FA_X1%B_17 40.56
R_x_PM_FA_X1%B_r38 N_B_M4_g x_PM_FA_X1%B_55 101.4
R_x_PM_FA_X1%B_r39 N_B_M18_g x_PM_FA_X1%B_54 41.34
R_x_PM_FA_X1%B_r40 N_B_M1_g x_PM_FA_X1%B_52 101.4
R_x_PM_FA_X1%B_r41 N_B_M15_g x_PM_FA_X1%B_51 41.34
C_x_PM_FA_X1%A_c0 VSS x_PM_FA_X1%A_43 2.85347e-16
C_x_PM_FA_X1%A_c1 VSS x_PM_FA_X1%A_39 8.58968e-18
C_x_PM_FA_X1%A_c2 VSS x_PM_FA_X1%A_36 4.73094e-18
C_x_PM_FA_X1%A_c3 VSS x_PM_FA_X1%A_35 2.85945e-17
C_x_PM_FA_X1%A_c4 VSS x_PM_FA_X1%A_34 3.12566e-18
C_x_PM_FA_X1%A_c5 VSS N_A_M25_g 1.15097e-16
C_x_PM_FA_X1%A_c6 VSS x_PM_FA_X1%A_26 5.14031e-18
C_x_PM_FA_X1%A_c7 VSS x_PM_FA_X1%A_25 1.14609e-16
C_x_PM_FA_X1%A_c8 VSS N_A_M6_g 6.67281e-17
C_x_PM_FA_X1%A_c9 VSS N_A_M20_g 4.28674e-17
C_x_PM_FA_X1%A_c10 VSS N_A_M5_g 7.62413e-17
C_x_PM_FA_X1%A_c11 VSS N_A_M19_g 6.05798e-17
C_x_PM_FA_X1%A_c12 VSS N_A_M2_g 6.94772e-17
C_x_PM_FA_X1%A_c13 VSS N_A_M16_g 5.92311e-17
R_x_PM_FA_X1%A_r14 x_PM_FA_X1%A_45 x_PM_FA_X1%A_43 25.0012
R_x_PM_FA_X1%A_r15 x_PM_FA_X1%A_43 A 2.185
R_x_PM_FA_X1%A_r16 x_PM_FA_X1%A_50 x_PM_FA_X1%A_39 4.7687
R_x_PM_FA_X1%A_r17 x_PM_FA_X1%A_49 x_PM_FA_X1%A_39 4.7687
R_x_PM_FA_X1%A_r18 x_PM_FA_X1%A_39 x_PM_FA_X1%A_37 25.0012
R_x_PM_FA_X1%A_r19 A x_PM_FA_X1%A_37 2.51071
R_x_PM_FA_X1%A_r20 x_PM_FA_X1%A_45 x_PM_FA_X1%A_35 5.46
R_x_PM_FA_X1%A_r21 x_PM_FA_X1%A_36 x_PM_FA_X1%A_35 0.043368
R_x_PM_FA_X1%A_r22 x_PM_FA_X1%A_45 x_PM_FA_X1%A_33 29.38
R_x_PM_FA_X1%A_r23 x_PM_FA_X1%A_34 x_PM_FA_X1%A_33 0.043368
R_x_PM_FA_X1%A_r24 N_A_M11_g N_A_M25_g 92.04
R_x_PM_FA_X1%A_r25 N_A_M11_g x_PM_FA_X1%A_27 49.14
R_x_PM_FA_X1%A_r26 x_PM_FA_X1%A_27 x_PM_FA_X1%A_25 4.35808
R_x_PM_FA_X1%A_r27 x_PM_FA_X1%A_26 x_PM_FA_X1%A_25 141.18
R_x_PM_FA_X1%A_r28 x_PM_FA_X1%A_26 x_PM_FA_X1%A_22 4.35808
R_x_PM_FA_X1%A_r29 N_A_M6_g x_PM_FA_X1%A_22 39.78
R_x_PM_FA_X1%A_r30 x_PM_FA_X1%A_36 x_PM_FA_X1%A_21 4.56151
R_x_PM_FA_X1%A_r31 N_A_M6_g x_PM_FA_X1%A_21 60.84
R_x_PM_FA_X1%A_r32 x_PM_FA_X1%A_36 x_PM_FA_X1%A_17 4.56151
R_x_PM_FA_X1%A_r33 N_A_M20_g x_PM_FA_X1%A_17 37.44
R_x_PM_FA_X1%A_r34 x_PM_FA_X1%A_34 x_PM_FA_X1%A_13 4.56151
R_x_PM_FA_X1%A_r35 N_A_M5_g x_PM_FA_X1%A_13 80.34
R_x_PM_FA_X1%A_r36 x_PM_FA_X1%A_34 x_PM_FA_X1%A_9 4.56151
R_x_PM_FA_X1%A_r37 N_A_M19_g x_PM_FA_X1%A_9 62.4
R_x_PM_FA_X1%A_r38 N_A_M2_g x_PM_FA_X1%A_50 80.34
R_x_PM_FA_X1%A_r39 N_A_M16_g x_PM_FA_X1%A_49 62.4
C_x_PM_FA_X1%CI_c0 VSS x_PM_FA_X1%CI_40 1.10947e-17
C_x_PM_FA_X1%CI_c1 VSS x_PM_FA_X1%CI_28 8.70616e-18
C_x_PM_FA_X1%CI_c2 VSS x_PM_FA_X1%CI_25 3.11646e-16
C_x_PM_FA_X1%CI_c3 VSS N_CI_M24_g 1.00844e-16
C_x_PM_FA_X1%CI_c4 VSS x_PM_FA_X1%CI_18 6.35554e-18
C_x_PM_FA_X1%CI_c5 VSS x_PM_FA_X1%CI_17 4.35365e-17
C_x_PM_FA_X1%CI_c6 VSS N_CI_M8_g 4.45866e-17
C_x_PM_FA_X1%CI_c7 VSS N_CI_M22_g 5.1125e-17
C_x_PM_FA_X1%CI_c8 VSS N_CI_M3_g 5.54613e-17
C_x_PM_FA_X1%CI_c9 VSS N_CI_M17_g 7.28823e-17
R_x_PM_FA_X1%CI_r10 x_PM_FA_X1%CI_40 x_PM_FA_X1%CI_34 4.42
R_x_PM_FA_X1%CI_r11 x_PM_FA_X1%CI_34 x_PM_FA_X1%CI_32 25.0012
R_x_PM_FA_X1%CI_r12 x_PM_FA_X1%CI_37 x_PM_FA_X1%CI_28 4.7687
R_x_PM_FA_X1%CI_r13 x_PM_FA_X1%CI_36 x_PM_FA_X1%CI_28 4.7687
R_x_PM_FA_X1%CI_r14 x_PM_FA_X1%CI_28 x_PM_FA_X1%CI_26 25.0012
R_x_PM_FA_X1%CI_r15 CI x_PM_FA_X1%CI_26 0.3135
R_x_PM_FA_X1%CI_r16 x_PM_FA_X1%CI_32 x_PM_FA_X1%CI_25 3.78414
R_x_PM_FA_X1%CI_r17 CI x_PM_FA_X1%CI_25 0.076
R_x_PM_FA_X1%CI_r18 N_CI_M10_g N_CI_M24_g 92.04
R_x_PM_FA_X1%CI_r19 N_CI_M24_g x_PM_FA_X1%CI_19 29.64
R_x_PM_FA_X1%CI_r20 x_PM_FA_X1%CI_19 x_PM_FA_X1%CI_17 4.35808
R_x_PM_FA_X1%CI_r21 x_PM_FA_X1%CI_18 x_PM_FA_X1%CI_17 52.26
R_x_PM_FA_X1%CI_r22 x_PM_FA_X1%CI_40 x_PM_FA_X1%CI_13 1.95
R_x_PM_FA_X1%CI_r23 N_CI_M8_g x_PM_FA_X1%CI_13 34.32
R_x_PM_FA_X1%CI_r24 x_PM_FA_X1%CI_40 x_PM_FA_X1%CI_10 1.95
R_x_PM_FA_X1%CI_r25 N_CI_M22_g x_PM_FA_X1%CI_10 63.96
R_x_PM_FA_X1%CI_r26 x_PM_FA_X1%CI_18 x_PM_FA_X1%CI_9 4.35808
R_x_PM_FA_X1%CI_r27 N_CI_M22_g x_PM_FA_X1%CI_9 21.06
R_x_PM_FA_X1%CI_r28 N_CI_M3_g x_PM_FA_X1%CI_37 58.5
R_x_PM_FA_X1%CI_r29 N_CI_M17_g x_PM_FA_X1%CI_36 84.24
C_x_PM_FA_X1%8_c0 VSS x_PM_FA_X1%8_12 5.57155e-17
C_x_PM_FA_X1%8_c1 VSS x_PM_FA_X1%8_8 6.79991e-18
C_x_PM_FA_X1%8_c2 VSS x_PM_FA_X1%8_3 2.72309e-17
C_x_PM_FA_X1%8_c3 VSS N_8_M5_d 3.36144e-17
R_x_PM_FA_X1%8_r4 x_PM_FA_X1%8_8 x_PM_FA_X1%8_12 1.30286
R_x_PM_FA_X1%8_r5 x_PM_FA_X1%8_8 x_PM_FA_X1%8_3 0.192227
R_x_PM_FA_X1%8_r6 N_8_M3_d x_PM_FA_X1%8_3 0.152
R_x_PM_FA_X1%8_r7 x_PM_FA_X1%8_12 N_8_M5_d 0.344227
C_x_PM_FA_X1%9_c0 VSS x_PM_FA_X1%9_8 1.67666e-17
C_x_PM_FA_X1%9_c1 VSS x_PM_FA_X1%9_7 8.28438e-17
C_x_PM_FA_X1%9_c2 VSS N_9_M17_d 3.53111e-17
C_x_PM_FA_X1%9_c3 VSS N_9_M19_d 3.42486e-17
R_x_PM_FA_X1%9_r4 x_PM_FA_X1%9_9 x_PM_FA_X1%9_7 0.212317
R_x_PM_FA_X1%9_r5 x_PM_FA_X1%9_8 x_PM_FA_X1%9_7 1.62857
R_x_PM_FA_X1%9_r6 x_PM_FA_X1%9_8 x_PM_FA_X1%9_3 0.212317
R_x_PM_FA_X1%9_r7 N_9_M17_d x_PM_FA_X1%9_3 0.420714
R_x_PM_FA_X1%9_r8 N_9_M19_d x_PM_FA_X1%9_9 0.420714
C_x_PM_FA_X1%10_c0 VSS x_PM_FA_X1%10_34 1.31996e-17
C_x_PM_FA_X1%10_c1 VSS x_PM_FA_X1%10_26 3.83691e-17
C_x_PM_FA_X1%10_c2 VSS x_PM_FA_X1%10_25 1.58553e-17
C_x_PM_FA_X1%10_c3 VSS N_10_M8_d 4.58406e-17
C_x_PM_FA_X1%10_c4 VSS N_10_M22_d 2.58795e-17
C_x_PM_FA_X1%10_c5 VSS x_PM_FA_X1%10_15 1.14339e-16
C_x_PM_FA_X1%10_c6 VSS x_PM_FA_X1%10_14 1.18951e-17
C_x_PM_FA_X1%10_c7 VSS x_PM_FA_X1%10_12 3.06502e-17
C_x_PM_FA_X1%10_c8 VSS N_10_M13_g 3.49955e-17
C_x_PM_FA_X1%10_c9 VSS N_10_M27_g 5.65928e-17
R_x_PM_FA_X1%10_r10 x_PM_FA_X1%10_34 x_PM_FA_X1%10_32 4.94
R_x_PM_FA_X1%10_r11 x_PM_FA_X1%10_32 x_PM_FA_X1%10_29 25.0012
R_x_PM_FA_X1%10_r12 x_PM_FA_X1%10_29 x_PM_FA_X1%10_26 0.176429
R_x_PM_FA_X1%10_r13 x_PM_FA_X1%10_25 x_PM_FA_X1%10_16 0.0418175
R_x_PM_FA_X1%10_r14 x_PM_FA_X1%10_26 x_PM_FA_X1%10_15 0.095
R_x_PM_FA_X1%10_r15 x_PM_FA_X1%10_16 x_PM_FA_X1%10_15 3.85429
R_x_PM_FA_X1%10_r16 x_PM_FA_X1%10_14 N_10_M8_d 0.30478
R_x_PM_FA_X1%10_r17 x_PM_FA_X1%10_25 x_PM_FA_X1%10_13 0.160909
R_x_PM_FA_X1%10_r18 x_PM_FA_X1%10_14 x_PM_FA_X1%10_13 0.461429
R_x_PM_FA_X1%10_r19 x_PM_FA_X1%10_25 x_PM_FA_X1%10_12 0.160909
R_x_PM_FA_X1%10_r20 x_PM_FA_X1%10_11 N_10_M22_d 0.30478
R_x_PM_FA_X1%10_r21 x_PM_FA_X1%10_12 x_PM_FA_X1%10_11 1.49286
R_x_PM_FA_X1%10_r22 x_PM_FA_X1%10_34 x_PM_FA_X1%10_5 1.95
R_x_PM_FA_X1%10_r23 N_10_M13_g x_PM_FA_X1%10_5 28.47
R_x_PM_FA_X1%10_r24 x_PM_FA_X1%10_34 x_PM_FA_X1%10_VSS 1.95
R_x_PM_FA_X1%10_r25 N_10_M27_g x_PM_FA_X1%10_VSS 60.06
C_x_PM_FA_X1%11_c0 VSS x_PM_FA_X1%11_12 6.13421e-17
C_x_PM_FA_X1%11_c1 VSS x_PM_FA_X1%11_8 7.15041e-18
C_x_PM_FA_X1%11_c2 VSS x_PM_FA_X1%11_3 3.6458e-17
C_x_PM_FA_X1%11_c3 VSS N_11_M11_d 2.79838e-17
R_x_PM_FA_X1%11_r4 x_PM_FA_X1%11_8 x_PM_FA_X1%11_12 1.30286
R_x_PM_FA_X1%11_r5 x_PM_FA_X1%11_8 x_PM_FA_X1%11_3 0.192227
R_x_PM_FA_X1%11_r6 N_11_M9_d x_PM_FA_X1%11_3 0.152
R_x_PM_FA_X1%11_r7 x_PM_FA_X1%11_12 N_11_M11_d 0.344227
C_x_PM_FA_X1%12_c0 VSS x_PM_FA_X1%12_8 1.43304e-17
C_x_PM_FA_X1%12_c1 VSS x_PM_FA_X1%12_7 5.70608e-17
C_x_PM_FA_X1%12_c2 VSS N_12_M23_d 2.09607e-17
C_x_PM_FA_X1%12_c3 VSS N_12_M25_d 1.79819e-17
R_x_PM_FA_X1%12_r4 x_PM_FA_X1%12_9 x_PM_FA_X1%12_7 0.212317
R_x_PM_FA_X1%12_r5 x_PM_FA_X1%12_8 x_PM_FA_X1%12_7 1.62857
R_x_PM_FA_X1%12_r6 x_PM_FA_X1%12_8 x_PM_FA_X1%12_3 0.212317
R_x_PM_FA_X1%12_r7 N_12_M23_d x_PM_FA_X1%12_3 0.230714
R_x_PM_FA_X1%12_r8 N_12_M25_d x_PM_FA_X1%12_9 0.230714
C_x_PM_FA_X1%S_c0 VSS N_S_M27_d 8.99624e-17
R_x_PM_FA_X1%S_r1 N_S_M13_d S 1.862
R_x_PM_FA_X1%S_r2 S N_S_M27_d 1.20333
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X1.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X1 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 2.21627e-17
c_2 0 VDD 2.21627e-17
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X16.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X16 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 2.16383e-16
c_2 0 VDD 2.16383e-16
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X2.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X2 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 3.54794e-17
c_2 0 VDD 3.54794e-17
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X32.                                                    *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X32 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 4.22044e-16
c_2 0 VDD 4.22044e-16
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X4.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X4 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 6.16729e-17
c_2 0 VDD 6.16729e-17
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   FILLCELL_X8.                                                     *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT FILLCELL_X8 VDD VSS
*.PININFO VDD:B VSS:B
c_1 0 VSS 1.13552e-16
c_2 0 VDD 1.13552e-16
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   HA_X1.                                                           *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT HA_X1 VSS VDD A S B CO
*.PININFO VSS:B VDD:B A:I S:O B:I CO:O
M_M8 10 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M9 N_VDD_M1_d N_B_M1_g 10 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M10 N_6_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M11 N_S_M3_d N_A_M3_g N_6_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M12 N_6_M4_d N_B_M4_g N_S_M3_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M13 N_8_M5_d N_A_M5_g N_VDD_M5_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M14 N_VDD_M6_d N_B_M6_g N_8_M5_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M15 N_CO_M7_d N_8_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_3_M8_d N_A_M8_g N_VSS_M8_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M9_d N_B_M9_g N_3_M8_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_S_M10_d N_3_M10_g N_VSS_M9_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 noxref_11 N_A_M11_g N_S_M10_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_VSS_M12_d N_B_M12_g noxref_11 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M5 12 N_A_M13_g N_8_M13_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M6 N_VSS_M14_d N_B_M14_g 12 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M7 N_CO_M15_d N_8_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_HA_X1%VSS_c0 VSS x_PM_HA_X1%VSS_33 5.3138e-17
C_x_PM_HA_X1%VSS_c1 VSS x_PM_HA_X1%VSS_32 4.6069e-18
C_x_PM_HA_X1%VSS_c2 VSS x_PM_HA_X1%VSS_31 4.62027e-18
C_x_PM_HA_X1%VSS_c3 VSS N_VSS_M14_d 2.25218e-17
C_x_PM_HA_X1%VSS_c4 VSS x_PM_HA_X1%VSS_23 4.23392e-17
C_x_PM_HA_X1%VSS_c5 VSS N_VSS_M12_d 3.64469e-17
C_x_PM_HA_X1%VSS_c6 VSS x_PM_HA_X1%VSS_15 5.23379e-17
C_x_PM_HA_X1%VSS_c7 VSS N_VSS_M9_d 3.87618e-17
C_x_PM_HA_X1%VSS_c8 VSS x_PM_HA_X1%VSS_10 1.08457e-17
C_x_PM_HA_X1%VSS_c9 VSS x_PM_HA_X1%VSS_9 3.02263e-17
C_x_PM_HA_X1%VSS_c10 VSS N_VSS_M8_s 2.54142e-17
R_x_PM_HA_X1%VSS_r11 x_PM_HA_X1%VSS_33 x_PM_HA_X1%VSS_25 0.145286
R_x_PM_HA_X1%VSS_r12 N_VSS_M14_d x_PM_HA_X1%VSS_25 0.637857
R_x_PM_HA_X1%VSS_r13 x_PM_HA_X1%VSS_32 x_PM_HA_X1%VSS_24 0.0731438
R_x_PM_HA_X1%VSS_r14 x_PM_HA_X1%VSS_33 x_PM_HA_X1%VSS_23 0.0731438
R_x_PM_HA_X1%VSS_r15 x_PM_HA_X1%VSS_24 x_PM_HA_X1%VSS_23 1.03941
R_x_PM_HA_X1%VSS_r16 x_PM_HA_X1%VSS_32 x_PM_HA_X1%VSS_19 0.145286
R_x_PM_HA_X1%VSS_r17 N_VSS_M12_d x_PM_HA_X1%VSS_19 0.909286
R_x_PM_HA_X1%VSS_r18 x_PM_HA_X1%VSS_31 x_PM_HA_X1%VSS_16 0.0731438
R_x_PM_HA_X1%VSS_r19 VSS x_PM_HA_X1%VSS_16 1.03941
R_x_PM_HA_X1%VSS_r20 x_PM_HA_X1%VSS_32 x_PM_HA_X1%VSS_15 0.0731438
R_x_PM_HA_X1%VSS_r21 VSS x_PM_HA_X1%VSS_15 0.0782353
R_x_PM_HA_X1%VSS_r22 x_PM_HA_X1%VSS_31 x_PM_HA_X1%VSS_11 0.145286
R_x_PM_HA_X1%VSS_r23 N_VSS_M9_d x_PM_HA_X1%VSS_11 1.12643
R_x_PM_HA_X1%VSS_r24 x_PM_HA_X1%VSS_31 x_PM_HA_X1%VSS_9 0.0731438
R_x_PM_HA_X1%VSS_r25 x_PM_HA_X1%VSS_10 x_PM_HA_X1%VSS_9 0.681765
R_x_PM_HA_X1%VSS_r26 x_PM_HA_X1%VSS_10 x_PM_HA_X1%VSS_5 0.264221
R_x_PM_HA_X1%VSS_r27 N_VSS_M8_s x_PM_HA_X1%VSS_5 1.12643
C_x_PM_HA_X1%VDD_c0 VSS x_PM_HA_X1%VDD_28 3.5687e-17
C_x_PM_HA_X1%VDD_c1 VSS x_PM_HA_X1%VDD_27 4.6069e-18
C_x_PM_HA_X1%VDD_c2 VSS x_PM_HA_X1%VDD_26 4.62654e-18
C_x_PM_HA_X1%VDD_c3 VSS N_VDD_M6_d 2.67358e-17
C_x_PM_HA_X1%VDD_c4 VSS x_PM_HA_X1%VDD_18 3.02782e-17
C_x_PM_HA_X1%VDD_c5 VSS N_VDD_M5_s 3.64332e-17
C_x_PM_HA_X1%VDD_c6 VSS x_PM_HA_X1%VDD_12 1.09237e-16
C_x_PM_HA_X1%VDD_c7 VSS N_VDD_M1_d 3.96535e-17
C_x_PM_HA_X1%VDD_c8 VSS x_PM_HA_X1%VDD_4 4.04111e-17
R_x_PM_HA_X1%VDD_r9 x_PM_HA_X1%VDD_28 x_PM_HA_X1%VDD_20 0.145286
R_x_PM_HA_X1%VDD_r10 N_VDD_M6_d x_PM_HA_X1%VDD_20 0.909286
R_x_PM_HA_X1%VDD_r11 x_PM_HA_X1%VDD_27 x_PM_HA_X1%VDD_19 0.0731438
R_x_PM_HA_X1%VDD_r12 x_PM_HA_X1%VDD_28 x_PM_HA_X1%VDD_18 0.0731438
R_x_PM_HA_X1%VDD_r13 x_PM_HA_X1%VDD_19 x_PM_HA_X1%VDD_18 0.681765
R_x_PM_HA_X1%VDD_r14 x_PM_HA_X1%VDD_27 x_PM_HA_X1%VDD_14 0.145286
R_x_PM_HA_X1%VDD_r15 N_VDD_M5_s x_PM_HA_X1%VDD_14 0.909286
R_x_PM_HA_X1%VDD_r16 x_PM_HA_X1%VDD_26 x_PM_HA_X1%VDD_13 0.0731438
R_x_PM_HA_X1%VDD_r17 x_PM_HA_X1%VDD_27 x_PM_HA_X1%VDD_12 0.0731438
R_x_PM_HA_X1%VDD_r18 x_PM_HA_X1%VDD_13 x_PM_HA_X1%VDD_12 1.45294
R_x_PM_HA_X1%VDD_r19 x_PM_HA_X1%VDD_26 x_PM_HA_X1%VDD_8 0.145286
R_x_PM_HA_X1%VDD_r20 N_VDD_M1_d x_PM_HA_X1%VDD_8 1.235
R_x_PM_HA_X1%VDD_r21 x_PM_HA_X1%VDD_26 x_PM_HA_X1%VDD_4 0.0731438
R_x_PM_HA_X1%VDD_r22 VDD x_PM_HA_X1%VDD_4 0.469412
C_x_PM_HA_X1%3_c0 VSS x_PM_HA_X1%3_31 7.54974e-18
C_x_PM_HA_X1%3_c1 VSS x_PM_HA_X1%3_30 5.03647e-18
C_x_PM_HA_X1%3_c2 VSS N_3_M8_d 3.48375e-17
C_x_PM_HA_X1%3_c3 VSS x_PM_HA_X1%3_23 2.58871e-17
C_x_PM_HA_X1%3_c4 VSS x_PM_HA_X1%3_20 3.63336e-17
C_x_PM_HA_X1%3_c5 VSS x_PM_HA_X1%3_18 1.13481e-17
C_x_PM_HA_X1%3_c6 VSS x_PM_HA_X1%3_16 1.537e-17
C_x_PM_HA_X1%3_c7 VSS x_PM_HA_X1%3_15 2.84202e-17
C_x_PM_HA_X1%3_c8 VSS N_3_M0_s 2.29049e-17
C_x_PM_HA_X1%3_c9 VSS N_3_M2_g 6.70227e-17
C_x_PM_HA_X1%3_c10 VSS N_3_M10_g 2.89369e-17
R_x_PM_HA_X1%3_r11 x_PM_HA_X1%3_33 x_PM_HA_X1%3_31 4.7687
R_x_PM_HA_X1%3_r12 x_PM_HA_X1%3_31 x_PM_HA_X1%3_23 25.0012
R_x_PM_HA_X1%3_r13 x_PM_HA_X1%3_30 x_PM_HA_X1%3_21 0.0418175
R_x_PM_HA_X1%3_r14 x_PM_HA_X1%3_23 x_PM_HA_X1%3_21 1.15357
R_x_PM_HA_X1%3_r15 x_PM_HA_X1%3_30 x_PM_HA_X1%3_19 0.160909
R_x_PM_HA_X1%3_r16 x_PM_HA_X1%3_20 x_PM_HA_X1%3_19 1.14
R_x_PM_HA_X1%3_r17 x_PM_HA_X1%3_30 x_PM_HA_X1%3_18 0.160909
R_x_PM_HA_X1%3_r18 x_PM_HA_X1%3_17 N_3_M8_d 0.30478
R_x_PM_HA_X1%3_r19 x_PM_HA_X1%3_18 x_PM_HA_X1%3_17 0.597143
R_x_PM_HA_X1%3_r20 x_PM_HA_X1%3_20 x_PM_HA_X1%3_15 0.212317
R_x_PM_HA_X1%3_r21 x_PM_HA_X1%3_16 x_PM_HA_X1%3_15 0.76
R_x_PM_HA_X1%3_r22 x_PM_HA_X1%3_16 x_PM_HA_X1%3_11 0.212317
R_x_PM_HA_X1%3_r23 N_3_M0_s x_PM_HA_X1%3_11 1.045
R_x_PM_HA_X1%3_r24 N_3_M2_g x_PM_HA_X1%3_33 83.07
R_x_PM_HA_X1%3_r25 x_PM_HA_X1%3_VSS x_PM_HA_X1%3_31 4.7687
R_x_PM_HA_X1%3_r26 N_3_M10_g x_PM_HA_X1%3_VSS 28.08
C_x_PM_HA_X1%A_c0 VSS x_PM_HA_X1%A_31 7.05575e-18
C_x_PM_HA_X1%A_c1 VSS x_PM_HA_X1%A_29 5.78171e-17
C_x_PM_HA_X1%A_c2 VSS x_PM_HA_X1%A_25 4.44306e-18
C_x_PM_HA_X1%A_c3 VSS N_A_M13_g 1.30114e-16
C_x_PM_HA_X1%A_c4 VSS x_PM_HA_X1%A_17 6.12196e-17
C_x_PM_HA_X1%A_c5 VSS N_A_M11_g 1.39206e-16
C_x_PM_HA_X1%A_c6 VSS x_PM_HA_X1%A_10 5.81129e-18
C_x_PM_HA_X1%A_c7 VSS x_PM_HA_X1%A_9 6.00547e-17
C_x_PM_HA_X1%A_c8 VSS N_A_M0_g 6.29167e-17
C_x_PM_HA_X1%A_c9 VSS N_A_M8_g 5.07094e-17
R_x_PM_HA_X1%A_r10 x_PM_HA_X1%A_35 x_PM_HA_X1%A_31 4.7687
R_x_PM_HA_X1%A_r11 x_PM_HA_X1%A_34 x_PM_HA_X1%A_31 4.7687
R_x_PM_HA_X1%A_r12 x_PM_HA_X1%A_31 x_PM_HA_X1%A_29 25.0012
R_x_PM_HA_X1%A_r13 x_PM_HA_X1%A_29 A 0.169643
R_x_PM_HA_X1%A_r14 N_A_M5_g N_A_M13_g 138.45
R_x_PM_HA_X1%A_r15 N_A_M13_g x_PM_HA_X1%A_19 21.84
R_x_PM_HA_X1%A_r16 x_PM_HA_X1%A_25 x_PM_HA_X1%A_18 3.30287
R_x_PM_HA_X1%A_r17 x_PM_HA_X1%A_19 x_PM_HA_X1%A_17 4.35808
R_x_PM_HA_X1%A_r18 x_PM_HA_X1%A_18 x_PM_HA_X1%A_17 74.88
R_x_PM_HA_X1%A_r19 N_A_M3_g N_A_M11_g 125.97
R_x_PM_HA_X1%A_r20 x_PM_HA_X1%A_25 x_PM_HA_X1%A_11 0.858359
R_x_PM_HA_X1%A_r21 N_A_M11_g x_PM_HA_X1%A_11 29.64
R_x_PM_HA_X1%A_r22 x_PM_HA_X1%A_25 x_PM_HA_X1%A_9 3.30287
R_x_PM_HA_X1%A_r23 x_PM_HA_X1%A_10 x_PM_HA_X1%A_9 81.12
R_x_PM_HA_X1%A_r24 N_A_M0_g x_PM_HA_X1%A_35 65.91
R_x_PM_HA_X1%A_r25 N_A_M8_g x_PM_HA_X1%A_34 45.24
R_x_PM_HA_X1%A_r26 x_PM_HA_X1%A_10 x_PM_HA_X1%A_VSS 4.35808
R_x_PM_HA_X1%A_r27 N_A_M8_g x_PM_HA_X1%A_VSS 32.76
C_x_PM_HA_X1%S_c0 VSS N_S_M3_d 5.53983e-17
C_x_PM_HA_X1%S_c1 VSS x_PM_HA_X1%S_14 2.01427e-17
C_x_PM_HA_X1%S_c2 VSS x_PM_HA_X1%S_10 6.40141e-17
C_x_PM_HA_X1%S_c3 VSS N_S_M10_d 2.03409e-17
R_x_PM_HA_X1%S_r4 N_S_M3_d x_PM_HA_X1%S_16 0.11963
R_x_PM_HA_X1%S_r5 x_PM_HA_X1%S_14 x_PM_HA_X1%S_13 0.678571
R_x_PM_HA_X1%S_r6 x_PM_HA_X1%S_13 x_PM_HA_X1%S_11 0.0407143
R_x_PM_HA_X1%S_r7 x_PM_HA_X1%S_16 x_PM_HA_X1%S_10 0.095
R_x_PM_HA_X1%S_r8 x_PM_HA_X1%S_14 x_PM_HA_X1%S_9 0.095
R_x_PM_HA_X1%S_r9 x_PM_HA_X1%S_10 x_PM_HA_X1%S_9 2.93143
R_x_PM_HA_X1%S_r10 x_PM_HA_X1%S_13 S 0.095
R_x_PM_HA_X1%S_r11 S N_S_M10_d 0.189553
R_x_PM_HA_X1%S_r12 x_PM_HA_X1%S_11 x_PM_HA_X1%S_3 0.095
R_x_PM_HA_X1%S_r13 S x_PM_HA_X1%S_3 0.000447059
C_x_PM_HA_X1%6_c0 VSS x_PM_HA_X1%6_8 1.85518e-17
C_x_PM_HA_X1%6_c1 VSS x_PM_HA_X1%6_7 1.01842e-16
C_x_PM_HA_X1%6_c2 VSS N_6_M2_d 2.64446e-17
C_x_PM_HA_X1%6_c3 VSS N_6_M4_d 2.25536e-17
R_x_PM_HA_X1%6_r4 x_PM_HA_X1%6_9 x_PM_HA_X1%6_7 0.212317
R_x_PM_HA_X1%6_r5 x_PM_HA_X1%6_8 x_PM_HA_X1%6_7 1.62857
R_x_PM_HA_X1%6_r6 x_PM_HA_X1%6_8 x_PM_HA_X1%6_3 0.212317
R_x_PM_HA_X1%6_r7 N_6_M2_d x_PM_HA_X1%6_3 0.393571
R_x_PM_HA_X1%6_r8 N_6_M4_d x_PM_HA_X1%6_9 0.393571
C_x_PM_HA_X1%B_c0 VSS B 6.49e-17
C_x_PM_HA_X1%B_c1 VSS x_PM_HA_X1%B_28 6.58664e-18
C_x_PM_HA_X1%B_c2 VSS x_PM_HA_X1%B_25 4.26296e-18
C_x_PM_HA_X1%B_c3 VSS N_B_M14_g 1.22516e-16
C_x_PM_HA_X1%B_c4 VSS x_PM_HA_X1%B_17 5.95785e-17
C_x_PM_HA_X1%B_c5 VSS N_B_M4_g 7.99925e-17
C_x_PM_HA_X1%B_c6 VSS N_B_M12_g 3.32969e-17
C_x_PM_HA_X1%B_c7 VSS x_PM_HA_X1%B_8 6.65069e-18
C_x_PM_HA_X1%B_c8 VSS x_PM_HA_X1%B_7 6.12089e-17
C_x_PM_HA_X1%B_c9 VSS N_B_M9_g 1.13127e-16
R_x_PM_HA_X1%B_r10 x_PM_HA_X1%B_35 x_PM_HA_X1%B_28 4.7687
R_x_PM_HA_X1%B_r11 x_PM_HA_X1%B_34 x_PM_HA_X1%B_28 4.7687
R_x_PM_HA_X1%B_r12 x_PM_HA_X1%B_28 x_PM_HA_X1%B_26 25.0012
R_x_PM_HA_X1%B_r13 B x_PM_HA_X1%B_26 0.278214
R_x_PM_HA_X1%B_r14 N_B_M6_g N_B_M14_g 138.45
R_x_PM_HA_X1%B_r15 N_B_M6_g x_PM_HA_X1%B_19 30.03
R_x_PM_HA_X1%B_r16 x_PM_HA_X1%B_25 x_PM_HA_X1%B_18 3.30287
R_x_PM_HA_X1%B_r17 x_PM_HA_X1%B_19 x_PM_HA_X1%B_17 4.35808
R_x_PM_HA_X1%B_r18 x_PM_HA_X1%B_18 x_PM_HA_X1%B_17 74.88
R_x_PM_HA_X1%B_r19 N_B_M4_g x_PM_HA_X1%B_35 86.97
R_x_PM_HA_X1%B_r20 x_PM_HA_X1%B_25 x_PM_HA_X1%B_14 0.858359
R_x_PM_HA_X1%B_r21 N_B_M4_g x_PM_HA_X1%B_14 34.71
R_x_PM_HA_X1%B_r22 N_B_M12_g x_PM_HA_X1%B_34 27.3
R_x_PM_HA_X1%B_r23 x_PM_HA_X1%B_25 x_PM_HA_X1%B_7 3.30287
R_x_PM_HA_X1%B_r24 x_PM_HA_X1%B_8 x_PM_HA_X1%B_7 81.12
R_x_PM_HA_X1%B_r25 N_B_M1_g N_B_M9_g 122.85
R_x_PM_HA_X1%B_r26 x_PM_HA_X1%B_8 x_PM_HA_X1%B_VSS 4.35808
R_x_PM_HA_X1%B_r27 N_B_M1_g x_PM_HA_X1%B_VSS 34.71
C_x_PM_HA_X1%8_c0 VSS x_PM_HA_X1%8_28 7.8216e-18
C_x_PM_HA_X1%8_c1 VSS N_8_M5_d 2.88197e-17
C_x_PM_HA_X1%8_c2 VSS x_PM_HA_X1%8_21 3.94575e-17
C_x_PM_HA_X1%8_c3 VSS x_PM_HA_X1%8_18 2.26695e-17
C_x_PM_HA_X1%8_c4 VSS x_PM_HA_X1%8_16 7.1346e-18
C_x_PM_HA_X1%8_c5 VSS x_PM_HA_X1%8_15 9.38374e-18
C_x_PM_HA_X1%8_c6 VSS N_8_M13_s 8.14202e-17
C_x_PM_HA_X1%8_c7 VSS N_8_M7_g 5.23176e-17
C_x_PM_HA_X1%8_c8 VSS N_8_M15_g 6.59874e-17
R_x_PM_HA_X1%8_r9 x_PM_HA_X1%8_30 x_PM_HA_X1%8_28 4.7687
R_x_PM_HA_X1%8_r10 x_PM_HA_X1%8_28 x_PM_HA_X1%8_21 25.0012
R_x_PM_HA_X1%8_r11 x_PM_HA_X1%8_21 x_PM_HA_X1%8_19 1.615
R_x_PM_HA_X1%8_r12 x_PM_HA_X1%8_18 N_8_M5_d 0.30478
R_x_PM_HA_X1%8_r13 x_PM_HA_X1%8_19 x_PM_HA_X1%8_17 0.095
R_x_PM_HA_X1%8_r14 x_PM_HA_X1%8_18 x_PM_HA_X1%8_17 1.38429
R_x_PM_HA_X1%8_r15 x_PM_HA_X1%8_19 x_PM_HA_X1%8_15 0.19
R_x_PM_HA_X1%8_r16 x_PM_HA_X1%8_16 x_PM_HA_X1%8_15 0.488571
R_x_PM_HA_X1%8_r17 x_PM_HA_X1%8_16 x_PM_HA_X1%8_11 0.212317
R_x_PM_HA_X1%8_r18 N_8_M13_s x_PM_HA_X1%8_11 2.375
R_x_PM_HA_X1%8_r19 N_8_M7_g x_PM_HA_X1%8_30 54.21
R_x_PM_HA_X1%8_r20 x_PM_HA_X1%8_VSS x_PM_HA_X1%8_28 4.7687
R_x_PM_HA_X1%8_r21 N_8_M15_g x_PM_HA_X1%8_VSS 75.66
C_x_PM_HA_X1%CO_c0 VSS x_PM_HA_X1%CO_15 2.61815e-17
C_x_PM_HA_X1%CO_c1 VSS x_PM_HA_X1%CO_10 5.00743e-17
C_x_PM_HA_X1%CO_c2 VSS CO 6.02917e-17
R_x_PM_HA_X1%CO_r3 x_PM_HA_X1%CO_15 N_CO_M7_d 0.175926
R_x_PM_HA_X1%CO_r4 x_PM_HA_X1%CO_10 N_CO_M15_d 0.175926
R_x_PM_HA_X1%CO_r5 x_PM_HA_X1%CO_15 x_PM_HA_X1%CO_4 0.095
R_x_PM_HA_X1%CO_r6 CO x_PM_HA_X1%CO_4 2.11714
R_x_PM_HA_X1%CO_r7 x_PM_HA_X1%CO_10 x_PM_HA_X1%CO_3 0.095
R_x_PM_HA_X1%CO_r8 CO x_PM_HA_X1%CO_3 1.87286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X1 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M1 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_ZN_M1_d N_A_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_INV_X1%VSS_c0 VSS VSS 4.04285e-17
C_x_PM_INV_X1%VSS_c1 VSS x_PM_INV_X1%VSS_6 1.05124e-17
C_x_PM_INV_X1%VSS_c2 VSS N_VSS_M1_s 2.31636e-17
R_x_PM_INV_X1%VSS_r3 VSS x_PM_INV_X1%VSS_6 0.178824
R_x_PM_INV_X1%VSS_r4 x_PM_INV_X1%VSS_6 x_PM_INV_X1%VSS_2 0.264221
R_x_PM_INV_X1%VSS_r5 N_VSS_M1_s x_PM_INV_X1%VSS_2 0.637857
C_x_PM_INV_X1%VDD_c0 VSS VDD 4.07945e-17
C_x_PM_INV_X1%VDD_c1 VSS x_PM_INV_X1%VDD_6 1.04356e-17
C_x_PM_INV_X1%VDD_c2 VSS N_VDD_M0_s 1.64358e-17
R_x_PM_INV_X1%VDD_r3 VDD x_PM_INV_X1%VDD_6 0.178824
R_x_PM_INV_X1%VDD_r4 x_PM_INV_X1%VDD_6 x_PM_INV_X1%VDD_2 0.264221
R_x_PM_INV_X1%VDD_r5 N_VDD_M0_s x_PM_INV_X1%VDD_2 0.393571
C_x_PM_INV_X1%A_c0 VSS x_PM_INV_X1%A_14 8.49607e-18
C_x_PM_INV_X1%A_c1 VSS x_PM_INV_X1%A_12 3.68113e-17
C_x_PM_INV_X1%A_c2 VSS N_A_M0_g 8.65221e-17
C_x_PM_INV_X1%A_c3 VSS N_A_M1_g 4.18099e-17
R_x_PM_INV_X1%A_r4 x_PM_INV_X1%A_18 x_PM_INV_X1%A_14 4.74714
R_x_PM_INV_X1%A_r5 x_PM_INV_X1%A_17 x_PM_INV_X1%A_14 4.74714
R_x_PM_INV_X1%A_r6 x_PM_INV_X1%A_14 x_PM_INV_X1%A_12 25.0012
R_x_PM_INV_X1%A_r7 x_PM_INV_X1%A_12 A 0.156071
R_x_PM_INV_X1%A_r8 N_A_M0_g x_PM_INV_X1%A_18 106.47
R_x_PM_INV_X1%A_r9 N_A_M1_g x_PM_INV_X1%A_17 38.22
C_x_PM_INV_X1%ZN_c0 VSS N_ZN_M0_d 3.98114e-17
C_x_PM_INV_X1%ZN_c1 VSS N_ZN_M1_d 4.09557e-17
C_x_PM_INV_X1%ZN_c2 VSS ZN 8.74217e-17
R_x_PM_INV_X1%ZN_r3 x_PM_INV_X1%ZN_4 N_ZN_M0_d 0.30478
R_x_PM_INV_X1%ZN_r4 ZN x_PM_INV_X1%ZN_4 2.63286
R_x_PM_INV_X1%ZN_r5 x_PM_INV_X1%ZN_3 N_ZN_M1_d 0.30478
R_x_PM_INV_X1%ZN_r6 ZN x_PM_INV_X1%ZN_3 1.87286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X16.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X16 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M4 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
M_M5 N_VDD_M1_d N_A_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M6 N_ZN_M2_d N_A_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M7 N_VDD_M3_d N_A_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_ZN_M4_d N_A_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_VSS_M5_d N_A_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M2 N_ZN_M6_d N_A_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M3 N_VSS_M7_d N_A_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_INV_X16%VSS_c0 VSS x_PM_INV_X16%VSS_22 5.79695e-18
C_x_PM_INV_X16%VSS_c1 VSS N_VSS_M7_d 3.40162e-17
C_x_PM_INV_X16%VSS_c2 VSS x_PM_INV_X16%VSS_16 3.57773e-17
C_x_PM_INV_X16%VSS_c3 VSS VSS 1.60704e-17
C_x_PM_INV_X16%VSS_c4 VSS x_PM_INV_X16%VSS_9 1.06862e-17
C_x_PM_INV_X16%VSS_c5 VSS x_PM_INV_X16%VSS_8 2.10275e-17
C_x_PM_INV_X16%VSS_c6 VSS N_VSS_M4_s 1.65803e-17
R_x_PM_INV_X16%VSS_r7 N_VSS_M7_d x_PM_INV_X16%VSS_18 1.77786
R_x_PM_INV_X16%VSS_r8 x_PM_INV_X16%VSS_22 x_PM_INV_X16%VSS_17 0.132285
R_x_PM_INV_X16%VSS_r9 x_PM_INV_X16%VSS_18 x_PM_INV_X16%VSS_16 0.264221
R_x_PM_INV_X16%VSS_r10 x_PM_INV_X16%VSS_17 x_PM_INV_X16%VSS_16 0.614706
R_x_PM_INV_X16%VSS_r11 N_VSS_M5_d VSS 0.197037
R_x_PM_INV_X16%VSS_r12 x_PM_INV_X16%VSS_22 x_PM_INV_X16%VSS_10 0.0680382
R_x_PM_INV_X16%VSS_r13 VSS x_PM_INV_X16%VSS_10 0.316667
R_x_PM_INV_X16%VSS_r14 x_PM_INV_X16%VSS_22 x_PM_INV_X16%VSS_8 0.132285
R_x_PM_INV_X16%VSS_r15 x_PM_INV_X16%VSS_9 x_PM_INV_X16%VSS_8 0.614706
R_x_PM_INV_X16%VSS_r16 x_PM_INV_X16%VSS_9 x_PM_INV_X16%VSS_4 0.264221
R_x_PM_INV_X16%VSS_r17 N_VSS_M4_s x_PM_INV_X16%VSS_4 0.990714
C_x_PM_INV_X16%VDD_c0 VSS x_PM_INV_X16%VDD_21 1.41439e-17
C_x_PM_INV_X16%VDD_c1 VSS x_PM_INV_X16%VDD_18 2.47447e-17
C_x_PM_INV_X16%VDD_c2 VSS N_VDD_M3_d 1.80345e-17
C_x_PM_INV_X16%VDD_c3 VSS x_PM_INV_X16%VDD_10 3.92123e-17
C_x_PM_INV_X16%VDD_c4 VSS x_PM_INV_X16%VDD_9 1.06862e-17
C_x_PM_INV_X16%VDD_c5 VSS N_VDD_M0_s 1.91781e-17
R_x_PM_INV_X16%VDD_r6 x_PM_INV_X16%VDD_21 VDD 0.105776
R_x_PM_INV_X16%VDD_r7 VDD N_VDD_M1_d 0.034898
R_x_PM_INV_X16%VDD_r8 x_PM_INV_X16%VDD_18 N_VDD_M1_d 0.140674
R_x_PM_INV_X16%VDD_r9 N_VDD_M3_d x_PM_INV_X16%VDD_12 0.230714
R_x_PM_INV_X16%VDD_r10 x_PM_INV_X16%VDD_12 x_PM_INV_X16%VDD_10 0.264221
R_x_PM_INV_X16%VDD_r11 x_PM_INV_X16%VDD_21 x_PM_INV_X16%VDD_10 0.614706
R_x_PM_INV_X16%VDD_r12 x_PM_INV_X16%VDD_9 x_PM_INV_X16%VDD_18 0.614706
R_x_PM_INV_X16%VDD_r13 x_PM_INV_X16%VDD_9 x_PM_INV_X16%VDD_4 0.264221
R_x_PM_INV_X16%VDD_r14 N_VDD_M0_s x_PM_INV_X16%VDD_4 0.230714
C_x_PM_INV_X16%A_c0 VSS x_PM_INV_X16%A_54 5.71489e-18
C_x_PM_INV_X16%A_c1 VSS x_PM_INV_X16%A_45 5.2028e-17
C_x_PM_INV_X16%A_c2 VSS x_PM_INV_X16%A_44 2.20635e-18
C_x_PM_INV_X16%A_c3 VSS x_PM_INV_X16%A_43 1.87244e-18
C_x_PM_INV_X16%A_c4 VSS x_PM_INV_X16%A_42 4.48018e-19
C_x_PM_INV_X16%A_c5 VSS x_PM_INV_X16%A_41 2.20635e-18
C_x_PM_INV_X16%A_c6 VSS N_A_M3_g 5.85501e-17
C_x_PM_INV_X16%A_c7 VSS N_A_M7_g 4.16806e-17
C_x_PM_INV_X16%A_c8 VSS x_PM_INV_X16%A_31 9.38337e-18
C_x_PM_INV_X16%A_c9 VSS N_A_M2_g 4.11036e-17
C_x_PM_INV_X16%A_c10 VSS N_A_M6_g 2.1704e-17
C_x_PM_INV_X16%A_c11 VSS x_PM_INV_X16%A_21 6.86232e-18
C_x_PM_INV_X16%A_c12 VSS N_A_M1_g 4.20181e-17
C_x_PM_INV_X16%A_c13 VSS N_A_M5_g 2.13634e-17
C_x_PM_INV_X16%A_c14 VSS x_PM_INV_X16%A_11 9.87485e-18
C_x_PM_INV_X16%A_c15 VSS N_A_M0_g 4.65422e-17
C_x_PM_INV_X16%A_c16 VSS x_PM_INV_X16%A_6 5.02183e-18
C_x_PM_INV_X16%A_c17 VSS N_A_M4_g 3.72183e-17
R_x_PM_INV_X16%A_r18 x_PM_INV_X16%A_54 x_PM_INV_X16%A_47 3.38
R_x_PM_INV_X16%A_r19 x_PM_INV_X16%A_47 x_PM_INV_X16%A_45 25.0012
R_x_PM_INV_X16%A_r20 A x_PM_INV_X16%A_45 0.302273
R_x_PM_INV_X16%A_r21 x_PM_INV_X16%A_44 x_PM_INV_X16%A_37 3.30287
R_x_PM_INV_X16%A_r22 N_A_M3_g x_PM_INV_X16%A_37 76.44
R_x_PM_INV_X16%A_r23 x_PM_INV_X16%A_44 x_PM_INV_X16%A_33 3.30287
R_x_PM_INV_X16%A_r24 N_A_M7_g x_PM_INV_X16%A_33 35.88
R_x_PM_INV_X16%A_r25 x_PM_INV_X16%A_43 x_PM_INV_X16%A_32 1.95
R_x_PM_INV_X16%A_r26 x_PM_INV_X16%A_44 x_PM_INV_X16%A_31 0.858359
R_x_PM_INV_X16%A_r27 x_PM_INV_X16%A_32 x_PM_INV_X16%A_31 21.84
R_x_PM_INV_X16%A_r28 x_PM_INV_X16%A_43 x_PM_INV_X16%A_27 1.95
R_x_PM_INV_X16%A_r29 N_A_M2_g x_PM_INV_X16%A_27 76.44
R_x_PM_INV_X16%A_r30 x_PM_INV_X16%A_43 x_PM_INV_X16%A_23 1.95
R_x_PM_INV_X16%A_r31 N_A_M6_g x_PM_INV_X16%A_23 35.88
R_x_PM_INV_X16%A_r32 x_PM_INV_X16%A_42 x_PM_INV_X16%A_22 1.95
R_x_PM_INV_X16%A_r33 x_PM_INV_X16%A_43 x_PM_INV_X16%A_21 1.95
R_x_PM_INV_X16%A_r34 x_PM_INV_X16%A_22 x_PM_INV_X16%A_21 21.84
R_x_PM_INV_X16%A_r35 x_PM_INV_X16%A_42 x_PM_INV_X16%A_17 1.95
R_x_PM_INV_X16%A_r36 N_A_M1_g x_PM_INV_X16%A_17 76.44
R_x_PM_INV_X16%A_r37 x_PM_INV_X16%A_42 x_PM_INV_X16%A_13 1.95
R_x_PM_INV_X16%A_r38 N_A_M5_g x_PM_INV_X16%A_13 35.88
R_x_PM_INV_X16%A_r39 x_PM_INV_X16%A_41 x_PM_INV_X16%A_12 0.858359
R_x_PM_INV_X16%A_r40 x_PM_INV_X16%A_42 x_PM_INV_X16%A_11 1.95
R_x_PM_INV_X16%A_r41 x_PM_INV_X16%A_12 x_PM_INV_X16%A_11 21.84
R_x_PM_INV_X16%A_r42 x_PM_INV_X16%A_54 x_PM_INV_X16%A_7 1.95
R_x_PM_INV_X16%A_r43 N_A_M0_g x_PM_INV_X16%A_7 49.92
R_x_PM_INV_X16%A_r44 x_PM_INV_X16%A_54 x_PM_INV_X16%A_6 1.95
R_x_PM_INV_X16%A_r45 x_PM_INV_X16%A_41 x_PM_INV_X16%A_5 3.30287
R_x_PM_INV_X16%A_r46 x_PM_INV_X16%A_6 x_PM_INV_X16%A_5 14.82
R_x_PM_INV_X16%A_r47 x_PM_INV_X16%A_41 x_PM_INV_X16%A_VSS 3.30287
R_x_PM_INV_X16%A_r48 N_A_M4_g x_PM_INV_X16%A_VSS 35.88
C_x_PM_INV_X16%ZN_c0 VSS x_PM_INV_X16%ZN_22 3.52263e-17
C_x_PM_INV_X16%ZN_c1 VSS x_PM_INV_X16%ZN_21 4.2555e-17
C_x_PM_INV_X16%ZN_c2 VSS N_ZN_M6_d 4.28961e-17
C_x_PM_INV_X16%ZN_c3 VSS x_PM_INV_X16%ZN_13 2.05202e-17
C_x_PM_INV_X16%ZN_c4 VSS N_ZN_M0_d 1.91267e-17
C_x_PM_INV_X16%ZN_c5 VSS N_ZN_M4_d 4.19107e-17
R_x_PM_INV_X16%ZN_r6 N_ZN_M2_d x_PM_INV_X16%ZN_22 0.513704
R_x_PM_INV_X16%ZN_r7 x_PM_INV_X16%ZN_22 x_PM_INV_X16%ZN_17 0.225185
R_x_PM_INV_X16%ZN_r8 N_ZN_M6_d x_PM_INV_X16%ZN_17 0.767037
R_x_PM_INV_X16%ZN_r9 x_PM_INV_X16%ZN_21 x_PM_INV_X16%ZN_14 0.0431301
R_x_PM_INV_X16%ZN_r10 ZN x_PM_INV_X16%ZN_14 0.40375
R_x_PM_INV_X16%ZN_r11 x_PM_INV_X16%ZN_22 x_PM_INV_X16%ZN_13 0.095
R_x_PM_INV_X16%ZN_r12 ZN x_PM_INV_X16%ZN_13 0.2375
R_x_PM_INV_X16%ZN_r13 x_PM_INV_X16%ZN_21 x_PM_INV_X16%ZN_9 0.299807
R_x_PM_INV_X16%ZN_r14 N_ZN_M0_d x_PM_INV_X16%ZN_9 0.556429
R_x_PM_INV_X16%ZN_r15 x_PM_INV_X16%ZN_21 x_PM_INV_X16%ZN_5 0.299807
R_x_PM_INV_X16%ZN_r16 N_ZN_M4_d x_PM_INV_X16%ZN_5 1.47929
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X2 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M1 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_ZN_M1_d N_A_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_INV_X2%VSS_c0 VSS VSS 4.27233e-17
C_x_PM_INV_X2%VSS_c1 VSS x_PM_INV_X2%VSS_6 1.03058e-17
C_x_PM_INV_X2%VSS_c2 VSS N_VSS_M1_s 1.41503e-17
R_x_PM_INV_X2%VSS_r3 VSS x_PM_INV_X2%VSS_6 0.178824
R_x_PM_INV_X2%VSS_r4 x_PM_INV_X2%VSS_6 x_PM_INV_X2%VSS_2 0.264221
R_x_PM_INV_X2%VSS_r5 N_VSS_M1_s x_PM_INV_X2%VSS_2 0.230714
C_x_PM_INV_X2%VDD_c0 VSS VDD 4.06353e-17
C_x_PM_INV_X2%VDD_c1 VSS N_VDD_M0_s 3.31015e-17
C_x_PM_INV_X2%VDD_c2 VSS x_PM_INV_X2%VDD_2 1.05089e-17
R_x_PM_INV_X2%VDD_r3 VDD x_PM_INV_X2%VDD_2 0.0689273
R_x_PM_INV_X2%VDD_r4 N_VDD_M0_s x_PM_INV_X2%VDD_2 0.420714
C_x_PM_INV_X2%A_c0 VSS x_PM_INV_X2%A_14 8.49814e-18
C_x_PM_INV_X2%A_c1 VSS x_PM_INV_X2%A_12 3.56395e-17
C_x_PM_INV_X2%A_c2 VSS N_A_M0_g 9.12771e-17
C_x_PM_INV_X2%A_c3 VSS N_A_M1_g 4.61923e-17
R_x_PM_INV_X2%A_r4 x_PM_INV_X2%A_18 x_PM_INV_X2%A_14 4.74714
R_x_PM_INV_X2%A_r5 x_PM_INV_X2%A_17 x_PM_INV_X2%A_14 4.74714
R_x_PM_INV_X2%A_r6 x_PM_INV_X2%A_14 x_PM_INV_X2%A_12 25.0012
R_x_PM_INV_X2%A_r7 x_PM_INV_X2%A_12 A 0.156071
R_x_PM_INV_X2%A_r8 N_A_M0_g x_PM_INV_X2%A_18 95.94
R_x_PM_INV_X2%A_r9 N_A_M1_g x_PM_INV_X2%A_17 42.12
C_x_PM_INV_X2%ZN_c0 VSS N_ZN_M1_d 3.90212e-17
C_x_PM_INV_X2%ZN_c1 VSS ZN 7.52075e-17
C_x_PM_INV_X2%ZN_c2 VSS N_ZN_M0_d 5.26306e-17
C_x_PM_INV_X2%ZN_c3 VSS x_PM_INV_X2%ZN_3 4.60415e-18
R_x_PM_INV_X2%ZN_r4 ZN x_PM_INV_X2%ZN_8 1.87286
R_x_PM_INV_X2%ZN_r5 x_PM_INV_X2%ZN_7 N_ZN_M1_d 0.30478
R_x_PM_INV_X2%ZN_r6 ZN x_PM_INV_X2%ZN_7 1.87286
R_x_PM_INV_X2%ZN_r7 x_PM_INV_X2%ZN_8 x_PM_INV_X2%ZN_3 0.20978
R_x_PM_INV_X2%ZN_r8 N_ZN_M0_d x_PM_INV_X2%ZN_3 0.686111
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X32.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X32 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M7 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.615000U L=0.050000U
M_M8 N_VDD_M1_d N_A_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M9 N_ZN_M2_d N_A_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M10 N_VDD_M3_d N_A_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M11 N_ZN_M4_d N_A_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M12 N_VDD_M5_d N_A_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M13 N_ZN_M6_d N_A_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.615000U L=0.050000U
M_M0 N_ZN_M7_d N_A_M7_g N_VSS_M7_s VSS NMOS_VTL W=0.410000U L=0.050000U
M_M1 N_VSS_M8_d N_A_M8_g N_ZN_M7_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M2 N_ZN_M9_d N_A_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M3 N_VSS_M10_d N_A_M10_g N_ZN_M9_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M4 N_ZN_M11_d N_A_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M5 N_VSS_M12_d N_A_M12_g N_ZN_M11_d VSS NMOS_VTL W=0.410000U L=0.050000U
M_M6 N_ZN_M13_d N_A_M13_g N_VSS_M12_d VSS NMOS_VTL W=0.410000U L=0.050000U
C_x_PM_INV_X32%VSS_c0 VSS x_PM_INV_X32%VSS_33 3.0161e-17
C_x_PM_INV_X32%VSS_c1 VSS x_PM_INV_X32%VSS_32 5.79695e-18
C_x_PM_INV_X32%VSS_c2 VSS x_PM_INV_X32%VSS_31 5.79695e-18
C_x_PM_INV_X32%VSS_c3 VSS N_VSS_M12_d 2.59476e-17
C_x_PM_INV_X32%VSS_c4 VSS x_PM_INV_X32%VSS_23 1.8178e-17
C_x_PM_INV_X32%VSS_c5 VSS N_VSS_M10_d 1.58042e-17
C_x_PM_INV_X32%VSS_c6 VSS x_PM_INV_X32%VSS_15 1.8178e-17
C_x_PM_INV_X32%VSS_c7 VSS N_VSS_M8_d 2.00715e-17
C_x_PM_INV_X32%VSS_c8 VSS x_PM_INV_X32%VSS_10 1.17956e-17
C_x_PM_INV_X32%VSS_c9 VSS x_PM_INV_X32%VSS_9 2.60829e-17
C_x_PM_INV_X32%VSS_c10 VSS N_VSS_M7_s 1.61302e-17
R_x_PM_INV_X32%VSS_r11 x_PM_INV_X32%VSS_33 x_PM_INV_X32%VSS_25 0.0680382
R_x_PM_INV_X32%VSS_r12 N_VSS_M12_d x_PM_INV_X32%VSS_25 0.513704
R_x_PM_INV_X32%VSS_r13 x_PM_INV_X32%VSS_32 x_PM_INV_X32%VSS_24 0.132285
R_x_PM_INV_X32%VSS_r14 x_PM_INV_X32%VSS_33 x_PM_INV_X32%VSS_23 0.132285
R_x_PM_INV_X32%VSS_r15 x_PM_INV_X32%VSS_24 x_PM_INV_X32%VSS_23 0.547647
R_x_PM_INV_X32%VSS_r16 x_PM_INV_X32%VSS_32 x_PM_INV_X32%VSS_19 0.0680382
R_x_PM_INV_X32%VSS_r17 N_VSS_M10_d x_PM_INV_X32%VSS_19 0.513704
R_x_PM_INV_X32%VSS_r18 x_PM_INV_X32%VSS_31 x_PM_INV_X32%VSS_16 0.132285
R_x_PM_INV_X32%VSS_r19 VSS x_PM_INV_X32%VSS_16 0.502941
R_x_PM_INV_X32%VSS_r20 x_PM_INV_X32%VSS_32 x_PM_INV_X32%VSS_15 0.132285
R_x_PM_INV_X32%VSS_r21 VSS x_PM_INV_X32%VSS_15 0.0447059
R_x_PM_INV_X32%VSS_r22 x_PM_INV_X32%VSS_31 x_PM_INV_X32%VSS_11 0.0680382
R_x_PM_INV_X32%VSS_r23 N_VSS_M8_d x_PM_INV_X32%VSS_11 0.513704
R_x_PM_INV_X32%VSS_r24 x_PM_INV_X32%VSS_31 x_PM_INV_X32%VSS_9 0.132285
R_x_PM_INV_X32%VSS_r25 x_PM_INV_X32%VSS_10 x_PM_INV_X32%VSS_9 0.614706
R_x_PM_INV_X32%VSS_r26 x_PM_INV_X32%VSS_10 x_PM_INV_X32%VSS_5 0.264221
R_x_PM_INV_X32%VSS_r27 N_VSS_M7_s x_PM_INV_X32%VSS_5 0.230714
C_x_PM_INV_X32%VDD_c0 VSS x_PM_INV_X32%VDD_36 2.9875e-17
C_x_PM_INV_X32%VDD_c1 VSS x_PM_INV_X32%VDD_35 5.79695e-18
C_x_PM_INV_X32%VDD_c2 VSS x_PM_INV_X32%VDD_34 5.79695e-18
C_x_PM_INV_X32%VDD_c3 VSS VDD 1.18523e-17
C_x_PM_INV_X32%VDD_c4 VSS N_VDD_M5_d 2.53922e-17
C_x_PM_INV_X32%VDD_c5 VSS x_PM_INV_X32%VDD_21 1.81734e-17
C_x_PM_INV_X32%VDD_c6 VSS N_VDD_M3_d 1.53344e-17
C_x_PM_INV_X32%VDD_c7 VSS x_PM_INV_X32%VDD_15 1.78523e-17
C_x_PM_INV_X32%VDD_c8 VSS N_VDD_M1_d 1.56795e-17
C_x_PM_INV_X32%VDD_c9 VSS x_PM_INV_X32%VDD_9 2.03499e-17
C_x_PM_INV_X32%VDD_c10 VSS N_VDD_M0_s 1.69414e-17
R_x_PM_INV_X32%VDD_r11 x_PM_INV_X32%VDD_32 VDD 0.2432
R_x_PM_INV_X32%VDD_r12 x_PM_INV_X32%VDD_31 VDD 0.0881799
R_x_PM_INV_X32%VDD_r13 x_PM_INV_X32%VDD_36 x_PM_INV_X32%VDD_23 0.0680382
R_x_PM_INV_X32%VDD_r14 N_VDD_M5_d x_PM_INV_X32%VDD_23 0.11963
R_x_PM_INV_X32%VDD_r15 x_PM_INV_X32%VDD_35 x_PM_INV_X32%VDD_22 0.132285
R_x_PM_INV_X32%VDD_r16 x_PM_INV_X32%VDD_36 x_PM_INV_X32%VDD_21 0.132285
R_x_PM_INV_X32%VDD_r17 x_PM_INV_X32%VDD_22 x_PM_INV_X32%VDD_21 0.547647
R_x_PM_INV_X32%VDD_r18 x_PM_INV_X32%VDD_35 x_PM_INV_X32%VDD_17 0.0680382
R_x_PM_INV_X32%VDD_r19 N_VDD_M3_d x_PM_INV_X32%VDD_17 0.11963
R_x_PM_INV_X32%VDD_r20 x_PM_INV_X32%VDD_34 x_PM_INV_X32%VDD_16 0.132285
R_x_PM_INV_X32%VDD_r21 x_PM_INV_X32%VDD_35 x_PM_INV_X32%VDD_15 0.132285
R_x_PM_INV_X32%VDD_r22 x_PM_INV_X32%VDD_16 x_PM_INV_X32%VDD_15 0.547647
R_x_PM_INV_X32%VDD_r23 x_PM_INV_X32%VDD_34 x_PM_INV_X32%VDD_11 0.0680382
R_x_PM_INV_X32%VDD_r24 N_VDD_M1_d x_PM_INV_X32%VDD_11 0.11963
R_x_PM_INV_X32%VDD_r25 x_PM_INV_X32%VDD_32 x_PM_INV_X32%VDD_10 0.095
R_x_PM_INV_X32%VDD_r26 x_PM_INV_X32%VDD_34 x_PM_INV_X32%VDD_9 0.132285
R_x_PM_INV_X32%VDD_r27 x_PM_INV_X32%VDD_10 x_PM_INV_X32%VDD_9 0.614706
R_x_PM_INV_X32%VDD_r28 N_VDD_M0_s x_PM_INV_X32%VDD_31 0.230714
C_x_PM_INV_X32%A_c0 VSS x_PM_INV_X32%A_85 4.86015e-18
C_x_PM_INV_X32%A_c1 VSS A 7.51287e-17
C_x_PM_INV_X32%A_c2 VSS x_PM_INV_X32%A_74 4.45005e-18
C_x_PM_INV_X32%A_c3 VSS x_PM_INV_X32%A_73 4.48018e-19
C_x_PM_INV_X32%A_c4 VSS x_PM_INV_X32%A_72 4.48018e-19
C_x_PM_INV_X32%A_c5 VSS x_PM_INV_X32%A_71 4.48018e-19
C_x_PM_INV_X32%A_c6 VSS x_PM_INV_X32%A_70 4.48018e-19
C_x_PM_INV_X32%A_c7 VSS x_PM_INV_X32%A_69 4.48018e-19
C_x_PM_INV_X32%A_c8 VSS N_A_M6_g 5.86177e-17
C_x_PM_INV_X32%A_c9 VSS N_A_M13_g 3.84853e-17
C_x_PM_INV_X32%A_c10 VSS x_PM_INV_X32%A_59 7.35616e-18
C_x_PM_INV_X32%A_c11 VSS N_A_M5_g 3.72226e-17
C_x_PM_INV_X32%A_c12 VSS N_A_M12_g 2.27954e-17
C_x_PM_INV_X32%A_c13 VSS x_PM_INV_X32%A_49 9.61639e-18
C_x_PM_INV_X32%A_c14 VSS N_A_M4_g 3.74637e-17
C_x_PM_INV_X32%A_c15 VSS N_A_M11_g 2.33309e-17
C_x_PM_INV_X32%A_c16 VSS x_PM_INV_X32%A_39 7.35616e-18
C_x_PM_INV_X32%A_c17 VSS N_A_M3_g 3.79261e-17
C_x_PM_INV_X32%A_c18 VSS N_A_M10_g 2.28212e-17
C_x_PM_INV_X32%A_c19 VSS x_PM_INV_X32%A_29 9.69325e-18
C_x_PM_INV_X32%A_c20 VSS N_A_M2_g 3.78741e-17
C_x_PM_INV_X32%A_c21 VSS N_A_M9_g 2.3343e-17
C_x_PM_INV_X32%A_c22 VSS x_PM_INV_X32%A_19 7.35616e-18
C_x_PM_INV_X32%A_c23 VSS N_A_M1_g 3.72259e-17
C_x_PM_INV_X32%A_c24 VSS N_A_M8_g 2.45887e-17
C_x_PM_INV_X32%A_c25 VSS x_PM_INV_X32%A_9 9.48232e-18
C_x_PM_INV_X32%A_c26 VSS N_A_M0_g 5.20847e-17
C_x_PM_INV_X32%A_c27 VSS N_A_M7_g 3.2562e-17
R_x_PM_INV_X32%A_r28 x_PM_INV_X32%A_85 x_PM_INV_X32%A_84 3.4687
R_x_PM_INV_X32%A_r29 x_PM_INV_X32%A_84 x_PM_INV_X32%A_80 3.38
R_x_PM_INV_X32%A_r30 x_PM_INV_X32%A_80 x_PM_INV_X32%A_78 25.0012
R_x_PM_INV_X32%A_r31 x_PM_INV_X32%A_78 A 0.2964
R_x_PM_INV_X32%A_r32 x_PM_INV_X32%A_74 x_PM_INV_X32%A_65 3.30287
R_x_PM_INV_X32%A_r33 N_A_M6_g x_PM_INV_X32%A_65 62.79
R_x_PM_INV_X32%A_r34 x_PM_INV_X32%A_74 x_PM_INV_X32%A_61 3.30287
R_x_PM_INV_X32%A_r35 N_A_M13_g x_PM_INV_X32%A_61 39.78
R_x_PM_INV_X32%A_r36 x_PM_INV_X32%A_73 x_PM_INV_X32%A_60 1.95
R_x_PM_INV_X32%A_r37 x_PM_INV_X32%A_74 x_PM_INV_X32%A_59 0.858359
R_x_PM_INV_X32%A_r38 x_PM_INV_X32%A_60 x_PM_INV_X32%A_59 21.84
R_x_PM_INV_X32%A_r39 x_PM_INV_X32%A_73 x_PM_INV_X32%A_55 1.95
R_x_PM_INV_X32%A_r40 N_A_M5_g x_PM_INV_X32%A_55 62.79
R_x_PM_INV_X32%A_r41 x_PM_INV_X32%A_73 x_PM_INV_X32%A_51 1.95
R_x_PM_INV_X32%A_r42 N_A_M12_g x_PM_INV_X32%A_51 39.78
R_x_PM_INV_X32%A_r43 x_PM_INV_X32%A_72 x_PM_INV_X32%A_50 1.95
R_x_PM_INV_X32%A_r44 x_PM_INV_X32%A_73 x_PM_INV_X32%A_49 1.95
R_x_PM_INV_X32%A_r45 x_PM_INV_X32%A_50 x_PM_INV_X32%A_49 21.84
R_x_PM_INV_X32%A_r46 x_PM_INV_X32%A_72 x_PM_INV_X32%A_45 1.95
R_x_PM_INV_X32%A_r47 N_A_M4_g x_PM_INV_X32%A_45 62.79
R_x_PM_INV_X32%A_r48 x_PM_INV_X32%A_72 x_PM_INV_X32%A_41 1.95
R_x_PM_INV_X32%A_r49 N_A_M11_g x_PM_INV_X32%A_41 39.78
R_x_PM_INV_X32%A_r50 x_PM_INV_X32%A_71 x_PM_INV_X32%A_40 1.95
R_x_PM_INV_X32%A_r51 x_PM_INV_X32%A_72 x_PM_INV_X32%A_39 1.95
R_x_PM_INV_X32%A_r52 x_PM_INV_X32%A_40 x_PM_INV_X32%A_39 21.84
R_x_PM_INV_X32%A_r53 x_PM_INV_X32%A_71 x_PM_INV_X32%A_35 1.95
R_x_PM_INV_X32%A_r54 N_A_M3_g x_PM_INV_X32%A_35 62.79
R_x_PM_INV_X32%A_r55 x_PM_INV_X32%A_71 x_PM_INV_X32%A_31 1.95
R_x_PM_INV_X32%A_r56 N_A_M10_g x_PM_INV_X32%A_31 39.78
R_x_PM_INV_X32%A_r57 x_PM_INV_X32%A_70 x_PM_INV_X32%A_30 1.95
R_x_PM_INV_X32%A_r58 x_PM_INV_X32%A_71 x_PM_INV_X32%A_29 1.95
R_x_PM_INV_X32%A_r59 x_PM_INV_X32%A_30 x_PM_INV_X32%A_29 21.84
R_x_PM_INV_X32%A_r60 x_PM_INV_X32%A_70 x_PM_INV_X32%A_25 1.95
R_x_PM_INV_X32%A_r61 N_A_M2_g x_PM_INV_X32%A_25 62.79
R_x_PM_INV_X32%A_r62 x_PM_INV_X32%A_70 x_PM_INV_X32%A_21 1.95
R_x_PM_INV_X32%A_r63 N_A_M9_g x_PM_INV_X32%A_21 39.78
R_x_PM_INV_X32%A_r64 x_PM_INV_X32%A_69 x_PM_INV_X32%A_20 1.95
R_x_PM_INV_X32%A_r65 x_PM_INV_X32%A_70 x_PM_INV_X32%A_19 1.95
R_x_PM_INV_X32%A_r66 x_PM_INV_X32%A_20 x_PM_INV_X32%A_19 21.84
R_x_PM_INV_X32%A_r67 x_PM_INV_X32%A_69 x_PM_INV_X32%A_15 1.95
R_x_PM_INV_X32%A_r68 N_A_M1_g x_PM_INV_X32%A_15 62.79
R_x_PM_INV_X32%A_r69 x_PM_INV_X32%A_69 x_PM_INV_X32%A_11 1.95
R_x_PM_INV_X32%A_r70 N_A_M8_g x_PM_INV_X32%A_11 39.78
R_x_PM_INV_X32%A_r71 x_PM_INV_X32%A_69 x_PM_INV_X32%A_9 1.95
R_x_PM_INV_X32%A_r72 x_PM_INV_X32%A_85 x_PM_INV_X32%A_9 21.84
R_x_PM_INV_X32%A_r73 x_PM_INV_X32%A_84 x_PM_INV_X32%A_5 1.95
R_x_PM_INV_X32%A_r74 N_A_M0_g x_PM_INV_X32%A_5 58.89
R_x_PM_INV_X32%A_r75 x_PM_INV_X32%A_84 x_PM_INV_X32%A_VSS 1.95
R_x_PM_INV_X32%A_r76 N_A_M7_g x_PM_INV_X32%A_VSS 39.78
C_x_PM_INV_X32%ZN_c0 VSS x_PM_INV_X32%ZN_52 3.87686e-18
C_x_PM_INV_X32%ZN_c1 VSS x_PM_INV_X32%ZN_51 1.69506e-19
C_x_PM_INV_X32%ZN_c2 VSS x_PM_INV_X32%ZN_49 2.1837e-17
C_x_PM_INV_X32%ZN_c3 VSS N_ZN_M6_d 1.35798e-17
C_x_PM_INV_X32%ZN_c4 VSS N_ZN_M13_d 1.51004e-17
C_x_PM_INV_X32%ZN_c5 VSS x_PM_INV_X32%ZN_39 2.30575e-17
C_x_PM_INV_X32%ZN_c6 VSS N_ZN_M11_d 1.74493e-17
C_x_PM_INV_X32%ZN_c7 VSS ZN 1.71641e-17
C_x_PM_INV_X32%ZN_c8 VSS x_PM_INV_X32%ZN_27 2.28285e-17
C_x_PM_INV_X32%ZN_c9 VSS N_ZN_M2_d 1.27452e-17
C_x_PM_INV_X32%ZN_c10 VSS N_ZN_M9_d 1.74478e-17
C_x_PM_INV_X32%ZN_c11 VSS x_PM_INV_X32%ZN_17 2.25283e-17
C_x_PM_INV_X32%ZN_c12 VSS N_ZN_M0_d 2.00532e-17
C_x_PM_INV_X32%ZN_c13 VSS N_ZN_M7_d 4.8836e-17
R_x_PM_INV_X32%ZN_r14 x_PM_INV_X32%ZN_52 x_PM_INV_X32%ZN_45 0.245404
R_x_PM_INV_X32%ZN_r15 N_ZN_M6_d x_PM_INV_X32%ZN_45 0.746429
R_x_PM_INV_X32%ZN_r16 x_PM_INV_X32%ZN_52 x_PM_INV_X32%ZN_41 0.245404
R_x_PM_INV_X32%ZN_r17 N_ZN_M13_d x_PM_INV_X32%ZN_41 0.827857
R_x_PM_INV_X32%ZN_r18 x_PM_INV_X32%ZN_51 x_PM_INV_X32%ZN_40 0.0725234
R_x_PM_INV_X32%ZN_r19 x_PM_INV_X32%ZN_52 x_PM_INV_X32%ZN_39 0.0157242
R_x_PM_INV_X32%ZN_r20 x_PM_INV_X32%ZN_40 x_PM_INV_X32%ZN_39 0.870833
R_x_PM_INV_X32%ZN_r21 x_PM_INV_X32%ZN_51 x_PM_INV_X32%ZN_35 0.1196
R_x_PM_INV_X32%ZN_r22 N_ZN_M11_d x_PM_INV_X32%ZN_35 0.827857
R_x_PM_INV_X32%ZN_r23 N_ZN_M4_d ZN 0.299615
R_x_PM_INV_X32%ZN_r24 x_PM_INV_X32%ZN_51 x_PM_INV_X32%ZN_29 0.0725234
R_x_PM_INV_X32%ZN_r25 ZN x_PM_INV_X32%ZN_29 0.0876923
R_x_PM_INV_X32%ZN_r26 x_PM_INV_X32%ZN_50 x_PM_INV_X32%ZN_28 0.0950001
R_x_PM_INV_X32%ZN_r27 x_PM_INV_X32%ZN_51 x_PM_INV_X32%ZN_27 0.1196
R_x_PM_INV_X32%ZN_r28 x_PM_INV_X32%ZN_28 x_PM_INV_X32%ZN_27 0.8664
R_x_PM_INV_X32%ZN_r29 x_PM_INV_X32%ZN_50 x_PM_INV_X32%ZN_23 0.0950001
R_x_PM_INV_X32%ZN_r30 N_ZN_M2_d x_PM_INV_X32%ZN_23 0.719286
R_x_PM_INV_X32%ZN_r31 x_PM_INV_X32%ZN_50 x_PM_INV_X32%ZN_19 0.0950001
R_x_PM_INV_X32%ZN_r32 N_ZN_M9_d x_PM_INV_X32%ZN_19 0.827857
R_x_PM_INV_X32%ZN_r33 x_PM_INV_X32%ZN_49 x_PM_INV_X32%ZN_18 0.0197808
R_x_PM_INV_X32%ZN_r34 x_PM_INV_X32%ZN_50 x_PM_INV_X32%ZN_17 0.0950001
R_x_PM_INV_X32%ZN_r35 x_PM_INV_X32%ZN_18 x_PM_INV_X32%ZN_17 0.912
R_x_PM_INV_X32%ZN_r36 x_PM_INV_X32%ZN_49 x_PM_INV_X32%ZN_13 0.252765
R_x_PM_INV_X32%ZN_r37 N_ZN_M0_d x_PM_INV_X32%ZN_13 0.719286
R_x_PM_INV_X32%ZN_r38 x_PM_INV_X32%ZN_49 x_PM_INV_X32%ZN_9 0.252765
R_x_PM_INV_X32%ZN_r39 N_ZN_M7_d x_PM_INV_X32%ZN_9 0.827857
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X4 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M1 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_ZN_M1_d N_A_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_INV_X4%VSS_c0 VSS VSS 4.34747e-17
C_x_PM_INV_X4%VSS_c1 VSS x_PM_INV_X4%VSS_6 1.03625e-17
C_x_PM_INV_X4%VSS_c2 VSS N_VSS_M1_s 3.5944e-17
R_x_PM_INV_X4%VSS_r3 VSS x_PM_INV_X4%VSS_6 0.178824
R_x_PM_INV_X4%VSS_r4 x_PM_INV_X4%VSS_6 x_PM_INV_X4%VSS_2 0.264221
R_x_PM_INV_X4%VSS_r5 N_VSS_M1_s x_PM_INV_X4%VSS_2 0.990714
C_x_PM_INV_X4%VDD_c0 VSS VDD 4.30571e-17
C_x_PM_INV_X4%VDD_c1 VSS N_VDD_M0_s 2.91627e-17
C_x_PM_INV_X4%VDD_c2 VSS x_PM_INV_X4%VDD_2 1.03625e-17
R_x_PM_INV_X4%VDD_r3 VDD x_PM_INV_X4%VDD_2 0.0689273
R_x_PM_INV_X4%VDD_r4 N_VDD_M0_s x_PM_INV_X4%VDD_2 0.230714
C_x_PM_INV_X4%A_c0 VSS x_PM_INV_X4%A_13 8.11053e-18
C_x_PM_INV_X4%A_c1 VSS A 4.62983e-17
C_x_PM_INV_X4%A_c2 VSS N_A_M0_g 8.75196e-17
C_x_PM_INV_X4%A_c3 VSS N_A_M1_g 5.68033e-17
R_x_PM_INV_X4%A_r4 x_PM_INV_X4%A_16 x_PM_INV_X4%A_13 4.7687
R_x_PM_INV_X4%A_r5 x_PM_INV_X4%A_15 x_PM_INV_X4%A_13 4.7687
R_x_PM_INV_X4%A_r6 x_PM_INV_X4%A_13 x_PM_INV_X4%A_11 25.0012
R_x_PM_INV_X4%A_r7 x_PM_INV_X4%A_11 A 0.141961
R_x_PM_INV_X4%A_r8 N_A_M0_g x_PM_INV_X4%A_16 70.98
R_x_PM_INV_X4%A_r9 N_A_M1_g x_PM_INV_X4%A_15 37.44
C_x_PM_INV_X4%ZN_c0 VSS x_PM_INV_X4%ZN_15 5.13456e-18
C_x_PM_INV_X4%ZN_c1 VSS x_PM_INV_X4%ZN_14 6.30981e-17
C_x_PM_INV_X4%ZN_c2 VSS N_ZN_M0_d 5.2927e-17
C_x_PM_INV_X4%ZN_c3 VSS x_PM_INV_X4%ZN_9 4.93901e-18
C_x_PM_INV_X4%ZN_c4 VSS ZN 5.2927e-17
R_x_PM_INV_X4%ZN_r5 x_PM_INV_X4%ZN_14 x_PM_INV_X4%ZN_15 2.98571
R_x_PM_INV_X4%ZN_r6 x_PM_INV_X4%ZN_14 x_PM_INV_X4%ZN_9 0.217071
R_x_PM_INV_X4%ZN_r7 N_ZN_M0_d x_PM_INV_X4%ZN_9 0.64
R_x_PM_INV_X4%ZN_r8 N_ZN_M1_d ZN 0.03
R_x_PM_INV_X4%ZN_r9 x_PM_INV_X4%ZN_15 x_PM_INV_X4%ZN_3 0.217071
R_x_PM_INV_X4%ZN_r10 N_ZN_M1_d x_PM_INV_X4%ZN_3 0.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   INV_X8.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT INV_X8 VSS VDD A ZN
*.PININFO VSS:B VDD:B A:I ZN:O
M_M2 N_ZN_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
M_M3 N_VDD_M1_d N_A_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_ZN_M2_d N_A_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_VSS_M3_d N_A_M3_g N_ZN_M2_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_INV_X8%VSS_c0 VSS N_VSS_M3_d 2.47387e-17
C_x_PM_INV_X8%VSS_c1 VSS x_PM_INV_X8%VSS_8 1.14613e-17
C_x_PM_INV_X8%VSS_c2 VSS x_PM_INV_X8%VSS_7 4.52573e-17
C_x_PM_INV_X8%VSS_c3 VSS N_VSS_M2_s 1.62856e-17
R_x_PM_INV_X8%VSS_r4 N_VSS_M3_d x_PM_INV_X8%VSS_11 0.990714
R_x_PM_INV_X8%VSS_r5 VSS x_PM_INV_X8%VSS_8 0.357647
R_x_PM_INV_X8%VSS_r6 x_PM_INV_X8%VSS_11 x_PM_INV_X8%VSS_7 0.264221
R_x_PM_INV_X8%VSS_r7 VSS x_PM_INV_X8%VSS_7 0.324118
R_x_PM_INV_X8%VSS_r8 x_PM_INV_X8%VSS_8 x_PM_INV_X8%VSS_3 0.264221
R_x_PM_INV_X8%VSS_r9 N_VSS_M2_s x_PM_INV_X8%VSS_3 0.230714
C_x_PM_INV_X8%VDD_c0 VSS VDD 1.1518e-17
C_x_PM_INV_X8%VDD_c1 VSS N_VDD_M1_d 1.55948e-17
C_x_PM_INV_X8%VDD_c2 VSS x_PM_INV_X8%VDD_7 3.62415e-17
C_x_PM_INV_X8%VDD_c3 VSS N_VDD_M0_s 1.5851e-17
R_x_PM_INV_X8%VDD_r4 x_PM_INV_X8%VDD_16 VDD 0.2432
R_x_PM_INV_X8%VDD_r5 x_PM_INV_X8%VDD_15 VDD 0.0881799
R_x_PM_INV_X8%VDD_r6 N_VDD_M1_d x_PM_INV_X8%VDD_9 0.230714
R_x_PM_INV_X8%VDD_r7 x_PM_INV_X8%VDD_16 x_PM_INV_X8%VDD_8 0.095
R_x_PM_INV_X8%VDD_r8 x_PM_INV_X8%VDD_9 x_PM_INV_X8%VDD_7 0.264221
R_x_PM_INV_X8%VDD_r9 x_PM_INV_X8%VDD_8 x_PM_INV_X8%VDD_7 0.681765
R_x_PM_INV_X8%VDD_r10 N_VDD_M0_s x_PM_INV_X8%VDD_15 0.230714
C_x_PM_INV_X8%A_c0 VSS x_PM_INV_X8%A_30 4.88818e-18
C_x_PM_INV_X8%A_c1 VSS x_PM_INV_X8%A_23 8.43281e-17
C_x_PM_INV_X8%A_c2 VSS x_PM_INV_X8%A_19 2.20635e-18
C_x_PM_INV_X8%A_c3 VSS N_A_M1_g 5.74073e-17
C_x_PM_INV_X8%A_c4 VSS N_A_M3_g 3.90714e-17
C_x_PM_INV_X8%A_c5 VSS x_PM_INV_X8%A_9 9.66323e-18
C_x_PM_INV_X8%A_c6 VSS N_A_M0_g 5.54917e-17
C_x_PM_INV_X8%A_c7 VSS N_A_M2_g 3.11794e-17
R_x_PM_INV_X8%A_r8 x_PM_INV_X8%A_30 x_PM_INV_X8%A_29 3.4687
R_x_PM_INV_X8%A_r9 x_PM_INV_X8%A_29 x_PM_INV_X8%A_25 3.38
R_x_PM_INV_X8%A_r10 x_PM_INV_X8%A_25 x_PM_INV_X8%A_23 25.0012
R_x_PM_INV_X8%A_r11 x_PM_INV_X8%A_23 A 0.0690118
R_x_PM_INV_X8%A_r12 x_PM_INV_X8%A_19 x_PM_INV_X8%A_15 3.30287
R_x_PM_INV_X8%A_r13 N_A_M1_g x_PM_INV_X8%A_15 76.44
R_x_PM_INV_X8%A_r14 x_PM_INV_X8%A_19 x_PM_INV_X8%A_11 3.30287
R_x_PM_INV_X8%A_r15 N_A_M3_g x_PM_INV_X8%A_11 35.88
R_x_PM_INV_X8%A_r16 x_PM_INV_X8%A_19 x_PM_INV_X8%A_9 0.858359
R_x_PM_INV_X8%A_r17 x_PM_INV_X8%A_30 x_PM_INV_X8%A_9 21.84
R_x_PM_INV_X8%A_r18 x_PM_INV_X8%A_29 x_PM_INV_X8%A_5 1.95
R_x_PM_INV_X8%A_r19 N_A_M0_g x_PM_INV_X8%A_5 72.54
R_x_PM_INV_X8%A_r20 x_PM_INV_X8%A_29 x_PM_INV_X8%A_VSS 1.95
R_x_PM_INV_X8%A_r21 N_A_M2_g x_PM_INV_X8%A_VSS 35.88
C_x_PM_INV_X8%ZN_c0 VSS N_ZN_M2_d 1.51667e-16
R_x_PM_INV_X8%ZN_r1 N_ZN_M0_d ZN 1.72357
R_x_PM_INV_X8%ZN_r2 ZN N_ZN_M2_d 1.18071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC0_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC0_X1 VSS VDD Z
*.PININFO VSS:B VDD:B Z:O
M_M1 N_VDD_M0_d N_4_M0_g N_4_M0_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M0 N_Z_M1_d N_4_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_LOGIC0_X1%VSS_c0 VSS VSS 5.2166e-17
R_x_PM_LOGIC0_X1%VSS_r1 VSS N_VSS_M1_s 0.126802
C_x_PM_LOGIC0_X1%VDD_c0 VSS N_VDD_M0_d 2.1513e-17
C_x_PM_LOGIC0_X1%VDD_c1 VSS VDD 3.75225e-17
R_x_PM_LOGIC0_X1%VDD_r2 N_VDD_M0_d VDD 0.0059375
C_x_PM_LOGIC0_X1%Z_c0 VSS N_Z_M1_d 3.93876e-17
R_x_PM_LOGIC0_X1%Z_r1 Z N_Z_M1_d 0.3325
C_x_PM_LOGIC0_X1%4_c0 VSS x_PM_LOGIC0_X1%4_23 5.25282e-18
C_x_PM_LOGIC0_X1%4_c1 VSS x_PM_LOGIC0_X1%4_20 4.8368e-18
C_x_PM_LOGIC0_X1%4_c2 VSS x_PM_LOGIC0_X1%4_18 7.68294e-18
C_x_PM_LOGIC0_X1%4_c3 VSS N_4_M0_s 3.18303e-17
C_x_PM_LOGIC0_X1%4_c4 VSS x_PM_LOGIC0_X1%4_12 2.20181e-17
C_x_PM_LOGIC0_X1%4_c5 VSS x_PM_LOGIC0_X1%4_10 4.14628e-17
C_x_PM_LOGIC0_X1%4_c6 VSS x_PM_LOGIC0_X1%4_5 2.42541e-17
C_x_PM_LOGIC0_X1%4_c7 VSS x_PM_LOGIC0_X1%4_VSS 2.91889e-17
R_x_PM_LOGIC0_X1%4_r8 x_PM_LOGIC0_X1%4_25 x_PM_LOGIC0_X1%4_23 4.7687
R_x_PM_LOGIC0_X1%4_r9 x_PM_LOGIC0_X1%4_23 x_PM_LOGIC0_X1%4_20 25.0012
R_x_PM_LOGIC0_X1%4_r10 x_PM_LOGIC0_X1%4_20 x_PM_LOGIC0_X1%4_18 0.176429
R_x_PM_LOGIC0_X1%4_r11 x_PM_LOGIC0_X1%4_18 x_PM_LOGIC0_X1%4_14 0.241334
R_x_PM_LOGIC0_X1%4_r12 N_4_M0_s x_PM_LOGIC0_X1%4_14 0.668519
R_x_PM_LOGIC0_X1%4_r13 x_PM_LOGIC0_X1%4_12 x_PM_LOGIC0_X1%4_25 47.58
R_x_PM_LOGIC0_X1%4_r14 x_PM_LOGIC0_X1%4_10 x_PM_LOGIC0_X1%4_23 4.7687
R_x_PM_LOGIC0_X1%4_r15 x_PM_LOGIC0_X1%4_10 x_PM_LOGIC0_X1%4_9 76.44
R_x_PM_LOGIC0_X1%4_r16 x_PM_LOGIC0_X1%4_12 x_PM_LOGIC0_X1%4_5 4.35808
R_x_PM_LOGIC0_X1%4_r17 N_4_M0_g x_PM_LOGIC0_X1%4_5 14.82
R_x_PM_LOGIC0_X1%4_r18 x_PM_LOGIC0_X1%4_9 x_PM_LOGIC0_X1%4_VSS 4.35808
R_x_PM_LOGIC0_X1%4_r19 N_4_M1_g x_PM_LOGIC0_X1%4_VSS 14.82
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   LOGIC1_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT LOGIC1_X1 VSS VDD Z
*.PININFO VSS:B VDD:B Z:O
M_M1 N_VDD_M0_d N_4_M0_g N_Z_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_4_M1_d N_4_M1_g N_VSS_M1_s VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_LOGIC1_X1%VSS_c0 VSS VSS 5.62036e-17
R_x_PM_LOGIC1_X1%VSS_r1 VSS N_VSS_M1_s 0.0545692
C_x_PM_LOGIC1_X1%VDD_c0 VSS N_VDD_M0_d 5.25879e-17
R_x_PM_LOGIC1_X1%VDD_r1 VDD N_VDD_M0_d 0.0603477
C_x_PM_LOGIC1_X1%Z_c0 VSS Z 8.05565e-17
R_x_PM_LOGIC1_X1%Z_r1 N_Z_M0_s Z 0.702174
C_x_PM_LOGIC1_X1%4_c0 VSS x_PM_LOGIC1_X1%4_24 2.80846e-18
C_x_PM_LOGIC1_X1%4_c1 VSS x_PM_LOGIC1_X1%4_21 1.17455e-17
C_x_PM_LOGIC1_X1%4_c2 VSS x_PM_LOGIC1_X1%4_19 5.89351e-18
C_x_PM_LOGIC1_X1%4_c3 VSS x_PM_LOGIC1_X1%4_14 2.4121e-17
C_x_PM_LOGIC1_X1%4_c4 VSS x_PM_LOGIC1_X1%4_12 7.15003e-17
C_x_PM_LOGIC1_X1%4_c5 VSS x_PM_LOGIC1_X1%4_5 2.87262e-17
C_x_PM_LOGIC1_X1%4_c6 VSS x_PM_LOGIC1_X1%4_VSS 3.45699e-17
R_x_PM_LOGIC1_X1%4_r7 x_PM_LOGIC1_X1%4_24 x_PM_LOGIC1_X1%4_21 4.7687
R_x_PM_LOGIC1_X1%4_r8 x_PM_LOGIC1_X1%4_21 x_PM_LOGIC1_X1%4_19 25.0012
R_x_PM_LOGIC1_X1%4_r9 x_PM_LOGIC1_X1%4_19 x_PM_LOGIC1_X1%4_18 0.239565
R_x_PM_LOGIC1_X1%4_r10 x_PM_LOGIC1_X1%4_18 x_PM_LOGIC1_X1%4_14 0.229077
R_x_PM_LOGIC1_X1%4_r11 N_4_M1_d x_PM_LOGIC1_X1%4_14 0.230714
R_x_PM_LOGIC1_X1%4_r12 x_PM_LOGIC1_X1%4_12 x_PM_LOGIC1_X1%4_24 124.02
R_x_PM_LOGIC1_X1%4_r13 x_PM_LOGIC1_X1%4_21 x_PM_LOGIC1_X1%4_9 18.46
R_x_PM_LOGIC1_X1%4_r14 x_PM_LOGIC1_X1%4_9 x_PM_LOGIC1_X1%4_5 4.58872
R_x_PM_LOGIC1_X1%4_r15 N_4_M1_g x_PM_LOGIC1_X1%4_5 14.82
R_x_PM_LOGIC1_X1%4_r16 x_PM_LOGIC1_X1%4_12 x_PM_LOGIC1_X1%4_VSS 4.35808
R_x_PM_LOGIC1_X1%4_r17 N_4_M0_g x_PM_LOGIC1_X1%4_VSS 18.33
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X1 VSS VDD S A B Z
*.PININFO VSS:B VDD:B S:I A:I B:I Z:O
M_M6 N_VDD_M0_d N_S_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M7 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M8 N_6_M2_d N_S_M2_g N_5_M1_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M9 N_5_M3_d N_B_M3_g N_6_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M10 N_VDD_M4_d N_A_M4_g N_5_M3_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M11 N_Z_M5_d N_6_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M6_d N_S_M6_g N_3_M6_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 noxref_10 N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_6_M8_d N_A_M8_g noxref_10 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 noxref_11 N_S_M9_g N_6_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M10_d N_B_M10_g noxref_11 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_Z_M11_d N_6_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_MUX2_X1%VSS_c0 VSS x_PM_MUX2_X1%VSS_18 3.55445e-17
C_x_PM_MUX2_X1%VSS_c1 VSS x_PM_MUX2_X1%VSS_17 3.9063e-17
C_x_PM_MUX2_X1%VSS_c2 VSS x_PM_MUX2_X1%VSS_14 2.41704e-17
C_x_PM_MUX2_X1%VSS_c3 VSS x_PM_MUX2_X1%VSS_9 1.0198e-16
C_x_PM_MUX2_X1%VSS_c4 VSS N_VSS_M6_d 1.69206e-17
R_x_PM_MUX2_X1%VSS_r5 x_PM_MUX2_X1%VSS_18 x_PM_MUX2_X1%VSS_14 0.145286
R_x_PM_MUX2_X1%VSS_r6 x_PM_MUX2_X1%VSS_14 N_VSS_M10_d 0.543196
R_x_PM_MUX2_X1%VSS_r7 x_PM_MUX2_X1%VSS_17 x_PM_MUX2_X1%VSS_10 0.0731438
R_x_PM_MUX2_X1%VSS_r8 VSS x_PM_MUX2_X1%VSS_10 0.793529
R_x_PM_MUX2_X1%VSS_r9 x_PM_MUX2_X1%VSS_18 x_PM_MUX2_X1%VSS_9 0.0731438
R_x_PM_MUX2_X1%VSS_r10 VSS x_PM_MUX2_X1%VSS_9 0.76
R_x_PM_MUX2_X1%VSS_r11 x_PM_MUX2_X1%VSS_17 x_PM_MUX2_X1%VSS_5 0.145286
R_x_PM_MUX2_X1%VSS_r12 N_VSS_M6_d x_PM_MUX2_X1%VSS_5 0.230714
C_x_PM_MUX2_X1%VDD_c0 VSS x_PM_MUX2_X1%VDD_20 3.19424e-17
C_x_PM_MUX2_X1%VDD_c1 VSS x_PM_MUX2_X1%VDD_19 4.54158e-18
C_x_PM_MUX2_X1%VDD_c2 VSS N_VDD_M4_d 3.37355e-17
C_x_PM_MUX2_X1%VDD_c3 VSS x_PM_MUX2_X1%VDD_11 1.33087e-16
C_x_PM_MUX2_X1%VDD_c4 VSS N_VDD_M0_d 3.93525e-17
C_x_PM_MUX2_X1%VDD_c5 VSS x_PM_MUX2_X1%VDD_3 2.76517e-17
R_x_PM_MUX2_X1%VDD_r6 x_PM_MUX2_X1%VDD_20 x_PM_MUX2_X1%VDD_13 0.145286
R_x_PM_MUX2_X1%VDD_r7 N_VDD_M4_d x_PM_MUX2_X1%VDD_13 0.692143
R_x_PM_MUX2_X1%VDD_r8 x_PM_MUX2_X1%VDD_19 x_PM_MUX2_X1%VDD_12 0.0731438
R_x_PM_MUX2_X1%VDD_r9 x_PM_MUX2_X1%VDD_20 x_PM_MUX2_X1%VDD_11 0.0731438
R_x_PM_MUX2_X1%VDD_r10 x_PM_MUX2_X1%VDD_12 x_PM_MUX2_X1%VDD_11 1.55353
R_x_PM_MUX2_X1%VDD_r11 x_PM_MUX2_X1%VDD_19 x_PM_MUX2_X1%VDD_7 0.145286
R_x_PM_MUX2_X1%VDD_r12 N_VDD_M0_d x_PM_MUX2_X1%VDD_7 0.936429
R_x_PM_MUX2_X1%VDD_r13 x_PM_MUX2_X1%VDD_19 x_PM_MUX2_X1%VDD_3 0.0731438
R_x_PM_MUX2_X1%VDD_r14 VDD x_PM_MUX2_X1%VDD_3 0.268235
C_x_PM_MUX2_X1%3_c0 VSS x_PM_MUX2_X1%3_29 1.30608e-17
C_x_PM_MUX2_X1%3_c1 VSS x_PM_MUX2_X1%3_26 2.56906e-18
C_x_PM_MUX2_X1%3_c2 VSS N_3_M6_s 3.04678e-17
C_x_PM_MUX2_X1%3_c3 VSS x_PM_MUX2_X1%3_19 3.65764e-17
C_x_PM_MUX2_X1%3_c4 VSS N_3_M0_s 1.91197e-17
C_x_PM_MUX2_X1%3_c5 VSS x_PM_MUX2_X1%3_12 5.89933e-17
C_x_PM_MUX2_X1%3_c6 VSS N_3_M1_g 3.02435e-17
C_x_PM_MUX2_X1%3_c7 VSS N_3_M7_g 8.48916e-17
R_x_PM_MUX2_X1%3_r8 x_PM_MUX2_X1%3_29 x_PM_MUX2_X1%3_27 5.46
R_x_PM_MUX2_X1%3_r9 x_PM_MUX2_X1%3_27 x_PM_MUX2_X1%3_19 25.0012
R_x_PM_MUX2_X1%3_r10 x_PM_MUX2_X1%3_26 x_PM_MUX2_X1%3_17 0.0569232
R_x_PM_MUX2_X1%3_r11 x_PM_MUX2_X1%3_19 x_PM_MUX2_X1%3_17 1.07214
R_x_PM_MUX2_X1%3_r12 x_PM_MUX2_X1%3_26 x_PM_MUX2_X1%3_13 0.143785
R_x_PM_MUX2_X1%3_r13 N_3_M0_s x_PM_MUX2_X1%3_13 0.369444
R_x_PM_MUX2_X1%3_r14 x_PM_MUX2_X1%3_26 x_PM_MUX2_X1%3_12 0.143785
R_x_PM_MUX2_X1%3_r15 x_PM_MUX2_X1%3_11 N_3_M6_s 0.30478
R_x_PM_MUX2_X1%3_r16 x_PM_MUX2_X1%3_12 x_PM_MUX2_X1%3_11 3.14857
R_x_PM_MUX2_X1%3_r17 x_PM_MUX2_X1%3_29 x_PM_MUX2_X1%3_5 1.95
R_x_PM_MUX2_X1%3_r18 N_3_M1_g x_PM_MUX2_X1%3_5 21.84
R_x_PM_MUX2_X1%3_r19 x_PM_MUX2_X1%3_29 x_PM_MUX2_X1%3_VSS 1.95
R_x_PM_MUX2_X1%3_r20 N_3_M7_g x_PM_MUX2_X1%3_VSS 108.42
C_x_PM_MUX2_X1%S_c0 VSS S 4.82511e-17
C_x_PM_MUX2_X1%S_c1 VSS x_PM_MUX2_X1%S_23 1.03759e-17
C_x_PM_MUX2_X1%S_c2 VSS N_S_M9_g 4.83006e-17
C_x_PM_MUX2_X1%S_c3 VSS x_PM_MUX2_X1%S_16 6.95182e-18
C_x_PM_MUX2_X1%S_c4 VSS x_PM_MUX2_X1%S_15 2.54316e-17
C_x_PM_MUX2_X1%S_c5 VSS N_S_M2_g 8.26899e-17
C_x_PM_MUX2_X1%S_c6 VSS x_PM_MUX2_X1%S_10 6.3711e-18
C_x_PM_MUX2_X1%S_c7 VSS x_PM_MUX2_X1%S_9 4.30811e-17
C_x_PM_MUX2_X1%S_c8 VSS N_S_M0_g 8.59414e-17
C_x_PM_MUX2_X1%S_c9 VSS N_S_M6_g 4.74454e-17
R_x_PM_MUX2_X1%S_r10 x_PM_MUX2_X1%S_30 x_PM_MUX2_X1%S_23 4.74714
R_x_PM_MUX2_X1%S_r11 x_PM_MUX2_X1%S_29 x_PM_MUX2_X1%S_23 4.74714
R_x_PM_MUX2_X1%S_r12 x_PM_MUX2_X1%S_23 x_PM_MUX2_X1%S_21 25.0012
R_x_PM_MUX2_X1%S_r13 S x_PM_MUX2_X1%S_21 0.223929
R_x_PM_MUX2_X1%S_r14 N_S_M9_g x_PM_MUX2_X1%S_17 45.24
R_x_PM_MUX2_X1%S_r15 x_PM_MUX2_X1%S_17 x_PM_MUX2_X1%S_15 4.35808
R_x_PM_MUX2_X1%S_r16 x_PM_MUX2_X1%S_16 x_PM_MUX2_X1%S_15 22.62
R_x_PM_MUX2_X1%S_r17 N_S_M2_g x_PM_MUX2_X1%S_12 33.54
R_x_PM_MUX2_X1%S_r18 x_PM_MUX2_X1%S_16 x_PM_MUX2_X1%S_11 4.35808
R_x_PM_MUX2_X1%S_r19 N_S_M2_g x_PM_MUX2_X1%S_11 88.92
R_x_PM_MUX2_X1%S_r20 x_PM_MUX2_X1%S_12 x_PM_MUX2_X1%S_9 4.35808
R_x_PM_MUX2_X1%S_r21 x_PM_MUX2_X1%S_10 x_PM_MUX2_X1%S_9 51.48
R_x_PM_MUX2_X1%S_r22 N_S_M0_g x_PM_MUX2_X1%S_30 87.36
R_x_PM_MUX2_X1%S_r23 x_PM_MUX2_X1%S_10 x_PM_MUX2_X1%S_6 4.35808
R_x_PM_MUX2_X1%S_r24 N_S_M0_g x_PM_MUX2_X1%S_6 33.54
R_x_PM_MUX2_X1%S_r25 N_S_M6_g x_PM_MUX2_X1%S_29 42.9
C_x_PM_MUX2_X1%5_c0 VSS x_PM_MUX2_X1%5_8 2.21652e-17
C_x_PM_MUX2_X1%5_c1 VSS x_PM_MUX2_X1%5_7 1.10942e-16
C_x_PM_MUX2_X1%5_c2 VSS N_5_M1_d 2.65534e-17
C_x_PM_MUX2_X1%5_c3 VSS N_5_M3_d 2.75094e-17
R_x_PM_MUX2_X1%5_r4 x_PM_MUX2_X1%5_9 x_PM_MUX2_X1%5_7 0.212317
R_x_PM_MUX2_X1%5_r5 x_PM_MUX2_X1%5_8 x_PM_MUX2_X1%5_7 1.62857
R_x_PM_MUX2_X1%5_r6 x_PM_MUX2_X1%5_8 x_PM_MUX2_X1%5_3 0.212317
R_x_PM_MUX2_X1%5_r7 N_5_M1_d x_PM_MUX2_X1%5_3 0.203571
R_x_PM_MUX2_X1%5_r8 N_5_M3_d x_PM_MUX2_X1%5_9 0.203571
C_x_PM_MUX2_X1%6_c0 VSS x_PM_MUX2_X1%6_28 1.2062e-17
C_x_PM_MUX2_X1%6_c1 VSS x_PM_MUX2_X1%6_21 3.65093e-17
C_x_PM_MUX2_X1%6_c2 VSS x_PM_MUX2_X1%6_17 1.51535e-16
C_x_PM_MUX2_X1%6_c3 VSS x_PM_MUX2_X1%6_16 1.04178e-16
C_x_PM_MUX2_X1%6_c4 VSS x_PM_MUX2_X1%6_15 7.97687e-17
C_x_PM_MUX2_X1%6_c5 VSS x_PM_MUX2_X1%6_14 8.31906e-17
C_x_PM_MUX2_X1%6_c6 VSS N_6_M5_g 3.48608e-17
C_x_PM_MUX2_X1%6_c7 VSS N_6_M11_g 9.06669e-17
R_x_PM_MUX2_X1%6_r8 x_PM_MUX2_X1%6_28 x_PM_MUX2_X1%6_26 3.9
R_x_PM_MUX2_X1%6_r9 x_PM_MUX2_X1%6_24 x_PM_MUX2_X1%6_21 0.176429
R_x_PM_MUX2_X1%6_r10 x_PM_MUX2_X1%6_26 x_PM_MUX2_X1%6_21 25.0012
R_x_PM_MUX2_X1%6_r11 N_6_M2_d x_PM_MUX2_X1%6_17 0.519592
R_x_PM_MUX2_X1%6_r12 N_6_M2_d x_PM_MUX2_X1%6_16 0.278601
R_x_PM_MUX2_X1%6_r13 x_PM_MUX2_X1%6_24 x_PM_MUX2_X1%6_15 0.095
R_x_PM_MUX2_X1%6_r14 x_PM_MUX2_X1%6_16 x_PM_MUX2_X1%6_15 1.84571
R_x_PM_MUX2_X1%6_r15 x_PM_MUX2_X1%6_14 N_6_M8_d 0.570339
R_x_PM_MUX2_X1%6_r16 x_PM_MUX2_X1%6_14 x_PM_MUX2_X1%6_11 0.212317
R_x_PM_MUX2_X1%6_r17 x_PM_MUX2_X1%6_17 x_PM_MUX2_X1%6_11 3.88143
R_x_PM_MUX2_X1%6_r18 x_PM_MUX2_X1%6_28 x_PM_MUX2_X1%6_5 1.95
R_x_PM_MUX2_X1%6_r19 N_6_M5_g x_PM_MUX2_X1%6_5 27.69
R_x_PM_MUX2_X1%6_r20 x_PM_MUX2_X1%6_28 x_PM_MUX2_X1%6_VSS 1.95
R_x_PM_MUX2_X1%6_r21 N_6_M11_g x_PM_MUX2_X1%6_VSS 106.08
C_x_PM_MUX2_X1%A_c0 VSS x_PM_MUX2_X1%A_27 1.13255e-17
C_x_PM_MUX2_X1%A_c1 VSS x_PM_MUX2_X1%A_17 7.42018e-17
C_x_PM_MUX2_X1%A_c2 VSS x_PM_MUX2_X1%A_16 4.79109e-17
C_x_PM_MUX2_X1%A_c3 VSS x_PM_MUX2_X1%A_12 1.78103e-17
C_x_PM_MUX2_X1%A_c4 VSS x_PM_MUX2_X1%A_10 1.90561e-16
C_x_PM_MUX2_X1%A_c5 VSS N_A_M4_g 4.94682e-17
C_x_PM_MUX2_X1%A_c6 VSS N_A_M8_g 3.39008e-17
R_x_PM_MUX2_X1%A_r7 x_PM_MUX2_X1%A_27 x_PM_MUX2_X1%A_19 1.82
R_x_PM_MUX2_X1%A_r8 x_PM_MUX2_X1%A_19 x_PM_MUX2_X1%A_17 25.0012
R_x_PM_MUX2_X1%A_r9 x_PM_MUX2_X1%A_17 x_PM_MUX2_X1%A_16 1.26214
R_x_PM_MUX2_X1%A_r10 x_PM_MUX2_X1%A_12 x_PM_MUX2_X1%A_21 5.46
R_x_PM_MUX2_X1%A_r11 x_PM_MUX2_X1%A_12 x_PM_MUX2_X1%A_10 25.0012
R_x_PM_MUX2_X1%A_r12 A x_PM_MUX2_X1%A_10 0.941364
R_x_PM_MUX2_X1%A_r13 x_PM_MUX2_X1%A_16 x_PM_MUX2_X1%A_9 0.226245
R_x_PM_MUX2_X1%A_r14 A x_PM_MUX2_X1%A_9 0.604545
R_x_PM_MUX2_X1%A_r15 x_PM_MUX2_X1%A_27 x_PM_MUX2_X1%A_5 1.95
R_x_PM_MUX2_X1%A_r16 N_A_M4_g x_PM_MUX2_X1%A_5 46.8
R_x_PM_MUX2_X1%A_r17 x_PM_MUX2_X1%A_21 x_PM_MUX2_X1%A_VSS 1.95
R_x_PM_MUX2_X1%A_r18 N_A_M8_g x_PM_MUX2_X1%A_VSS 21.84
C_x_PM_MUX2_X1%B_c0 VSS B 8.40004e-17
C_x_PM_MUX2_X1%B_c1 VSS x_PM_MUX2_X1%B_10 1.74055e-17
C_x_PM_MUX2_X1%B_c2 VSS x_PM_MUX2_X1%B_9 7.8565e-18
C_x_PM_MUX2_X1%B_c3 VSS N_B_M10_g 5.59843e-17
C_x_PM_MUX2_X1%B_c4 VSS N_B_M3_g 6.5122e-17
R_x_PM_MUX2_X1%B_r5 x_PM_MUX2_X1%B_16 x_PM_MUX2_X1%B_14 25.0012
R_x_PM_MUX2_X1%B_r6 x_PM_MUX2_X1%B_14 B 0.4332
R_x_PM_MUX2_X1%B_r7 x_PM_MUX2_X1%B_16 x_PM_MUX2_X1%B_10 13.26
R_x_PM_MUX2_X1%B_r8 x_PM_MUX2_X1%B_16 x_PM_MUX2_X1%B_9 1.82
R_x_PM_MUX2_X1%B_r9 x_PM_MUX2_X1%B_10 x_PM_MUX2_X1%B_5 4.58872
R_x_PM_MUX2_X1%B_r10 N_B_M10_g x_PM_MUX2_X1%B_5 64.74
R_x_PM_MUX2_X1%B_r11 x_PM_MUX2_X1%B_9 x_PM_MUX2_X1%B_VSS 4.58872
R_x_PM_MUX2_X1%B_r12 N_B_M3_g x_PM_MUX2_X1%B_VSS 69.03
C_x_PM_MUX2_X1%Z_c0 VSS N_Z_M11_d 1.24703e-16
R_x_PM_MUX2_X1%Z_r1 N_Z_M5_d Z 2.70071
R_x_PM_MUX2_X1%Z_r2 Z N_Z_M11_d 2.15786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   MUX2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT MUX2_X2 VSS VDD S A B Z
*.PININFO VSS:B VDD:B S:I A:I B:I Z:O
M_M6 N_VDD_M0_d N_S_M0_g N_3_M0_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M7 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M8 N_6_M2_d N_S_M2_g N_5_M1_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M9 N_5_M3_d N_B_M3_g N_6_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M10 N_VDD_M4_d N_A_M4_g N_5_M3_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M11 N_Z_M5_d N_6_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M6_d N_S_M6_g N_3_M6_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 noxref_10 N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_6_M8_d N_A_M8_g noxref_10 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 noxref_11 N_S_M9_g N_6_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M10_d N_B_M10_g noxref_11 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_Z_M11_d N_6_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_MUX2_X2%VSS_c0 VSS x_PM_MUX2_X2%VSS_20 3.76443e-17
C_x_PM_MUX2_X2%VSS_c1 VSS x_PM_MUX2_X2%VSS_19 3.90623e-17
C_x_PM_MUX2_X2%VSS_c2 VSS N_VSS_M10_d 1.3887e-17
C_x_PM_MUX2_X2%VSS_c3 VSS x_PM_MUX2_X2%VSS_9 1.0157e-16
C_x_PM_MUX2_X2%VSS_c4 VSS N_VSS_M6_d 1.69202e-17
R_x_PM_MUX2_X2%VSS_r5 x_PM_MUX2_X2%VSS_20 x_PM_MUX2_X2%VSS_13 0.145286
R_x_PM_MUX2_X2%VSS_r6 N_VSS_M10_d x_PM_MUX2_X2%VSS_13 0.230714
R_x_PM_MUX2_X2%VSS_r7 x_PM_MUX2_X2%VSS_19 x_PM_MUX2_X2%VSS_10 0.0731438
R_x_PM_MUX2_X2%VSS_r8 VSS x_PM_MUX2_X2%VSS_10 0.793529
R_x_PM_MUX2_X2%VSS_r9 x_PM_MUX2_X2%VSS_20 x_PM_MUX2_X2%VSS_9 0.0731438
R_x_PM_MUX2_X2%VSS_r10 VSS x_PM_MUX2_X2%VSS_9 0.76
R_x_PM_MUX2_X2%VSS_r11 x_PM_MUX2_X2%VSS_19 x_PM_MUX2_X2%VSS_5 0.145286
R_x_PM_MUX2_X2%VSS_r12 N_VSS_M6_d x_PM_MUX2_X2%VSS_5 0.230714
C_x_PM_MUX2_X2%VDD_c0 VSS x_PM_MUX2_X2%VDD_18 3.13797e-17
C_x_PM_MUX2_X2%VDD_c1 VSS x_PM_MUX2_X2%VDD_17 4.6069e-18
C_x_PM_MUX2_X2%VDD_c2 VSS x_PM_MUX2_X2%VDD_14 4.25003e-17
C_x_PM_MUX2_X2%VDD_c3 VSS x_PM_MUX2_X2%VDD_11 1.00754e-16
C_x_PM_MUX2_X2%VDD_c4 VSS N_VDD_M0_d 3.9264e-17
C_x_PM_MUX2_X2%VDD_c5 VSS x_PM_MUX2_X2%VDD_3 2.79312e-17
R_x_PM_MUX2_X2%VDD_r6 x_PM_MUX2_X2%VDD_18 x_PM_MUX2_X2%VDD_14 0.145286
R_x_PM_MUX2_X2%VDD_r7 x_PM_MUX2_X2%VDD_14 N_VDD_M4_d 0.543196
R_x_PM_MUX2_X2%VDD_r8 x_PM_MUX2_X2%VDD_17 x_PM_MUX2_X2%VDD_12 0.0731438
R_x_PM_MUX2_X2%VDD_r9 x_PM_MUX2_X2%VDD_18 x_PM_MUX2_X2%VDD_11 0.0731438
R_x_PM_MUX2_X2%VDD_r10 x_PM_MUX2_X2%VDD_12 x_PM_MUX2_X2%VDD_11 1.57588
R_x_PM_MUX2_X2%VDD_r11 x_PM_MUX2_X2%VDD_17 x_PM_MUX2_X2%VDD_7 0.145286
R_x_PM_MUX2_X2%VDD_r12 N_VDD_M0_d x_PM_MUX2_X2%VDD_7 0.909286
R_x_PM_MUX2_X2%VDD_r13 x_PM_MUX2_X2%VDD_17 x_PM_MUX2_X2%VDD_3 0.0731438
R_x_PM_MUX2_X2%VDD_r14 VDD x_PM_MUX2_X2%VDD_3 0.268235
C_x_PM_MUX2_X2%3_c0 VSS x_PM_MUX2_X2%3_29 1.30528e-17
C_x_PM_MUX2_X2%3_c1 VSS x_PM_MUX2_X2%3_26 2.57034e-18
C_x_PM_MUX2_X2%3_c2 VSS N_3_M6_s 3.04862e-17
C_x_PM_MUX2_X2%3_c3 VSS x_PM_MUX2_X2%3_19 3.65559e-17
C_x_PM_MUX2_X2%3_c4 VSS N_3_M0_s 1.94105e-17
C_x_PM_MUX2_X2%3_c5 VSS x_PM_MUX2_X2%3_12 5.93543e-17
C_x_PM_MUX2_X2%3_c6 VSS N_3_M1_g 2.92845e-17
C_x_PM_MUX2_X2%3_c7 VSS N_3_M7_g 8.53624e-17
R_x_PM_MUX2_X2%3_r8 x_PM_MUX2_X2%3_29 x_PM_MUX2_X2%3_27 5.46
R_x_PM_MUX2_X2%3_r9 x_PM_MUX2_X2%3_27 x_PM_MUX2_X2%3_19 25.0012
R_x_PM_MUX2_X2%3_r10 x_PM_MUX2_X2%3_26 x_PM_MUX2_X2%3_17 0.0569232
R_x_PM_MUX2_X2%3_r11 x_PM_MUX2_X2%3_19 x_PM_MUX2_X2%3_17 1.07214
R_x_PM_MUX2_X2%3_r12 x_PM_MUX2_X2%3_26 x_PM_MUX2_X2%3_13 0.143785
R_x_PM_MUX2_X2%3_r13 N_3_M0_s x_PM_MUX2_X2%3_13 0.369444
R_x_PM_MUX2_X2%3_r14 x_PM_MUX2_X2%3_26 x_PM_MUX2_X2%3_12 0.143785
R_x_PM_MUX2_X2%3_r15 x_PM_MUX2_X2%3_11 N_3_M6_s 0.30478
R_x_PM_MUX2_X2%3_r16 x_PM_MUX2_X2%3_12 x_PM_MUX2_X2%3_11 3.17571
R_x_PM_MUX2_X2%3_r17 x_PM_MUX2_X2%3_29 x_PM_MUX2_X2%3_5 1.95
R_x_PM_MUX2_X2%3_r18 N_3_M1_g x_PM_MUX2_X2%3_5 21.84
R_x_PM_MUX2_X2%3_r19 x_PM_MUX2_X2%3_29 x_PM_MUX2_X2%3_VSS 1.95
R_x_PM_MUX2_X2%3_r20 N_3_M7_g x_PM_MUX2_X2%3_VSS 109.2
C_x_PM_MUX2_X2%S_c0 VSS S 4.82014e-17
C_x_PM_MUX2_X2%S_c1 VSS x_PM_MUX2_X2%S_23 1.0373e-17
C_x_PM_MUX2_X2%S_c2 VSS N_S_M9_g 4.82167e-17
C_x_PM_MUX2_X2%S_c3 VSS x_PM_MUX2_X2%S_16 6.95182e-18
C_x_PM_MUX2_X2%S_c4 VSS x_PM_MUX2_X2%S_15 2.50884e-17
C_x_PM_MUX2_X2%S_c5 VSS N_S_M2_g 8.20103e-17
C_x_PM_MUX2_X2%S_c6 VSS x_PM_MUX2_X2%S_10 6.45496e-18
C_x_PM_MUX2_X2%S_c7 VSS x_PM_MUX2_X2%S_9 4.33072e-17
C_x_PM_MUX2_X2%S_c8 VSS N_S_M0_g 8.65386e-17
C_x_PM_MUX2_X2%S_c9 VSS N_S_M6_g 4.74457e-17
R_x_PM_MUX2_X2%S_r10 x_PM_MUX2_X2%S_30 x_PM_MUX2_X2%S_23 4.74714
R_x_PM_MUX2_X2%S_r11 x_PM_MUX2_X2%S_29 x_PM_MUX2_X2%S_23 4.74714
R_x_PM_MUX2_X2%S_r12 x_PM_MUX2_X2%S_23 x_PM_MUX2_X2%S_21 25.0012
R_x_PM_MUX2_X2%S_r13 S x_PM_MUX2_X2%S_21 0.223929
R_x_PM_MUX2_X2%S_r14 N_S_M9_g x_PM_MUX2_X2%S_17 45.24
R_x_PM_MUX2_X2%S_r15 x_PM_MUX2_X2%S_17 x_PM_MUX2_X2%S_15 4.35808
R_x_PM_MUX2_X2%S_r16 x_PM_MUX2_X2%S_16 x_PM_MUX2_X2%S_15 22.62
R_x_PM_MUX2_X2%S_r17 N_S_M2_g x_PM_MUX2_X2%S_12 33.54
R_x_PM_MUX2_X2%S_r18 x_PM_MUX2_X2%S_16 x_PM_MUX2_X2%S_11 4.35808
R_x_PM_MUX2_X2%S_r19 N_S_M2_g x_PM_MUX2_X2%S_11 89.7
R_x_PM_MUX2_X2%S_r20 x_PM_MUX2_X2%S_12 x_PM_MUX2_X2%S_9 4.35808
R_x_PM_MUX2_X2%S_r21 x_PM_MUX2_X2%S_10 x_PM_MUX2_X2%S_9 51.48
R_x_PM_MUX2_X2%S_r22 N_S_M0_g x_PM_MUX2_X2%S_30 88.14
R_x_PM_MUX2_X2%S_r23 x_PM_MUX2_X2%S_10 x_PM_MUX2_X2%S_6 4.35808
R_x_PM_MUX2_X2%S_r24 N_S_M0_g x_PM_MUX2_X2%S_6 33.54
R_x_PM_MUX2_X2%S_r25 N_S_M6_g x_PM_MUX2_X2%S_29 42.9
C_x_PM_MUX2_X2%5_c0 VSS x_PM_MUX2_X2%5_3 4.70469e-17
C_x_PM_MUX2_X2%5_c1 VSS N_5_M3_d 1.06963e-16
R_x_PM_MUX2_X2%5_r2 x_PM_MUX2_X2%5_3 N_5_M1_d 0.29113
R_x_PM_MUX2_X2%5_r3 N_5_M3_d x_PM_MUX2_X2%5_3 1.77786
C_x_PM_MUX2_X2%6_c0 VSS x_PM_MUX2_X2%6_28 1.35708e-17
C_x_PM_MUX2_X2%6_c1 VSS x_PM_MUX2_X2%6_19 2.3255e-17
C_x_PM_MUX2_X2%6_c2 VSS x_PM_MUX2_X2%6_16 8.79132e-17
C_x_PM_MUX2_X2%6_c3 VSS x_PM_MUX2_X2%6_15 1.12254e-16
C_x_PM_MUX2_X2%6_c4 VSS x_PM_MUX2_X2%6_14 8.32655e-17
C_x_PM_MUX2_X2%6_c5 VSS x_PM_MUX2_X2%6_12 1.59001e-16
C_x_PM_MUX2_X2%6_c6 VSS N_6_M5_g 4.04524e-17
C_x_PM_MUX2_X2%6_c7 VSS N_6_M11_g 9.98485e-17
R_x_PM_MUX2_X2%6_r8 x_PM_MUX2_X2%6_28 x_PM_MUX2_X2%6_27 1.04
R_x_PM_MUX2_X2%6_r9 x_PM_MUX2_X2%6_27 x_PM_MUX2_X2%6_25 3.9
R_x_PM_MUX2_X2%6_r10 N_6_M2_d x_PM_MUX2_X2%6_22 0.748824
R_x_PM_MUX2_X2%6_r11 x_PM_MUX2_X2%6_25 x_PM_MUX2_X2%6_19 25.0012
R_x_PM_MUX2_X2%6_r12 x_PM_MUX2_X2%6_19 x_PM_MUX2_X2%6_17 0.149286
R_x_PM_MUX2_X2%6_r13 N_6_M2_d x_PM_MUX2_X2%6_16 0.314723
R_x_PM_MUX2_X2%6_r14 x_PM_MUX2_X2%6_17 x_PM_MUX2_X2%6_15 0.212317
R_x_PM_MUX2_X2%6_r15 x_PM_MUX2_X2%6_16 x_PM_MUX2_X2%6_15 1.84571
R_x_PM_MUX2_X2%6_r16 x_PM_MUX2_X2%6_14 N_6_M8_d 0.570339
R_x_PM_MUX2_X2%6_r17 x_PM_MUX2_X2%6_22 x_PM_MUX2_X2%6_12 0.111765
R_x_PM_MUX2_X2%6_r18 x_PM_MUX2_X2%6_14 x_PM_MUX2_X2%6_11 0.212317
R_x_PM_MUX2_X2%6_r19 x_PM_MUX2_X2%6_12 x_PM_MUX2_X2%6_11 4.09857
R_x_PM_MUX2_X2%6_r20 x_PM_MUX2_X2%6_28 x_PM_MUX2_X2%6_5 1.95
R_x_PM_MUX2_X2%6_r21 N_6_M5_g x_PM_MUX2_X2%6_5 28.86
R_x_PM_MUX2_X2%6_r22 x_PM_MUX2_X2%6_27 x_PM_MUX2_X2%6_VSS 1.95
R_x_PM_MUX2_X2%6_r23 N_6_M11_g x_PM_MUX2_X2%6_VSS 114.66
C_x_PM_MUX2_X2%A_c0 VSS x_PM_MUX2_X2%A_27 1.22805e-17
C_x_PM_MUX2_X2%A_c1 VSS x_PM_MUX2_X2%A_17 7.5529e-17
C_x_PM_MUX2_X2%A_c2 VSS x_PM_MUX2_X2%A_16 4.83977e-17
C_x_PM_MUX2_X2%A_c3 VSS x_PM_MUX2_X2%A_12 1.78063e-17
C_x_PM_MUX2_X2%A_c4 VSS x_PM_MUX2_X2%A_10 2e-16
C_x_PM_MUX2_X2%A_c5 VSS N_A_M4_g 4.01608e-17
C_x_PM_MUX2_X2%A_c6 VSS N_A_M8_g 3.38841e-17
R_x_PM_MUX2_X2%A_r7 x_PM_MUX2_X2%A_27 x_PM_MUX2_X2%A_19 2.86
R_x_PM_MUX2_X2%A_r8 x_PM_MUX2_X2%A_19 x_PM_MUX2_X2%A_17 25.0012
R_x_PM_MUX2_X2%A_r9 x_PM_MUX2_X2%A_17 x_PM_MUX2_X2%A_16 1.26214
R_x_PM_MUX2_X2%A_r10 x_PM_MUX2_X2%A_12 x_PM_MUX2_X2%A_21 5.46
R_x_PM_MUX2_X2%A_r11 x_PM_MUX2_X2%A_12 x_PM_MUX2_X2%A_10 25.0012
R_x_PM_MUX2_X2%A_r12 A x_PM_MUX2_X2%A_10 0.941364
R_x_PM_MUX2_X2%A_r13 x_PM_MUX2_X2%A_16 x_PM_MUX2_X2%A_9 0.226245
R_x_PM_MUX2_X2%A_r14 A x_PM_MUX2_X2%A_9 0.742727
R_x_PM_MUX2_X2%A_r15 x_PM_MUX2_X2%A_27 x_PM_MUX2_X2%A_5 1.95
R_x_PM_MUX2_X2%A_r16 N_A_M4_g x_PM_MUX2_X2%A_5 32.76
R_x_PM_MUX2_X2%A_r17 x_PM_MUX2_X2%A_21 x_PM_MUX2_X2%A_VSS 1.95
R_x_PM_MUX2_X2%A_r18 N_A_M8_g x_PM_MUX2_X2%A_VSS 21.84
C_x_PM_MUX2_X2%B_c0 VSS B 7.88524e-17
C_x_PM_MUX2_X2%B_c1 VSS x_PM_MUX2_X2%B_10 1.57143e-17
C_x_PM_MUX2_X2%B_c2 VSS x_PM_MUX2_X2%B_9 7.14879e-18
C_x_PM_MUX2_X2%B_c3 VSS N_B_M10_g 5.51462e-17
C_x_PM_MUX2_X2%B_c4 VSS N_B_M3_g 6.98783e-17
R_x_PM_MUX2_X2%B_r5 x_PM_MUX2_X2%B_16 x_PM_MUX2_X2%B_14 25.0012
R_x_PM_MUX2_X2%B_r6 x_PM_MUX2_X2%B_14 B 0.4332
R_x_PM_MUX2_X2%B_r7 x_PM_MUX2_X2%B_16 x_PM_MUX2_X2%B_10 13.26
R_x_PM_MUX2_X2%B_r8 x_PM_MUX2_X2%B_16 x_PM_MUX2_X2%B_9 0.26
R_x_PM_MUX2_X2%B_r9 x_PM_MUX2_X2%B_10 x_PM_MUX2_X2%B_5 4.58872
R_x_PM_MUX2_X2%B_r10 N_B_M10_g x_PM_MUX2_X2%B_5 64.74
R_x_PM_MUX2_X2%B_r11 x_PM_MUX2_X2%B_9 x_PM_MUX2_X2%B_VSS 4.58872
R_x_PM_MUX2_X2%B_r12 N_B_M3_g x_PM_MUX2_X2%B_VSS 75.27
C_x_PM_MUX2_X2%Z_c0 VSS N_Z_M11_d 1.19845e-16
R_x_PM_MUX2_X2%Z_r1 N_Z_M5_d Z 2.26733
R_x_PM_MUX2_X2%Z_r2 Z N_Z_M11_d 2.014
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X1 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M2 N_ZN_M0_d N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M3 N_VDD_M1_d N_A1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 6 N_A2_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_ZN_M3_d N_A1_M3_g 6 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_NAND2_X1%VSS_c0 VSS VSS 5.51676e-17
C_x_PM_NAND2_X1%VSS_c1 VSS x_PM_NAND2_X1%VSS_6 1.05978e-17
C_x_PM_NAND2_X1%VSS_c2 VSS N_VSS_M2_s 1.55128e-17
R_x_PM_NAND2_X1%VSS_r3 VSS x_PM_NAND2_X1%VSS_6 0.391176
R_x_PM_NAND2_X1%VSS_r4 x_PM_NAND2_X1%VSS_6 x_PM_NAND2_X1%VSS_2 0.264221
R_x_PM_NAND2_X1%VSS_r5 N_VSS_M2_s x_PM_NAND2_X1%VSS_2 0.420714
C_x_PM_NAND2_X1%VDD_c0 VSS N_VDD_M1_d 2.02815e-17
C_x_PM_NAND2_X1%VDD_c1 VSS x_PM_NAND2_X1%VDD_8 1.05763e-17
C_x_PM_NAND2_X1%VDD_c2 VSS x_PM_NAND2_X1%VDD_7 4.95623e-17
C_x_PM_NAND2_X1%VDD_c3 VSS N_VDD_M0_s 1.38413e-17
R_x_PM_NAND2_X1%VDD_r4 N_VDD_M1_d x_PM_NAND2_X1%VDD_11 0.393571
R_x_PM_NAND2_X1%VDD_r5 VDD x_PM_NAND2_X1%VDD_8 0.391176
R_x_PM_NAND2_X1%VDD_r6 x_PM_NAND2_X1%VDD_11 x_PM_NAND2_X1%VDD_7 0.264221
R_x_PM_NAND2_X1%VDD_r7 VDD x_PM_NAND2_X1%VDD_7 0.290588
R_x_PM_NAND2_X1%VDD_r8 x_PM_NAND2_X1%VDD_8 x_PM_NAND2_X1%VDD_3 0.264221
R_x_PM_NAND2_X1%VDD_r9 N_VDD_M0_s x_PM_NAND2_X1%VDD_3 0.393571
C_x_PM_NAND2_X1%A2_c0 VSS x_PM_NAND2_X1%A2_14 6.9408e-18
C_x_PM_NAND2_X1%A2_c1 VSS x_PM_NAND2_X1%A2_12 1.47724e-17
C_x_PM_NAND2_X1%A2_c2 VSS N_A2_M0_g 7.38791e-17
C_x_PM_NAND2_X1%A2_c3 VSS N_A2_M2_g 3.97559e-17
R_x_PM_NAND2_X1%A2_r4 x_PM_NAND2_X1%A2_18 x_PM_NAND2_X1%A2_14 4.74714
R_x_PM_NAND2_X1%A2_r5 x_PM_NAND2_X1%A2_17 x_PM_NAND2_X1%A2_14 4.74714
R_x_PM_NAND2_X1%A2_r6 x_PM_NAND2_X1%A2_14 x_PM_NAND2_X1%A2_12 25.0012
R_x_PM_NAND2_X1%A2_r7 x_PM_NAND2_X1%A2_12 A2 0.156071
R_x_PM_NAND2_X1%A2_r8 N_A2_M0_g x_PM_NAND2_X1%A2_18 106.47
R_x_PM_NAND2_X1%A2_r9 N_A2_M2_g x_PM_NAND2_X1%A2_17 41.34
C_x_PM_NAND2_X1%ZN_c0 VSS N_ZN_M3_d 1.05803e-16
C_x_PM_NAND2_X1%ZN_c1 VSS x_PM_NAND2_X1%ZN_9 2.03587e-17
C_x_PM_NAND2_X1%ZN_c2 VSS N_ZN_M0_d 5.00649e-17
C_x_PM_NAND2_X1%ZN_c3 VSS ZN 7.74842e-18
R_x_PM_NAND2_X1%ZN_r4 N_ZN_M3_d x_PM_NAND2_X1%ZN_11 4.13929
R_x_PM_NAND2_X1%ZN_r5 x_PM_NAND2_X1%ZN_11 x_PM_NAND2_X1%ZN_9 0.212317
R_x_PM_NAND2_X1%ZN_r6 x_PM_NAND2_X1%ZN_10 x_PM_NAND2_X1%ZN_9 0.542857
R_x_PM_NAND2_X1%ZN_r7 N_ZN_M0_d ZN 0.592353
R_x_PM_NAND2_X1%ZN_r8 x_PM_NAND2_X1%ZN_10 ZN 0.193838
C_x_PM_NAND2_X1%A1_c0 VSS x_PM_NAND2_X1%A1_18 1.23651e-17
C_x_PM_NAND2_X1%A1_c1 VSS x_PM_NAND2_X1%A1_12 4.01483e-17
C_x_PM_NAND2_X1%A1_c2 VSS N_A1_M1_g 1.08163e-16
C_x_PM_NAND2_X1%A1_c3 VSS N_A1_M3_g 2.78057e-17
R_x_PM_NAND2_X1%A1_r4 x_PM_NAND2_X1%A1_18 x_PM_NAND2_X1%A1_14 3.9
R_x_PM_NAND2_X1%A1_r5 x_PM_NAND2_X1%A1_14 x_PM_NAND2_X1%A1_12 25.0012
R_x_PM_NAND2_X1%A1_r6 x_PM_NAND2_X1%A1_12 A1 0.101786
R_x_PM_NAND2_X1%A1_r7 x_PM_NAND2_X1%A1_18 x_PM_NAND2_X1%A1_5 1.95
R_x_PM_NAND2_X1%A1_r8 N_A1_M1_g x_PM_NAND2_X1%A1_5 129.09
R_x_PM_NAND2_X1%A1_r9 x_PM_NAND2_X1%A1_18 x_PM_NAND2_X1%A1_VSS 1.95
R_x_PM_NAND2_X1%A1_r10 N_A1_M3_g x_PM_NAND2_X1%A1_VSS 18.72
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X2 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M2 N_ZN_M0_d N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M3 N_VDD_M1_d N_A1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 6 N_A2_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M3_d N_A1_M3_g 6 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_NAND2_X2%VSS_c0 VSS VSS 5.03826e-17
C_x_PM_NAND2_X2%VSS_c1 VSS x_PM_NAND2_X2%VSS_6 1.04465e-17
C_x_PM_NAND2_X2%VSS_c2 VSS N_VSS_M2_s 1.83058e-17
R_x_PM_NAND2_X2%VSS_r3 VSS x_PM_NAND2_X2%VSS_6 0.391176
R_x_PM_NAND2_X2%VSS_r4 x_PM_NAND2_X2%VSS_6 x_PM_NAND2_X2%VSS_2 0.264221
R_x_PM_NAND2_X2%VSS_r5 N_VSS_M2_s x_PM_NAND2_X2%VSS_2 0.230714
C_x_PM_NAND2_X2%VDD_c0 VSS N_VDD_M1_d 4.75732e-17
C_x_PM_NAND2_X2%VDD_c1 VSS x_PM_NAND2_X2%VDD_7 4.67275e-17
C_x_PM_NAND2_X2%VDD_c2 VSS N_VDD_M0_s 2.99432e-17
C_x_PM_NAND2_X2%VDD_c3 VSS x_PM_NAND2_X2%VDD_3 1.06496e-17
R_x_PM_NAND2_X2%VDD_r4 N_VDD_M1_d x_PM_NAND2_X2%VDD_9 0.420714
R_x_PM_NAND2_X2%VDD_r5 VDD x_PM_NAND2_X2%VDD_8 0.195294
R_x_PM_NAND2_X2%VDD_r6 x_PM_NAND2_X2%VDD_9 x_PM_NAND2_X2%VDD_7 0.264221
R_x_PM_NAND2_X2%VDD_r7 x_PM_NAND2_X2%VDD_8 x_PM_NAND2_X2%VDD_7 0.681765
R_x_PM_NAND2_X2%VDD_r8 VDD x_PM_NAND2_X2%VDD_3 0.0689273
R_x_PM_NAND2_X2%VDD_r9 N_VDD_M0_s x_PM_NAND2_X2%VDD_3 0.420714
C_x_PM_NAND2_X2%A2_c0 VSS x_PM_NAND2_X2%A2_14 7.51478e-18
C_x_PM_NAND2_X2%A2_c1 VSS A2 6.01437e-17
C_x_PM_NAND2_X2%A2_c2 VSS N_A2_M0_g 8.26414e-17
C_x_PM_NAND2_X2%A2_c3 VSS N_A2_M2_g 3.58741e-17
R_x_PM_NAND2_X2%A2_r4 x_PM_NAND2_X2%A2_18 x_PM_NAND2_X2%A2_14 4.74714
R_x_PM_NAND2_X2%A2_r5 x_PM_NAND2_X2%A2_17 x_PM_NAND2_X2%A2_14 4.74714
R_x_PM_NAND2_X2%A2_r6 x_PM_NAND2_X2%A2_14 x_PM_NAND2_X2%A2_12 25.0012
R_x_PM_NAND2_X2%A2_r7 x_PM_NAND2_X2%A2_12 A2 0.266
R_x_PM_NAND2_X2%A2_r8 N_A2_M0_g x_PM_NAND2_X2%A2_18 103.74
R_x_PM_NAND2_X2%A2_r9 N_A2_M2_g x_PM_NAND2_X2%A2_17 28.08
C_x_PM_NAND2_X2%ZN_c0 VSS N_ZN_M3_d 9.46701e-17
C_x_PM_NAND2_X2%ZN_c1 VSS x_PM_NAND2_X2%ZN_8 7.68686e-18
C_x_PM_NAND2_X2%ZN_c2 VSS x_PM_NAND2_X2%ZN_7 3.24105e-17
C_x_PM_NAND2_X2%ZN_c3 VSS N_ZN_M0_d 6.2878e-17
R_x_PM_NAND2_X2%ZN_r4 ZN N_ZN_M3_d 1.93167
R_x_PM_NAND2_X2%ZN_r5 ZN x_PM_NAND2_X2%ZN_9 0.527778
R_x_PM_NAND2_X2%ZN_r6 x_PM_NAND2_X2%ZN_9 x_PM_NAND2_X2%ZN_7 0.21666
R_x_PM_NAND2_X2%ZN_r7 x_PM_NAND2_X2%ZN_8 x_PM_NAND2_X2%ZN_7 0.624286
R_x_PM_NAND2_X2%ZN_r8 x_PM_NAND2_X2%ZN_8 x_PM_NAND2_X2%ZN_3 0.212317
R_x_PM_NAND2_X2%ZN_r9 N_ZN_M0_d x_PM_NAND2_X2%ZN_3 1.18071
C_x_PM_NAND2_X2%A1_c0 VSS x_PM_NAND2_X2%A1_18 1.23667e-17
C_x_PM_NAND2_X2%A1_c1 VSS A1 8.87208e-17
C_x_PM_NAND2_X2%A1_c2 VSS N_A1_M1_g 9.96411e-17
C_x_PM_NAND2_X2%A1_c3 VSS N_A1_M3_g 3.7962e-17
R_x_PM_NAND2_X2%A1_r4 x_PM_NAND2_X2%A1_18 x_PM_NAND2_X2%A1_14 3.9
R_x_PM_NAND2_X2%A1_r5 x_PM_NAND2_X2%A1_14 x_PM_NAND2_X2%A1_12 25.0012
R_x_PM_NAND2_X2%A1_r6 x_PM_NAND2_X2%A1_12 A1 0.316667
R_x_PM_NAND2_X2%A1_r7 x_PM_NAND2_X2%A1_18 x_PM_NAND2_X2%A1_5 1.95
R_x_PM_NAND2_X2%A1_r8 N_A1_M1_g x_PM_NAND2_X2%A1_5 103.74
R_x_PM_NAND2_X2%A1_r9 x_PM_NAND2_X2%A1_18 x_PM_NAND2_X2%A1_VSS 1.95
R_x_PM_NAND2_X2%A1_r10 N_A1_M3_g x_PM_NAND2_X2%A1_VSS 28.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND2_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND2_X4 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M4 N_ZN_M0_d N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M5 N_VDD_M1_d N_A1_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M6 N_ZN_M2_d N_A1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M7 N_VDD_M3_d N_A2_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 6 N_A2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_ZN_M5_d N_A1_M5_g 6 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 7 N_A1_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M7_d N_A2_M7_g 7 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_NAND2_X4%VSS_c0 VSS N_VSS_M7_d 5.04201e-17
C_x_PM_NAND2_X4%VSS_c1 VSS x_PM_NAND2_X4%VSS_8 1.35595e-17
C_x_PM_NAND2_X4%VSS_c2 VSS x_PM_NAND2_X4%VSS_7 1.52944e-16
C_x_PM_NAND2_X4%VSS_c3 VSS N_VSS_M4_s 3.4602e-17
R_x_PM_NAND2_X4%VSS_r4 N_VSS_M7_d x_PM_NAND2_X4%VSS_11 1.20786
R_x_PM_NAND2_X4%VSS_r5 VSS x_PM_NAND2_X4%VSS_8 0.726471
R_x_PM_NAND2_X4%VSS_r6 x_PM_NAND2_X4%VSS_11 x_PM_NAND2_X4%VSS_7 0.264221
R_x_PM_NAND2_X4%VSS_r7 VSS x_PM_NAND2_X4%VSS_7 0.815882
R_x_PM_NAND2_X4%VSS_r8 x_PM_NAND2_X4%VSS_8 x_PM_NAND2_X4%VSS_3 0.264221
R_x_PM_NAND2_X4%VSS_r9 N_VSS_M4_s x_PM_NAND2_X4%VSS_3 1.20786
C_x_PM_NAND2_X4%VDD_c0 VSS x_PM_NAND2_X4%VDD_22 2.84978e-18
C_x_PM_NAND2_X4%VDD_c1 VSS N_VDD_M3_d 2.38945e-17
C_x_PM_NAND2_X4%VDD_c2 VSS x_PM_NAND2_X4%VDD_16 3.48115e-17
C_x_PM_NAND2_X4%VDD_c3 VSS N_VDD_M1_d 2.33791e-17
C_x_PM_NAND2_X4%VDD_c4 VSS x_PM_NAND2_X4%VDD_9 1.35387e-17
C_x_PM_NAND2_X4%VDD_c5 VSS x_PM_NAND2_X4%VDD_8 3.32701e-17
C_x_PM_NAND2_X4%VDD_c6 VSS N_VDD_M0_s 2.98636e-17
R_x_PM_NAND2_X4%VDD_r7 N_VDD_M3_d x_PM_NAND2_X4%VDD_18 0.420714
R_x_PM_NAND2_X4%VDD_r8 x_PM_NAND2_X4%VDD_22 x_PM_NAND2_X4%VDD_17 0.0731438
R_x_PM_NAND2_X4%VDD_r9 x_PM_NAND2_X4%VDD_18 x_PM_NAND2_X4%VDD_16 0.264221
R_x_PM_NAND2_X4%VDD_r10 x_PM_NAND2_X4%VDD_17 x_PM_NAND2_X4%VDD_16 0.692941
R_x_PM_NAND2_X4%VDD_r11 VDD N_VDD_M1_d 0.108571
R_x_PM_NAND2_X4%VDD_r12 x_PM_NAND2_X4%VDD_22 x_PM_NAND2_X4%VDD_10 0.145286
R_x_PM_NAND2_X4%VDD_r13 VDD x_PM_NAND2_X4%VDD_10 0.312143
R_x_PM_NAND2_X4%VDD_r14 x_PM_NAND2_X4%VDD_22 x_PM_NAND2_X4%VDD_8 0.0731438
R_x_PM_NAND2_X4%VDD_r15 x_PM_NAND2_X4%VDD_9 x_PM_NAND2_X4%VDD_8 0.681765
R_x_PM_NAND2_X4%VDD_r16 x_PM_NAND2_X4%VDD_9 x_PM_NAND2_X4%VDD_4 0.264221
R_x_PM_NAND2_X4%VDD_r17 N_VDD_M0_s x_PM_NAND2_X4%VDD_4 0.420714
C_x_PM_NAND2_X4%A2_c0 VSS x_PM_NAND2_X4%A2_39 9.67703e-18
C_x_PM_NAND2_X4%A2_c1 VSS x_PM_NAND2_X4%A2_32 1.99121e-17
C_x_PM_NAND2_X4%A2_c2 VSS x_PM_NAND2_X4%A2_30 7.43471e-18
C_x_PM_NAND2_X4%A2_c3 VSS x_PM_NAND2_X4%A2_24 4.12968e-17
C_x_PM_NAND2_X4%A2_c4 VSS x_PM_NAND2_X4%A2_22 2.74861e-17
C_x_PM_NAND2_X4%A2_c5 VSS x_PM_NAND2_X4%A2_21 1.49321e-16
C_x_PM_NAND2_X4%A2_c6 VSS A2 3.26413e-17
C_x_PM_NAND2_X4%A2_c7 VSS N_A2_M3_g 7.88585e-17
C_x_PM_NAND2_X4%A2_c8 VSS N_A2_M7_g 3.8573e-17
C_x_PM_NAND2_X4%A2_c9 VSS N_A2_M0_g 7.80153e-17
C_x_PM_NAND2_X4%A2_c10 VSS N_A2_M4_g 4.22186e-17
R_x_PM_NAND2_X4%A2_r11 x_PM_NAND2_X4%A2_36 x_PM_NAND2_X4%A2_30 4.7687
R_x_PM_NAND2_X4%A2_r12 x_PM_NAND2_X4%A2_35 x_PM_NAND2_X4%A2_30 4.7687
R_x_PM_NAND2_X4%A2_r13 x_PM_NAND2_X4%A2_30 x_PM_NAND2_X4%A2_28 25.0012
R_x_PM_NAND2_X4%A2_r14 x_PM_NAND2_X4%A2_32 x_PM_NAND2_X4%A2_28 0.175926
R_x_PM_NAND2_X4%A2_r15 x_PM_NAND2_X4%A2_39 x_PM_NAND2_X4%A2_26 3.9
R_x_PM_NAND2_X4%A2_r16 x_PM_NAND2_X4%A2_26 x_PM_NAND2_X4%A2_24 25.0012
R_x_PM_NAND2_X4%A2_r17 x_PM_NAND2_X4%A2_24 x_PM_NAND2_X4%A2_23 1.39786
R_x_PM_NAND2_X4%A2_r18 x_PM_NAND2_X4%A2_23 x_PM_NAND2_X4%A2_21 0.212317
R_x_PM_NAND2_X4%A2_r19 x_PM_NAND2_X4%A2_22 x_PM_NAND2_X4%A2_21 2.09
R_x_PM_NAND2_X4%A2_r20 x_PM_NAND2_X4%A2_32 x_PM_NAND2_X4%A2_18 0.095
R_x_PM_NAND2_X4%A2_r21 A2 x_PM_NAND2_X4%A2_18 0.434286
R_x_PM_NAND2_X4%A2_r22 x_PM_NAND2_X4%A2_22 x_PM_NAND2_X4%A2_17 0.212317
R_x_PM_NAND2_X4%A2_r23 A2 x_PM_NAND2_X4%A2_17 0.705714
R_x_PM_NAND2_X4%A2_r24 x_PM_NAND2_X4%A2_39 x_PM_NAND2_X4%A2_13 1.95
R_x_PM_NAND2_X4%A2_r25 N_A2_M3_g x_PM_NAND2_X4%A2_13 97.5
R_x_PM_NAND2_X4%A2_r26 x_PM_NAND2_X4%A2_39 x_PM_NAND2_X4%A2_9 1.95
R_x_PM_NAND2_X4%A2_r27 N_A2_M7_g x_PM_NAND2_X4%A2_9 28.08
R_x_PM_NAND2_X4%A2_r28 N_A2_M0_g x_PM_NAND2_X4%A2_36 94.38
R_x_PM_NAND2_X4%A2_r29 N_A2_M4_g x_PM_NAND2_X4%A2_35 31.2
C_x_PM_NAND2_X4%ZN_c0 VSS x_PM_NAND2_X4%ZN_22 7.421e-18
C_x_PM_NAND2_X4%ZN_c1 VSS N_ZN_M5_d 9.80454e-17
C_x_PM_NAND2_X4%ZN_c2 VSS N_ZN_M2_d 7.42336e-17
C_x_PM_NAND2_X4%ZN_c3 VSS x_PM_NAND2_X4%ZN_11 9.2718e-18
C_x_PM_NAND2_X4%ZN_c4 VSS x_PM_NAND2_X4%ZN_10 1.32528e-17
C_x_PM_NAND2_X4%ZN_c5 VSS N_ZN_M0_d 4.31293e-17
C_x_PM_NAND2_X4%ZN_c6 VSS x_PM_NAND2_X4%ZN_5 1.86994e-17
R_x_PM_NAND2_X4%ZN_r7 ZN N_ZN_M5_d 1.00429
R_x_PM_NAND2_X4%ZN_r8 ZN x_PM_NAND2_X4%ZN_16 0.398095
R_x_PM_NAND2_X4%ZN_r9 x_PM_NAND2_X4%ZN_22 x_PM_NAND2_X4%ZN_12 0.0418175
R_x_PM_NAND2_X4%ZN_r10 N_ZN_M2_d x_PM_NAND2_X4%ZN_12 1.83214
R_x_PM_NAND2_X4%ZN_r11 x_PM_NAND2_X4%ZN_16 x_PM_NAND2_X4%ZN_10 0.223553
R_x_PM_NAND2_X4%ZN_r12 x_PM_NAND2_X4%ZN_11 x_PM_NAND2_X4%ZN_10 0.407143
R_x_PM_NAND2_X4%ZN_r13 x_PM_NAND2_X4%ZN_22 x_PM_NAND2_X4%ZN_6 0.160909
R_x_PM_NAND2_X4%ZN_r14 N_ZN_M0_d x_PM_NAND2_X4%ZN_6 0.556429
R_x_PM_NAND2_X4%ZN_r15 x_PM_NAND2_X4%ZN_22 x_PM_NAND2_X4%ZN_5 0.160909
R_x_PM_NAND2_X4%ZN_r16 x_PM_NAND2_X4%ZN_11 x_PM_NAND2_X4%ZN_4 0.212317
R_x_PM_NAND2_X4%ZN_r17 x_PM_NAND2_X4%ZN_5 x_PM_NAND2_X4%ZN_4 1.08571
C_x_PM_NAND2_X4%A1_c0 VSS A1 4.31138e-17
C_x_PM_NAND2_X4%A1_c1 VSS x_PM_NAND2_X4%A1_22 6.08605e-18
C_x_PM_NAND2_X4%A1_c2 VSS x_PM_NAND2_X4%A1_19 4.6987e-18
C_x_PM_NAND2_X4%A1_c3 VSS N_A1_M2_g 3.27647e-17
C_x_PM_NAND2_X4%A1_c4 VSS N_A1_M6_g 6.02645e-17
C_x_PM_NAND2_X4%A1_c5 VSS x_PM_NAND2_X4%A1_9 8.79999e-18
C_x_PM_NAND2_X4%A1_c6 VSS N_A1_M1_g 3.29364e-17
C_x_PM_NAND2_X4%A1_c7 VSS N_A1_M5_g 7.79491e-17
R_x_PM_NAND2_X4%A1_r8 x_PM_NAND2_X4%A1_22 x_PM_NAND2_X4%A1_20 25.0012
R_x_PM_NAND2_X4%A1_r9 A1 x_PM_NAND2_X4%A1_20 0.339286
R_x_PM_NAND2_X4%A1_r10 x_PM_NAND2_X4%A1_22 x_PM_NAND2_X4%A1_15 4.56151
R_x_PM_NAND2_X4%A1_r11 N_A1_M2_g x_PM_NAND2_X4%A1_15 30.42
R_x_PM_NAND2_X4%A1_r12 x_PM_NAND2_X4%A1_22 x_PM_NAND2_X4%A1_11 4.56151
R_x_PM_NAND2_X4%A1_r13 N_A1_M6_g x_PM_NAND2_X4%A1_11 95.16
R_x_PM_NAND2_X4%A1_r14 x_PM_NAND2_X4%A1_19 x_PM_NAND2_X4%A1_10 0.043368
R_x_PM_NAND2_X4%A1_r15 x_PM_NAND2_X4%A1_22 x_PM_NAND2_X4%A1_9 0.043368
R_x_PM_NAND2_X4%A1_r16 x_PM_NAND2_X4%A1_10 x_PM_NAND2_X4%A1_9 14.56
R_x_PM_NAND2_X4%A1_r17 x_PM_NAND2_X4%A1_19 x_PM_NAND2_X4%A1_5 4.56151
R_x_PM_NAND2_X4%A1_r18 N_A1_M1_g x_PM_NAND2_X4%A1_5 30.42
R_x_PM_NAND2_X4%A1_r19 x_PM_NAND2_X4%A1_19 x_PM_NAND2_X4%A1_VSS 4.56151
R_x_PM_NAND2_X4%A1_r20 N_A1_M5_g x_PM_NAND2_X4%A1_VSS 95.16
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X1 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M3 N_ZN_M0_d N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_ZN_M2_d N_A1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 7 N_A3_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 8 N_A2_M4_g 7 VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_ZN_M5_d N_A1_M5_g 8 VSS NMOS_VTL W=0.170000U L=0.050000U
C_x_PM_NAND3_X1%VSS_c0 VSS VSS 7.54734e-17
C_x_PM_NAND3_X1%VSS_c1 VSS x_PM_NAND3_X1%VSS_6 1.05487e-17
C_x_PM_NAND3_X1%VSS_c2 VSS N_VSS_M3_s 1.76206e-17
R_x_PM_NAND3_X1%VSS_r3 VSS x_PM_NAND3_X1%VSS_6 0.603529
R_x_PM_NAND3_X1%VSS_r4 x_PM_NAND3_X1%VSS_6 x_PM_NAND3_X1%VSS_2 0.264221
R_x_PM_NAND3_X1%VSS_r5 N_VSS_M3_s x_PM_NAND3_X1%VSS_2 0.230714
C_x_PM_NAND3_X1%VDD_c0 VSS x_PM_NAND3_X1%VDD_17 4.10027e-17
C_x_PM_NAND3_X1%VDD_c1 VSS N_VDD_M1_d 2.62238e-17
C_x_PM_NAND3_X1%VDD_c2 VSS x_PM_NAND3_X1%VDD_8 1.06786e-17
C_x_PM_NAND3_X1%VDD_c3 VSS x_PM_NAND3_X1%VDD_7 3.57972e-17
C_x_PM_NAND3_X1%VDD_c4 VSS N_VDD_M0_s 1.38899e-17
R_x_PM_NAND3_X1%VDD_r5 x_PM_NAND3_X1%VDD_17 x_PM_NAND3_X1%VDD_11 0.145286
R_x_PM_NAND3_X1%VDD_r6 N_VDD_M1_d x_PM_NAND3_X1%VDD_11 0.393571
R_x_PM_NAND3_X1%VDD_r7 VDD x_PM_NAND3_X1%VDD_8 0.603529
R_x_PM_NAND3_X1%VDD_r8 x_PM_NAND3_X1%VDD_17 x_PM_NAND3_X1%VDD_7 0.0731438
R_x_PM_NAND3_X1%VDD_r9 VDD x_PM_NAND3_X1%VDD_7 0.0894118
R_x_PM_NAND3_X1%VDD_r10 x_PM_NAND3_X1%VDD_8 x_PM_NAND3_X1%VDD_3 0.264221
R_x_PM_NAND3_X1%VDD_r11 N_VDD_M0_s x_PM_NAND3_X1%VDD_3 0.393571
C_x_PM_NAND3_X1%A3_c0 VSS x_PM_NAND3_X1%A3_16 7.0771e-18
C_x_PM_NAND3_X1%A3_c1 VSS x_PM_NAND3_X1%A3_14 1.24965e-17
C_x_PM_NAND3_X1%A3_c2 VSS A3 2.79143e-17
C_x_PM_NAND3_X1%A3_c3 VSS N_A3_M0_g 6.90889e-17
C_x_PM_NAND3_X1%A3_c4 VSS N_A3_M3_g 4.57614e-17
R_x_PM_NAND3_X1%A3_r5 x_PM_NAND3_X1%A3_20 x_PM_NAND3_X1%A3_16 4.7687
R_x_PM_NAND3_X1%A3_r6 x_PM_NAND3_X1%A3_19 x_PM_NAND3_X1%A3_16 4.7687
R_x_PM_NAND3_X1%A3_r7 x_PM_NAND3_X1%A3_16 x_PM_NAND3_X1%A3_14 25.0012
R_x_PM_NAND3_X1%A3_r8 x_PM_NAND3_X1%A3_14 A3 0.246296
R_x_PM_NAND3_X1%A3_r9 N_A3_M0_g x_PM_NAND3_X1%A3_20 98.67
R_x_PM_NAND3_X1%A3_r10 N_A3_M3_g x_PM_NAND3_X1%A3_19 51.48
C_x_PM_NAND3_X1%ZN_c0 VSS x_PM_NAND3_X1%ZN_18 2.14222e-18
C_x_PM_NAND3_X1%ZN_c1 VSS x_PM_NAND3_X1%ZN_17 3.60399e-17
C_x_PM_NAND3_X1%ZN_c2 VSS N_ZN_M5_d 1.03275e-16
C_x_PM_NAND3_X1%ZN_c3 VSS x_PM_NAND3_X1%ZN_10 2.42332e-17
C_x_PM_NAND3_X1%ZN_c4 VSS N_ZN_M0_d 4.46102e-17
C_x_PM_NAND3_X1%ZN_c5 VSS ZN 8.2039e-18
R_x_PM_NAND3_X1%ZN_r6 x_PM_NAND3_X1%ZN_18 x_PM_NAND3_X1%ZN_17 0.160909
R_x_PM_NAND3_X1%ZN_r7 x_PM_NAND3_X1%ZN_17 N_ZN_M2_d 0.543196
R_x_PM_NAND3_X1%ZN_r8 x_PM_NAND3_X1%ZN_18 x_PM_NAND3_X1%ZN_12 0.160909
R_x_PM_NAND3_X1%ZN_r9 N_ZN_M5_d x_PM_NAND3_X1%ZN_12 4.11214
R_x_PM_NAND3_X1%ZN_r10 x_PM_NAND3_X1%ZN_18 x_PM_NAND3_X1%ZN_10 0.0418175
R_x_PM_NAND3_X1%ZN_r11 x_PM_NAND3_X1%ZN_11 x_PM_NAND3_X1%ZN_10 1.57429
R_x_PM_NAND3_X1%ZN_r12 N_ZN_M0_d ZN 0.592353
R_x_PM_NAND3_X1%ZN_r13 x_PM_NAND3_X1%ZN_11 ZN 0.193838
C_x_PM_NAND3_X1%A2_c0 VSS x_PM_NAND3_X1%A2_14 9.36597e-18
C_x_PM_NAND3_X1%A2_c1 VSS x_PM_NAND3_X1%A2_12 4.57631e-17
C_x_PM_NAND3_X1%A2_c2 VSS N_A2_M1_g 9.40206e-17
C_x_PM_NAND3_X1%A2_c3 VSS N_A2_M4_g 2.93674e-17
R_x_PM_NAND3_X1%A2_r4 x_PM_NAND3_X1%A2_18 x_PM_NAND3_X1%A2_14 4.74714
R_x_PM_NAND3_X1%A2_r5 x_PM_NAND3_X1%A2_17 x_PM_NAND3_X1%A2_14 4.74714
R_x_PM_NAND3_X1%A2_r6 x_PM_NAND3_X1%A2_14 x_PM_NAND3_X1%A2_12 25.0012
R_x_PM_NAND3_X1%A2_r7 x_PM_NAND3_X1%A2_12 A2 0.156071
R_x_PM_NAND3_X1%A2_r8 N_A2_M1_g x_PM_NAND3_X1%A2_18 128.31
R_x_PM_NAND3_X1%A2_r9 N_A2_M4_g x_PM_NAND3_X1%A2_17 21.84
C_x_PM_NAND3_X1%A1_c0 VSS x_PM_NAND3_X1%A1_18 1.23963e-17
C_x_PM_NAND3_X1%A1_c1 VSS x_PM_NAND3_X1%A1_12 5.74094e-17
C_x_PM_NAND3_X1%A1_c2 VSS N_A1_M2_g 1.09705e-16
C_x_PM_NAND3_X1%A1_c3 VSS N_A1_M5_g 3.11643e-17
R_x_PM_NAND3_X1%A1_r4 x_PM_NAND3_X1%A1_18 x_PM_NAND3_X1%A1_14 3.9
R_x_PM_NAND3_X1%A1_r5 x_PM_NAND3_X1%A1_14 x_PM_NAND3_X1%A1_12 25.0012
R_x_PM_NAND3_X1%A1_r6 x_PM_NAND3_X1%A1_12 A1 0.101786
R_x_PM_NAND3_X1%A1_r7 x_PM_NAND3_X1%A1_18 x_PM_NAND3_X1%A1_5 1.95
R_x_PM_NAND3_X1%A1_r8 N_A1_M2_g x_PM_NAND3_X1%A1_5 129.09
R_x_PM_NAND3_X1%A1_r9 x_PM_NAND3_X1%A1_18 x_PM_NAND3_X1%A1_VSS 1.95
R_x_PM_NAND3_X1%A1_r10 N_A1_M5_g x_PM_NAND3_X1%A1_VSS 21.06
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X2 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M3 N_ZN_M0_d N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M5 N_ZN_M2_d N_A1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 7 N_A3_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 8 N_A2_M4_g 7 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_ZN_M5_d N_A1_M5_g 8 VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_NAND3_X2%VSS_c0 VSS VSS 7.02872e-17
C_x_PM_NAND3_X2%VSS_c1 VSS x_PM_NAND3_X2%VSS_6 1.05487e-17
C_x_PM_NAND3_X2%VSS_c2 VSS N_VSS_M3_s 1.8134e-17
R_x_PM_NAND3_X2%VSS_r3 VSS x_PM_NAND3_X2%VSS_6 0.603529
R_x_PM_NAND3_X2%VSS_r4 x_PM_NAND3_X2%VSS_6 x_PM_NAND3_X2%VSS_2 0.264221
R_x_PM_NAND3_X2%VSS_r5 N_VSS_M3_s x_PM_NAND3_X2%VSS_2 0.230714
C_x_PM_NAND3_X2%VDD_c0 VSS N_VDD_M1_d 6.12848e-17
C_x_PM_NAND3_X2%VDD_c1 VSS x_PM_NAND3_X2%VDD_7 3.00804e-17
C_x_PM_NAND3_X2%VDD_c2 VSS N_VDD_M0_s 2.5125e-17
C_x_PM_NAND3_X2%VDD_c3 VSS x_PM_NAND3_X2%VDD_3 1.06055e-17
R_x_PM_NAND3_X2%VDD_r4 VDD x_PM_NAND3_X2%VDD_8 0.195294
R_x_PM_NAND3_X2%VDD_r5 x_PM_NAND3_X2%VDD_7 N_VDD_M1_d 0.140674
R_x_PM_NAND3_X2%VDD_r6 x_PM_NAND3_X2%VDD_8 x_PM_NAND3_X2%VDD_7 0.614706
R_x_PM_NAND3_X2%VDD_r7 VDD x_PM_NAND3_X2%VDD_3 0.0689273
R_x_PM_NAND3_X2%VDD_r8 N_VDD_M0_s x_PM_NAND3_X2%VDD_3 0.230714
C_x_PM_NAND3_X2%A3_c0 VSS x_PM_NAND3_X2%A3_14 6.68331e-18
C_x_PM_NAND3_X2%A3_c1 VSS x_PM_NAND3_X2%A3_12 3.18495e-17
C_x_PM_NAND3_X2%A3_c2 VSS N_A3_M0_g 7.81987e-17
C_x_PM_NAND3_X2%A3_c3 VSS N_A3_M3_g 4.14029e-17
R_x_PM_NAND3_X2%A3_r4 x_PM_NAND3_X2%A3_18 x_PM_NAND3_X2%A3_14 4.7687
R_x_PM_NAND3_X2%A3_r5 x_PM_NAND3_X2%A3_17 x_PM_NAND3_X2%A3_14 4.7687
R_x_PM_NAND3_X2%A3_r6 x_PM_NAND3_X2%A3_14 x_PM_NAND3_X2%A3_12 25.0012
R_x_PM_NAND3_X2%A3_r7 x_PM_NAND3_X2%A3_12 A3 0.0781486
R_x_PM_NAND3_X2%A3_r8 N_A3_M0_g x_PM_NAND3_X2%A3_18 95.94
R_x_PM_NAND3_X2%A3_r9 N_A3_M3_g x_PM_NAND3_X2%A3_17 35.1
C_x_PM_NAND3_X2%ZN_c0 VSS N_ZN_M5_d 1.32739e-16
C_x_PM_NAND3_X2%ZN_c1 VSS x_PM_NAND3_X2%ZN_8 1.01878e-17
C_x_PM_NAND3_X2%ZN_c2 VSS x_PM_NAND3_X2%ZN_4 7.15422e-17
R_x_PM_NAND3_X2%ZN_r3 ZN N_ZN_M5_d 1.59389
R_x_PM_NAND3_X2%ZN_r4 N_ZN_M2_d x_PM_NAND3_X2%ZN_8 0.0406238
R_x_PM_NAND3_X2%ZN_r5 ZN x_PM_NAND3_X2%ZN_8 1.28778
R_x_PM_NAND3_X2%ZN_r6 N_ZN_M2_d x_PM_NAND3_X2%ZN_4 0.176037
R_x_PM_NAND3_X2%ZN_r7 N_ZN_M0_d x_PM_NAND3_X2%ZN_4 1.85929
C_x_PM_NAND3_X2%A2_c0 VSS x_PM_NAND3_X2%A2_14 8.63262e-18
C_x_PM_NAND3_X2%A2_c1 VSS x_PM_NAND3_X2%A2_12 3.91329e-17
C_x_PM_NAND3_X2%A2_c2 VSS N_A2_M1_g 4.24405e-17
C_x_PM_NAND3_X2%A2_c3 VSS N_A2_M4_g 8.48173e-17
R_x_PM_NAND3_X2%A2_r4 x_PM_NAND3_X2%A2_18 x_PM_NAND3_X2%A2_14 4.7687
R_x_PM_NAND3_X2%A2_r5 x_PM_NAND3_X2%A2_17 x_PM_NAND3_X2%A2_14 4.7687
R_x_PM_NAND3_X2%A2_r6 x_PM_NAND3_X2%A2_14 x_PM_NAND3_X2%A2_12 25.0012
R_x_PM_NAND3_X2%A2_r7 x_PM_NAND3_X2%A2_12 A2 0.169643
R_x_PM_NAND3_X2%A2_r8 N_A2_M1_g x_PM_NAND3_X2%A2_18 29.64
R_x_PM_NAND3_X2%A2_r9 N_A2_M4_g x_PM_NAND3_X2%A2_17 101.4
C_x_PM_NAND3_X2%A1_c0 VSS x_PM_NAND3_X2%A1_18 1.22048e-17
C_x_PM_NAND3_X2%A1_c1 VSS x_PM_NAND3_X2%A1_12 7.61168e-17
C_x_PM_NAND3_X2%A1_c2 VSS N_A1_M2_g 8.98944e-17
C_x_PM_NAND3_X2%A1_c3 VSS N_A1_M5_g 4.86035e-17
R_x_PM_NAND3_X2%A1_r4 x_PM_NAND3_X2%A1_18 x_PM_NAND3_X2%A1_14 3.9
R_x_PM_NAND3_X2%A1_r5 x_PM_NAND3_X2%A1_14 x_PM_NAND3_X2%A1_12 25.0012
R_x_PM_NAND3_X2%A1_r6 x_PM_NAND3_X2%A1_12 A1 0.0459677
R_x_PM_NAND3_X2%A1_r7 x_PM_NAND3_X2%A1_18 x_PM_NAND3_X2%A1_5 1.95
R_x_PM_NAND3_X2%A1_r8 N_A1_M2_g x_PM_NAND3_X2%A1_5 95.94
R_x_PM_NAND3_X2%A1_r9 x_PM_NAND3_X2%A1_18 x_PM_NAND3_X2%A1_VSS 1.95
R_x_PM_NAND3_X2%A1_r10 N_A1_M5_g x_PM_NAND3_X2%A1_VSS 35.1
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND3_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND3_X4 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M6 N_ZN_M0_d N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.540000U L=0.050000U
M_M7 N_VDD_M1_d N_A2_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M8 N_ZN_M2_d N_A1_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M9 N_VDD_M3_d N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M10 N_ZN_M4_d N_A2_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M11 N_VDD_M5_d N_A3_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 7 N_A3_M6_g N_VSS_M6_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 8 N_A2_M7_g 7 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_ZN_M8_d N_A1_M8_g 8 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 9 N_A1_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 10 N_A2_M10_g 9 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M5 N_VSS_M11_d N_A3_M11_g 10 VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_NAND3_X4%VSS_c0 VSS N_VSS_M11_d 4.55408e-17
C_x_PM_NAND3_X4%VSS_c1 VSS x_PM_NAND3_X4%VSS_8 1.10131e-17
C_x_PM_NAND3_X4%VSS_c2 VSS x_PM_NAND3_X4%VSS_7 2.44191e-16
C_x_PM_NAND3_X4%VSS_c3 VSS N_VSS_M6_s 6.05889e-17
R_x_PM_NAND3_X4%VSS_r4 N_VSS_M11_d x_PM_NAND3_X4%VSS_11 1.50643
R_x_PM_NAND3_X4%VSS_r5 VSS x_PM_NAND3_X4%VSS_8 1.24059
R_x_PM_NAND3_X4%VSS_r6 x_PM_NAND3_X4%VSS_11 x_PM_NAND3_X4%VSS_7 0.264221
R_x_PM_NAND3_X4%VSS_r7 VSS x_PM_NAND3_X4%VSS_7 1.15118
R_x_PM_NAND3_X4%VSS_r8 x_PM_NAND3_X4%VSS_8 x_PM_NAND3_X4%VSS_3 0.264221
R_x_PM_NAND3_X4%VSS_r9 N_VSS_M6_s x_PM_NAND3_X4%VSS_3 1.50643
C_x_PM_NAND3_X4%VDD_c0 VSS x_PM_NAND3_X4%VDD_27 2.28129e-17
C_x_PM_NAND3_X4%VDD_c1 VSS x_PM_NAND3_X4%VDD_23 2.27771e-17
C_x_PM_NAND3_X4%VDD_c2 VSS N_VDD_M5_d 5.93988e-17
C_x_PM_NAND3_X4%VDD_c3 VSS x_PM_NAND3_X4%VDD_13 4.29259e-17
C_x_PM_NAND3_X4%VDD_c4 VSS x_PM_NAND3_X4%VDD_11 2.81637e-17
C_x_PM_NAND3_X4%VDD_c5 VSS x_PM_NAND3_X4%VDD_9 2.85474e-17
C_x_PM_NAND3_X4%VDD_c6 VSS N_VDD_M0_s 2.27965e-17
C_x_PM_NAND3_X4%VDD_c7 VSS x_PM_NAND3_X4%VDD_5 1.08104e-17
R_x_PM_NAND3_X4%VDD_r8 x_PM_NAND3_X4%VDD_27 N_VDD_M3_d 0.140674
R_x_PM_NAND3_X4%VDD_r9 x_PM_NAND3_X4%VDD_23 N_VDD_M1_d 0.140674
R_x_PM_NAND3_X4%VDD_r10 N_VDD_M5_d x_PM_NAND3_X4%VDD_15 1.995
R_x_PM_NAND3_X4%VDD_r11 x_PM_NAND3_X4%VDD_15 x_PM_NAND3_X4%VDD_13 0.264221
R_x_PM_NAND3_X4%VDD_r12 x_PM_NAND3_X4%VDD_27 x_PM_NAND3_X4%VDD_13 0.614706
R_x_PM_NAND3_X4%VDD_r13 x_PM_NAND3_X4%VDD_11 N_VDD_M3_d 0.140674
R_x_PM_NAND3_X4%VDD_r14 x_PM_NAND3_X4%VDD_23 x_PM_NAND3_X4%VDD_11 0.558824
R_x_PM_NAND3_X4%VDD_r15 VDD x_PM_NAND3_X4%VDD_10 0.195294
R_x_PM_NAND3_X4%VDD_r16 x_PM_NAND3_X4%VDD_9 N_VDD_M1_d 0.140674
R_x_PM_NAND3_X4%VDD_r17 x_PM_NAND3_X4%VDD_10 x_PM_NAND3_X4%VDD_9 0.614706
R_x_PM_NAND3_X4%VDD_r18 VDD x_PM_NAND3_X4%VDD_5 0.0689273
R_x_PM_NAND3_X4%VDD_r19 N_VDD_M0_s x_PM_NAND3_X4%VDD_5 0.230714
C_x_PM_NAND3_X4%A3_c0 VSS x_PM_NAND3_X4%A3_37 7.04474e-18
C_x_PM_NAND3_X4%A3_c1 VSS x_PM_NAND3_X4%A3_35 2.17203e-17
C_x_PM_NAND3_X4%A3_c2 VSS x_PM_NAND3_X4%A3_32 1.18863e-17
C_x_PM_NAND3_X4%A3_c3 VSS x_PM_NAND3_X4%A3_29 7.35162e-18
C_x_PM_NAND3_X4%A3_c4 VSS x_PM_NAND3_X4%A3_27 1.87168e-17
C_x_PM_NAND3_X4%A3_c5 VSS x_PM_NAND3_X4%A3_26 2.72425e-17
C_x_PM_NAND3_X4%A3_c6 VSS A3 3.76377e-17
C_x_PM_NAND3_X4%A3_c7 VSS x_PM_NAND3_X4%A3_20 3.982e-17
C_x_PM_NAND3_X4%A3_c8 VSS x_PM_NAND3_X4%A3_19 2.81364e-16
C_x_PM_NAND3_X4%A3_c9 VSS x_PM_NAND3_X4%A3_18 4.81618e-17
C_x_PM_NAND3_X4%A3_c10 VSS N_A3_M5_g 8.17604e-17
C_x_PM_NAND3_X4%A3_c11 VSS N_A3_M11_g 4.72824e-17
C_x_PM_NAND3_X4%A3_c12 VSS N_A3_M0_g 7.11048e-17
C_x_PM_NAND3_X4%A3_c13 VSS N_A3_M6_g 4.43532e-17
R_x_PM_NAND3_X4%A3_r14 x_PM_NAND3_X4%A3_44 x_PM_NAND3_X4%A3_37 4.7687
R_x_PM_NAND3_X4%A3_r15 x_PM_NAND3_X4%A3_43 x_PM_NAND3_X4%A3_37 4.7687
R_x_PM_NAND3_X4%A3_r16 x_PM_NAND3_X4%A3_37 x_PM_NAND3_X4%A3_35 25.0012
R_x_PM_NAND3_X4%A3_r17 x_PM_NAND3_X4%A3_35 x_PM_NAND3_X4%A3_33 0.312143
R_x_PM_NAND3_X4%A3_r18 x_PM_NAND3_X4%A3_41 x_PM_NAND3_X4%A3_29 4.7687
R_x_PM_NAND3_X4%A3_r19 x_PM_NAND3_X4%A3_40 x_PM_NAND3_X4%A3_29 4.7687
R_x_PM_NAND3_X4%A3_r20 x_PM_NAND3_X4%A3_29 x_PM_NAND3_X4%A3_27 25.0012
R_x_PM_NAND3_X4%A3_r21 x_PM_NAND3_X4%A3_33 x_PM_NAND3_X4%A3_26 0.095
R_x_PM_NAND3_X4%A3_r22 x_PM_NAND3_X4%A3_26 x_PM_NAND3_X4%A3_32 0.841429
R_x_PM_NAND3_X4%A3_r23 x_PM_NAND3_X4%A3_32 x_PM_NAND3_X4%A3_22 0.196927
R_x_PM_NAND3_X4%A3_r24 A3 x_PM_NAND3_X4%A3_22 0.1425
R_x_PM_NAND3_X4%A3_r25 A3 x_PM_NAND3_X4%A3_21 0.6175
R_x_PM_NAND3_X4%A3_r26 x_PM_NAND3_X4%A3_21 x_PM_NAND3_X4%A3_19 0.213547
R_x_PM_NAND3_X4%A3_r27 x_PM_NAND3_X4%A3_20 x_PM_NAND3_X4%A3_19 4.15286
R_x_PM_NAND3_X4%A3_r28 x_PM_NAND3_X4%A3_18 x_PM_NAND3_X4%A3_27 0.297071
R_x_PM_NAND3_X4%A3_r29 x_PM_NAND3_X4%A3_20 x_PM_NAND3_X4%A3_17 0.212317
R_x_PM_NAND3_X4%A3_r30 x_PM_NAND3_X4%A3_18 x_PM_NAND3_X4%A3_17 1.76429
R_x_PM_NAND3_X4%A3_r31 N_A3_M5_g x_PM_NAND3_X4%A3_44 60.84
R_x_PM_NAND3_X4%A3_r32 N_A3_M11_g x_PM_NAND3_X4%A3_43 34.32
R_x_PM_NAND3_X4%A3_r33 N_A3_M0_g x_PM_NAND3_X4%A3_41 60.84
R_x_PM_NAND3_X4%A3_r34 N_A3_M6_g x_PM_NAND3_X4%A3_40 34.32
C_x_PM_NAND3_X4%ZN_c0 VSS N_ZN_M4_d 6.25386e-17
C_x_PM_NAND3_X4%ZN_c1 VSS N_ZN_M2_d 5.02829e-18
C_x_PM_NAND3_X4%ZN_c2 VSS ZN 3.89653e-17
C_x_PM_NAND3_X4%ZN_c3 VSS x_PM_NAND3_X4%ZN_11 5.45804e-17
C_x_PM_NAND3_X4%ZN_c4 VSS N_ZN_M8_d 1.37261e-16
C_x_PM_NAND3_X4%ZN_c5 VSS x_PM_NAND3_X4%ZN_5 3.12559e-17
R_x_PM_NAND3_X4%ZN_r6 N_ZN_M0_d x_PM_NAND3_X4%ZN_16 0.0140741
R_x_PM_NAND3_X4%ZN_r7 x_PM_NAND3_X4%ZN_16 ZN 0.0914815
R_x_PM_NAND3_X4%ZN_r8 N_ZN_M2_d x_PM_NAND3_X4%ZN_12 0.151873
R_x_PM_NAND3_X4%ZN_r9 N_ZN_M4_d x_PM_NAND3_X4%ZN_11 0.095
R_x_PM_NAND3_X4%ZN_r10 x_PM_NAND3_X4%ZN_12 x_PM_NAND3_X4%ZN_11 1.444
R_x_PM_NAND3_X4%ZN_r11 N_ZN_M2_d x_PM_NAND3_X4%ZN_7 0.0495914
R_x_PM_NAND3_X4%ZN_r12 N_ZN_M8_d x_PM_NAND3_X4%ZN_7 3.02643
R_x_PM_NAND3_X4%ZN_r13 x_PM_NAND3_X4%ZN_16 x_PM_NAND3_X4%ZN_6 0.095
R_x_PM_NAND3_X4%ZN_r14 N_ZN_M2_d x_PM_NAND3_X4%ZN_5 0.151873
R_x_PM_NAND3_X4%ZN_r15 x_PM_NAND3_X4%ZN_6 x_PM_NAND3_X4%ZN_5 1.368
C_x_PM_NAND3_X4%A2_c0 VSS x_PM_NAND3_X4%A2_33 8.44264e-18
C_x_PM_NAND3_X4%A2_c1 VSS x_PM_NAND3_X4%A2_31 2.49082e-17
C_x_PM_NAND3_X4%A2_c2 VSS x_PM_NAND3_X4%A2_30 8.58968e-18
C_x_PM_NAND3_X4%A2_c3 VSS x_PM_NAND3_X4%A2_29 3.33996e-17
C_x_PM_NAND3_X4%A2_c4 VSS x_PM_NAND3_X4%A2_27 2.12921e-17
C_x_PM_NAND3_X4%A2_c5 VSS x_PM_NAND3_X4%A2_26 1.44856e-16
C_x_PM_NAND3_X4%A2_c6 VSS A2 2.98764e-17
C_x_PM_NAND3_X4%A2_c7 VSS x_PM_NAND3_X4%A2_20 8.96557e-18
C_x_PM_NAND3_X4%A2_c8 VSS x_PM_NAND3_X4%A2_17 3.18915e-17
C_x_PM_NAND3_X4%A2_c9 VSS N_A2_M4_g 7.31638e-17
C_x_PM_NAND3_X4%A2_c10 VSS N_A2_M10_g 4.53125e-17
C_x_PM_NAND3_X4%A2_c11 VSS N_A2_M1_g 7.34033e-17
C_x_PM_NAND3_X4%A2_c12 VSS N_A2_M7_g 4.66032e-17
R_x_PM_NAND3_X4%A2_r13 x_PM_NAND3_X4%A2_41 x_PM_NAND3_X4%A2_33 4.7687
R_x_PM_NAND3_X4%A2_r14 x_PM_NAND3_X4%A2_40 x_PM_NAND3_X4%A2_33 4.7687
R_x_PM_NAND3_X4%A2_r15 x_PM_NAND3_X4%A2_33 x_PM_NAND3_X4%A2_31 25.0012
R_x_PM_NAND3_X4%A2_r16 x_PM_NAND3_X4%A2_31 x_PM_NAND3_X4%A2_30 0.130625
R_x_PM_NAND3_X4%A2_r17 x_PM_NAND3_X4%A2_29 x_PM_NAND3_X4%A2_30 0.196927
R_x_PM_NAND3_X4%A2_r18 x_PM_NAND3_X4%A2_29 x_PM_NAND3_X4%A2_28 1.03143
R_x_PM_NAND3_X4%A2_r19 x_PM_NAND3_X4%A2_28 x_PM_NAND3_X4%A2_26 0.212317
R_x_PM_NAND3_X4%A2_r20 x_PM_NAND3_X4%A2_27 x_PM_NAND3_X4%A2_26 1.98143
R_x_PM_NAND3_X4%A2_r21 A2 x_PM_NAND3_X4%A2_23 0.461429
R_x_PM_NAND3_X4%A2_r22 x_PM_NAND3_X4%A2_27 x_PM_NAND3_X4%A2_22 0.212317
R_x_PM_NAND3_X4%A2_r23 A2 x_PM_NAND3_X4%A2_22 0.732857
R_x_PM_NAND3_X4%A2_r24 x_PM_NAND3_X4%A2_38 x_PM_NAND3_X4%A2_20 4.74714
R_x_PM_NAND3_X4%A2_r25 x_PM_NAND3_X4%A2_37 x_PM_NAND3_X4%A2_20 4.74714
R_x_PM_NAND3_X4%A2_r26 x_PM_NAND3_X4%A2_20 x_PM_NAND3_X4%A2_18 25.0012
R_x_PM_NAND3_X4%A2_r27 x_PM_NAND3_X4%A2_23 x_PM_NAND3_X4%A2_17 0.212317
R_x_PM_NAND3_X4%A2_r28 x_PM_NAND3_X4%A2_18 x_PM_NAND3_X4%A2_17 0.339286
R_x_PM_NAND3_X4%A2_r29 N_A2_M4_g x_PM_NAND3_X4%A2_41 60.84
R_x_PM_NAND3_X4%A2_r30 N_A2_M10_g x_PM_NAND3_X4%A2_40 34.32
R_x_PM_NAND3_X4%A2_r31 N_A2_M1_g x_PM_NAND3_X4%A2_38 60.84
R_x_PM_NAND3_X4%A2_r32 N_A2_M7_g x_PM_NAND3_X4%A2_37 34.32
C_x_PM_NAND3_X4%A1_c0 VSS A1 7.85514e-17
C_x_PM_NAND3_X4%A1_c1 VSS x_PM_NAND3_X4%A1_23 6.76882e-18
C_x_PM_NAND3_X4%A1_c2 VSS x_PM_NAND3_X4%A1_21 5.45055e-17
C_x_PM_NAND3_X4%A1_c3 VSS x_PM_NAND3_X4%A1_19 4.34988e-18
C_x_PM_NAND3_X4%A1_c4 VSS N_A1_M3_g 4.86394e-17
C_x_PM_NAND3_X4%A1_c5 VSS N_A1_M9_g 4.45492e-17
C_x_PM_NAND3_X4%A1_c6 VSS x_PM_NAND3_X4%A1_9 1.25055e-17
C_x_PM_NAND3_X4%A1_c7 VSS N_A1_M2_g 5.19352e-17
C_x_PM_NAND3_X4%A1_c8 VSS N_A1_M8_g 4.52798e-17
R_x_PM_NAND3_X4%A1_r9 x_PM_NAND3_X4%A1_30 x_PM_NAND3_X4%A1_29 0.52
R_x_PM_NAND3_X4%A1_r10 x_PM_NAND3_X4%A1_27 A1 0.286226
R_x_PM_NAND3_X4%A1_r11 x_PM_NAND3_X4%A1_23 x_PM_NAND3_X4%A1_30 2.86
R_x_PM_NAND3_X4%A1_r12 x_PM_NAND3_X4%A1_23 x_PM_NAND3_X4%A1_21 25.0012
R_x_PM_NAND3_X4%A1_r13 x_PM_NAND3_X4%A1_21 x_PM_NAND3_X4%A1_27 0.855
R_x_PM_NAND3_X4%A1_r14 x_PM_NAND3_X4%A1_30 x_PM_NAND3_X4%A1_15 1.95
R_x_PM_NAND3_X4%A1_r15 N_A1_M3_g x_PM_NAND3_X4%A1_15 49.92
R_x_PM_NAND3_X4%A1_r16 x_PM_NAND3_X4%A1_29 x_PM_NAND3_X4%A1_11 1.95
R_x_PM_NAND3_X4%A1_r17 N_A1_M9_g x_PM_NAND3_X4%A1_11 45.24
R_x_PM_NAND3_X4%A1_r18 x_PM_NAND3_X4%A1_19 x_PM_NAND3_X4%A1_10 0.043368
R_x_PM_NAND3_X4%A1_r19 x_PM_NAND3_X4%A1_29 x_PM_NAND3_X4%A1_9 2.6
R_x_PM_NAND3_X4%A1_r20 x_PM_NAND3_X4%A1_10 x_PM_NAND3_X4%A1_9 14.56
R_x_PM_NAND3_X4%A1_r21 x_PM_NAND3_X4%A1_19 x_PM_NAND3_X4%A1_5 4.56151
R_x_PM_NAND3_X4%A1_r22 N_A1_M2_g x_PM_NAND3_X4%A1_5 49.92
R_x_PM_NAND3_X4%A1_r23 x_PM_NAND3_X4%A1_19 x_PM_NAND3_X4%A1_VSS 4.56151
R_x_PM_NAND3_X4%A1_r24 N_A1_M8_g x_PM_NAND3_X4%A1_VSS 45.24
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X1 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B A4:I ZN:O A3:I A2:I A1:I
M_M4 N_ZN_M0_d N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 N_VDD_M1_d N_A3_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_ZN_M2_d N_A2_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_VDD_M3_d N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 8 N_A4_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.215000U L=0.050000U
M_M1 9 N_A3_M5_g 8 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M2 10 N_A2_M6_g 9 VSS NMOS_VTL W=0.215000U L=0.050000U
M_M3 N_ZN_M7_d N_A1_M7_g 10 VSS NMOS_VTL W=0.215000U L=0.050000U
C_x_PM_NAND4_X1%VSS_c0 VSS VSS 8.92789e-17
C_x_PM_NAND4_X1%VSS_c1 VSS x_PM_NAND4_X1%VSS_6 1.06295e-17
C_x_PM_NAND4_X1%VSS_c2 VSS N_VSS_M4_s 1.82974e-17
R_x_PM_NAND4_X1%VSS_r3 VSS x_PM_NAND4_X1%VSS_6 0.815882
R_x_PM_NAND4_X1%VSS_r4 x_PM_NAND4_X1%VSS_6 x_PM_NAND4_X1%VSS_2 0.264221
R_x_PM_NAND4_X1%VSS_r5 N_VSS_M4_s x_PM_NAND4_X1%VSS_2 0.230714
C_x_PM_NAND4_X1%VDD_c0 VSS VDD 2.82055e-18
C_x_PM_NAND4_X1%VDD_c1 VSS N_VDD_M3_d 1.89805e-17
C_x_PM_NAND4_X1%VDD_c2 VSS x_PM_NAND4_X1%VDD_14 4.73887e-17
C_x_PM_NAND4_X1%VDD_c3 VSS N_VDD_M1_d 2.41654e-17
C_x_PM_NAND4_X1%VDD_c4 VSS x_PM_NAND4_X1%VDD_9 1.07593e-17
C_x_PM_NAND4_X1%VDD_c5 VSS x_PM_NAND4_X1%VDD_8 3.57384e-17
C_x_PM_NAND4_X1%VDD_c6 VSS N_VDD_M0_s 1.38062e-17
R_x_PM_NAND4_X1%VDD_r7 N_VDD_M3_d x_PM_NAND4_X1%VDD_16 0.393571
R_x_PM_NAND4_X1%VDD_r8 VDD x_PM_NAND4_X1%VDD_15 0.0731438
R_x_PM_NAND4_X1%VDD_r9 x_PM_NAND4_X1%VDD_16 x_PM_NAND4_X1%VDD_14 0.264221
R_x_PM_NAND4_X1%VDD_r10 x_PM_NAND4_X1%VDD_15 x_PM_NAND4_X1%VDD_14 0.681765
R_x_PM_NAND4_X1%VDD_r11 VDD x_PM_NAND4_X1%VDD_10 0.145286
R_x_PM_NAND4_X1%VDD_r12 N_VDD_M1_d x_PM_NAND4_X1%VDD_10 0.393571
R_x_PM_NAND4_X1%VDD_r13 VDD x_PM_NAND4_X1%VDD_8 0.0731438
R_x_PM_NAND4_X1%VDD_r14 x_PM_NAND4_X1%VDD_9 x_PM_NAND4_X1%VDD_8 0.692941
R_x_PM_NAND4_X1%VDD_r15 x_PM_NAND4_X1%VDD_9 x_PM_NAND4_X1%VDD_4 0.264221
R_x_PM_NAND4_X1%VDD_r16 N_VDD_M0_s x_PM_NAND4_X1%VDD_4 0.393571
C_x_PM_NAND4_X1%A4_c0 VSS x_PM_NAND4_X1%A4_14 7.18264e-18
C_x_PM_NAND4_X1%A4_c1 VSS x_PM_NAND4_X1%A4_12 5.01341e-17
C_x_PM_NAND4_X1%A4_c2 VSS N_A4_M0_g 8.15211e-17
C_x_PM_NAND4_X1%A4_c3 VSS N_A4_M4_g 3.26635e-17
R_x_PM_NAND4_X1%A4_r4 x_PM_NAND4_X1%A4_18 x_PM_NAND4_X1%A4_14 4.74714
R_x_PM_NAND4_X1%A4_r5 x_PM_NAND4_X1%A4_17 x_PM_NAND4_X1%A4_14 4.74714
R_x_PM_NAND4_X1%A4_r6 x_PM_NAND4_X1%A4_14 x_PM_NAND4_X1%A4_12 25.0012
R_x_PM_NAND4_X1%A4_r7 x_PM_NAND4_X1%A4_12 A4 0.121389
R_x_PM_NAND4_X1%A4_r8 N_A4_M0_g x_PM_NAND4_X1%A4_18 122.07
R_x_PM_NAND4_X1%A4_r9 N_A4_M4_g x_PM_NAND4_X1%A4_17 24.57
C_x_PM_NAND4_X1%ZN_c0 VSS x_PM_NAND4_X1%ZN_20 2.17438e-18
C_x_PM_NAND4_X1%ZN_c1 VSS N_ZN_M7_d 9.82626e-17
C_x_PM_NAND4_X1%ZN_c2 VSS x_PM_NAND4_X1%ZN_14 2.21929e-17
C_x_PM_NAND4_X1%ZN_c3 VSS x_PM_NAND4_X1%ZN_13 3.92749e-17
C_x_PM_NAND4_X1%ZN_c4 VSS x_PM_NAND4_X1%ZN_10 2.3013e-17
C_x_PM_NAND4_X1%ZN_c5 VSS N_ZN_M0_d 4.45788e-17
C_x_PM_NAND4_X1%ZN_c6 VSS ZN 8.5927e-18
R_x_PM_NAND4_X1%ZN_r7 N_ZN_M7_d x_PM_NAND4_X1%ZN_16 3.86786
R_x_PM_NAND4_X1%ZN_r8 x_PM_NAND4_X1%ZN_20 x_PM_NAND4_X1%ZN_15 0.160909
R_x_PM_NAND4_X1%ZN_r9 x_PM_NAND4_X1%ZN_16 x_PM_NAND4_X1%ZN_14 0.212317
R_x_PM_NAND4_X1%ZN_r10 x_PM_NAND4_X1%ZN_15 x_PM_NAND4_X1%ZN_14 0.678571
R_x_PM_NAND4_X1%ZN_r11 x_PM_NAND4_X1%ZN_20 x_PM_NAND4_X1%ZN_13 0.0418175
R_x_PM_NAND4_X1%ZN_r12 x_PM_NAND4_X1%ZN_13 N_ZN_M2_d 0.543196
R_x_PM_NAND4_X1%ZN_r13 x_PM_NAND4_X1%ZN_20 x_PM_NAND4_X1%ZN_10 0.160909
R_x_PM_NAND4_X1%ZN_r14 x_PM_NAND4_X1%ZN_11 x_PM_NAND4_X1%ZN_10 1.54714
R_x_PM_NAND4_X1%ZN_r15 N_ZN_M0_d ZN 0.592353
R_x_PM_NAND4_X1%ZN_r16 x_PM_NAND4_X1%ZN_11 ZN 0.193838
C_x_PM_NAND4_X1%A3_c0 VSS x_PM_NAND4_X1%A3_14 9.01161e-18
C_x_PM_NAND4_X1%A3_c1 VSS x_PM_NAND4_X1%A3_12 7.59294e-17
C_x_PM_NAND4_X1%A3_c2 VSS N_A3_M1_g 8.94207e-17
C_x_PM_NAND4_X1%A3_c3 VSS N_A3_M5_g 3.26787e-17
R_x_PM_NAND4_X1%A3_r4 x_PM_NAND4_X1%A3_18 x_PM_NAND4_X1%A3_14 4.74714
R_x_PM_NAND4_X1%A3_r5 x_PM_NAND4_X1%A3_17 x_PM_NAND4_X1%A3_14 4.74714
R_x_PM_NAND4_X1%A3_r6 x_PM_NAND4_X1%A3_14 x_PM_NAND4_X1%A3_12 25.0012
R_x_PM_NAND4_X1%A3_r7 x_PM_NAND4_X1%A3_12 A3 0.121389
R_x_PM_NAND4_X1%A3_r8 N_A3_M1_g x_PM_NAND4_X1%A3_18 122.07
R_x_PM_NAND4_X1%A3_r9 N_A3_M5_g x_PM_NAND4_X1%A3_17 24.57
C_x_PM_NAND4_X1%A2_c0 VSS x_PM_NAND4_X1%A2_14 9.37702e-18
C_x_PM_NAND4_X1%A2_c1 VSS x_PM_NAND4_X1%A2_12 7.59339e-17
C_x_PM_NAND4_X1%A2_c2 VSS N_A2_M2_g 9.01665e-17
C_x_PM_NAND4_X1%A2_c3 VSS N_A2_M6_g 3.26494e-17
R_x_PM_NAND4_X1%A2_r4 x_PM_NAND4_X1%A2_18 x_PM_NAND4_X1%A2_14 4.74714
R_x_PM_NAND4_X1%A2_r5 x_PM_NAND4_X1%A2_17 x_PM_NAND4_X1%A2_14 4.74714
R_x_PM_NAND4_X1%A2_r6 x_PM_NAND4_X1%A2_14 x_PM_NAND4_X1%A2_12 25.0012
R_x_PM_NAND4_X1%A2_r7 x_PM_NAND4_X1%A2_12 A2 0.121389
R_x_PM_NAND4_X1%A2_r8 N_A2_M2_g x_PM_NAND4_X1%A2_18 122.07
R_x_PM_NAND4_X1%A2_r9 N_A2_M6_g x_PM_NAND4_X1%A2_17 24.57
C_x_PM_NAND4_X1%A1_c0 VSS x_PM_NAND4_X1%A1_18 1.23471e-17
C_x_PM_NAND4_X1%A1_c1 VSS A1 7.20134e-17
C_x_PM_NAND4_X1%A1_c2 VSS N_A1_M3_g 1.02743e-16
C_x_PM_NAND4_X1%A1_c3 VSS N_A1_M7_g 3.44708e-17
R_x_PM_NAND4_X1%A1_r4 x_PM_NAND4_X1%A1_18 x_PM_NAND4_X1%A1_14 3.9
R_x_PM_NAND4_X1%A1_r5 x_PM_NAND4_X1%A1_14 x_PM_NAND4_X1%A1_12 25.0012
R_x_PM_NAND4_X1%A1_r6 x_PM_NAND4_X1%A1_12 A1 0.15381
R_x_PM_NAND4_X1%A1_r7 x_PM_NAND4_X1%A1_18 x_PM_NAND4_X1%A1_5 1.95
R_x_PM_NAND4_X1%A1_r8 N_A1_M3_g x_PM_NAND4_X1%A1_5 122.07
R_x_PM_NAND4_X1%A1_r9 x_PM_NAND4_X1%A1_18 x_PM_NAND4_X1%A1_VSS 1.95
R_x_PM_NAND4_X1%A1_r10 N_A1_M7_g x_PM_NAND4_X1%A1_VSS 24.57
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X2 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B A4:I ZN:O A3:I A2:I A1:I
M_M4 N_ZN_M0_d N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M5 N_VDD_M1_d N_A3_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M6 N_ZN_M2_d N_A2_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M7 N_VDD_M3_d N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 8 N_A4_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.430000U L=0.050000U
M_M1 9 N_A3_M5_g 8 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M2 10 N_A2_M6_g 9 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M3 N_ZN_M7_d N_A1_M7_g 10 VSS NMOS_VTL W=0.430000U L=0.050000U
C_x_PM_NAND4_X2%VSS_c0 VSS VSS 8.25672e-17
C_x_PM_NAND4_X2%VSS_c1 VSS x_PM_NAND4_X2%VSS_6 1.06295e-17
C_x_PM_NAND4_X2%VSS_c2 VSS N_VSS_M4_s 1.83032e-17
R_x_PM_NAND4_X2%VSS_r3 VSS x_PM_NAND4_X2%VSS_6 0.815882
R_x_PM_NAND4_X2%VSS_r4 x_PM_NAND4_X2%VSS_6 x_PM_NAND4_X2%VSS_2 0.264221
R_x_PM_NAND4_X2%VSS_r5 N_VSS_M4_s x_PM_NAND4_X2%VSS_2 0.230714
C_x_PM_NAND4_X2%VDD_c0 VSS x_PM_NAND4_X2%VDD_21 2.22427e-17
C_x_PM_NAND4_X2%VDD_c1 VSS x_PM_NAND4_X2%VDD_18 2.85296e-17
C_x_PM_NAND4_X2%VDD_c2 VSS N_VDD_M3_d 1.65418e-17
C_x_PM_NAND4_X2%VDD_c3 VSS x_PM_NAND4_X2%VDD_10 4.55249e-17
C_x_PM_NAND4_X2%VDD_c4 VSS x_PM_NAND4_X2%VDD_9 1.06862e-17
C_x_PM_NAND4_X2%VDD_c5 VSS N_VDD_M0_s 2.46607e-17
R_x_PM_NAND4_X2%VDD_r6 x_PM_NAND4_X2%VDD_21 VDD 0.105776
R_x_PM_NAND4_X2%VDD_r7 VDD N_VDD_M1_d 0.034898
R_x_PM_NAND4_X2%VDD_r8 x_PM_NAND4_X2%VDD_18 N_VDD_M1_d 0.140674
R_x_PM_NAND4_X2%VDD_r9 N_VDD_M3_d x_PM_NAND4_X2%VDD_12 0.230714
R_x_PM_NAND4_X2%VDD_r10 x_PM_NAND4_X2%VDD_12 x_PM_NAND4_X2%VDD_10 0.264221
R_x_PM_NAND4_X2%VDD_r11 x_PM_NAND4_X2%VDD_21 x_PM_NAND4_X2%VDD_10 0.614706
R_x_PM_NAND4_X2%VDD_r12 x_PM_NAND4_X2%VDD_9 x_PM_NAND4_X2%VDD_18 0.614706
R_x_PM_NAND4_X2%VDD_r13 x_PM_NAND4_X2%VDD_9 x_PM_NAND4_X2%VDD_4 0.264221
R_x_PM_NAND4_X2%VDD_r14 N_VDD_M0_s x_PM_NAND4_X2%VDD_4 0.230714
C_x_PM_NAND4_X2%A4_c0 VSS x_PM_NAND4_X2%A4_16 6.55889e-18
C_x_PM_NAND4_X2%A4_c1 VSS x_PM_NAND4_X2%A4_14 1.05776e-17
C_x_PM_NAND4_X2%A4_c2 VSS x_PM_NAND4_X2%A4_9 5.54991e-17
C_x_PM_NAND4_X2%A4_c3 VSS N_A4_M0_g 5.70968e-17
C_x_PM_NAND4_X2%A4_c4 VSS N_A4_M4_g 6.56165e-17
R_x_PM_NAND4_X2%A4_r5 x_PM_NAND4_X2%A4_20 x_PM_NAND4_X2%A4_16 4.7687
R_x_PM_NAND4_X2%A4_r6 x_PM_NAND4_X2%A4_19 x_PM_NAND4_X2%A4_16 4.7687
R_x_PM_NAND4_X2%A4_r7 x_PM_NAND4_X2%A4_16 x_PM_NAND4_X2%A4_14 25.0012
R_x_PM_NAND4_X2%A4_r8 x_PM_NAND4_X2%A4_14 x_PM_NAND4_X2%A4_12 0.175926
R_x_PM_NAND4_X2%A4_r9 x_PM_NAND4_X2%A4_12 x_PM_NAND4_X2%A4_9 0.095
R_x_PM_NAND4_X2%A4_r10 A4 x_PM_NAND4_X2%A4_9 0.407143
R_x_PM_NAND4_X2%A4_r11 N_A4_M0_g x_PM_NAND4_X2%A4_20 56.94
R_x_PM_NAND4_X2%A4_r12 N_A4_M4_g x_PM_NAND4_X2%A4_19 67.08
C_x_PM_NAND4_X2%ZN_c0 VSS x_PM_NAND4_X2%ZN_18 4.60917e-18
C_x_PM_NAND4_X2%ZN_c1 VSS x_PM_NAND4_X2%ZN_17 5.36046e-17
C_x_PM_NAND4_X2%ZN_c2 VSS ZN 2.74872e-17
C_x_PM_NAND4_X2%ZN_c3 VSS x_PM_NAND4_X2%ZN_4 1.04221e-16
R_x_PM_NAND4_X2%ZN_r4 x_PM_NAND4_X2%ZN_17 x_PM_NAND4_X2%ZN_18 2.66
R_x_PM_NAND4_X2%ZN_r5 N_ZN_M7_d ZN 0.53
R_x_PM_NAND4_X2%ZN_r6 x_PM_NAND4_X2%ZN_18 x_PM_NAND4_X2%ZN_10 0.217071
R_x_PM_NAND4_X2%ZN_r7 N_ZN_M7_d x_PM_NAND4_X2%ZN_10 0.1
R_x_PM_NAND4_X2%ZN_r8 N_ZN_M2_d N_ZN_M0_d 2.03571
R_x_PM_NAND4_X2%ZN_r9 x_PM_NAND4_X2%ZN_17 x_PM_NAND4_X2%ZN_4 0.212317
R_x_PM_NAND4_X2%ZN_r10 N_ZN_M2_d x_PM_NAND4_X2%ZN_4 0.990714
C_x_PM_NAND4_X2%A3_c0 VSS x_PM_NAND4_X2%A3_16 8.19497e-18
C_x_PM_NAND4_X2%A3_c1 VSS x_PM_NAND4_X2%A3_14 2.87605e-17
C_x_PM_NAND4_X2%A3_c2 VSS x_PM_NAND4_X2%A3_9 4.18416e-17
C_x_PM_NAND4_X2%A3_c3 VSS N_A3_M1_g 7.29487e-17
C_x_PM_NAND4_X2%A3_c4 VSS N_A3_M5_g 5.25208e-17
R_x_PM_NAND4_X2%A3_r5 x_PM_NAND4_X2%A3_20 x_PM_NAND4_X2%A3_16 4.7687
R_x_PM_NAND4_X2%A3_r6 x_PM_NAND4_X2%A3_19 x_PM_NAND4_X2%A3_16 4.7687
R_x_PM_NAND4_X2%A3_r7 x_PM_NAND4_X2%A3_16 x_PM_NAND4_X2%A3_14 25.0012
R_x_PM_NAND4_X2%A3_r8 x_PM_NAND4_X2%A3_14 x_PM_NAND4_X2%A3_12 0.246296
R_x_PM_NAND4_X2%A3_r9 x_PM_NAND4_X2%A3_12 x_PM_NAND4_X2%A3_9 0.095
R_x_PM_NAND4_X2%A3_r10 A3 x_PM_NAND4_X2%A3_9 0.298571
R_x_PM_NAND4_X2%A3_r11 N_A3_M1_g x_PM_NAND4_X2%A3_20 81.9
R_x_PM_NAND4_X2%A3_r12 N_A3_M5_g x_PM_NAND4_X2%A3_19 42.12
C_x_PM_NAND4_X2%A2_c0 VSS A2 3.11586e-17
C_x_PM_NAND4_X2%A2_c1 VSS x_PM_NAND4_X2%A2_12 8.82597e-18
C_x_PM_NAND4_X2%A2_c2 VSS x_PM_NAND4_X2%A2_10 2.65815e-17
C_x_PM_NAND4_X2%A2_c3 VSS N_A2_M2_g 7.35018e-17
C_x_PM_NAND4_X2%A2_c4 VSS N_A2_M6_g 4.85913e-17
R_x_PM_NAND4_X2%A2_r5 x_PM_NAND4_X2%A2_17 A2 0.287272
R_x_PM_NAND4_X2%A2_r6 x_PM_NAND4_X2%A2_20 x_PM_NAND4_X2%A2_12 4.7687
R_x_PM_NAND4_X2%A2_r7 x_PM_NAND4_X2%A2_19 x_PM_NAND4_X2%A2_12 4.7687
R_x_PM_NAND4_X2%A2_r8 x_PM_NAND4_X2%A2_12 x_PM_NAND4_X2%A2_10 25.0012
R_x_PM_NAND4_X2%A2_r9 x_PM_NAND4_X2%A2_10 x_PM_NAND4_X2%A2_17 1.045
R_x_PM_NAND4_X2%A2_r10 N_A2_M2_g x_PM_NAND4_X2%A2_20 81.9
R_x_PM_NAND4_X2%A2_r11 N_A2_M6_g x_PM_NAND4_X2%A2_19 42.12
C_x_PM_NAND4_X2%A1_c0 VSS x_PM_NAND4_X2%A1_14 9.95936e-18
C_x_PM_NAND4_X2%A1_c1 VSS x_PM_NAND4_X2%A1_12 6.14869e-17
C_x_PM_NAND4_X2%A1_c2 VSS N_A1_M3_g 4.84558e-17
C_x_PM_NAND4_X2%A1_c3 VSS N_A1_M7_g 8.95683e-17
R_x_PM_NAND4_X2%A1_r4 x_PM_NAND4_X2%A1_18 x_PM_NAND4_X2%A1_14 4.7687
R_x_PM_NAND4_X2%A1_r5 x_PM_NAND4_X2%A1_17 x_PM_NAND4_X2%A1_14 4.7687
R_x_PM_NAND4_X2%A1_r6 x_PM_NAND4_X2%A1_14 x_PM_NAND4_X2%A1_12 25.0012
R_x_PM_NAND4_X2%A1_r7 x_PM_NAND4_X2%A1_12 A1 0.169643
R_x_PM_NAND4_X2%A1_r8 N_A1_M3_g x_PM_NAND4_X2%A1_18 35.88
R_x_PM_NAND4_X2%A1_r9 N_A1_M7_g x_PM_NAND4_X2%A1_17 88.14
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NAND4_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NAND4_X4 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B ZN:O A4:I A3:I A2:I A1:I
M_M8 N_ZN_M0_d N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M9 N_VDD_M1_d N_A3_M1_g N_ZN_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M10 N_ZN_M2_d N_A2_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M11 N_VDD_M3_d N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M12 N_ZN_M4_d N_A1_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M13 N_VDD_M5_d N_A2_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M14 N_ZN_M6_d N_A3_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M15 N_VDD_M7_d N_A4_M7_g N_ZN_M6_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 8 N_A4_M8_g N_VSS_M8_s VSS NMOS_VTL W=0.430000U L=0.050000U
M_M1 9 N_A3_M9_g 8 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M2 10 N_A2_M10_g 9 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M3 N_ZN_M11_d N_A1_M11_g 10 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M4 11 N_A1_M12_g N_ZN_M11_d VSS NMOS_VTL W=0.430000U L=0.050000U
M_M5 12 N_A2_M13_g 11 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M6 13 N_A3_M14_g 12 VSS NMOS_VTL W=0.430000U L=0.050000U
M_M7 N_VSS_M15_d N_A4_M15_g 13 VSS NMOS_VTL W=0.430000U L=0.050000U
C_x_PM_NAND4_X4%VSS_c0 VSS N_VSS_M15_d 1.19387e-17
C_x_PM_NAND4_X4%VSS_c1 VSS x_PM_NAND4_X4%VSS_8 1.41067e-17
C_x_PM_NAND4_X4%VSS_c2 VSS x_PM_NAND4_X4%VSS_7 1.61367e-16
C_x_PM_NAND4_X4%VSS_c3 VSS N_VSS_M8_s 2.28291e-17
R_x_PM_NAND4_X4%VSS_r4 N_VSS_M15_d x_PM_NAND4_X4%VSS_11 0.230714
R_x_PM_NAND4_X4%VSS_r5 VSS x_PM_NAND4_X4%VSS_8 1.57588
R_x_PM_NAND4_X4%VSS_r6 x_PM_NAND4_X4%VSS_11 x_PM_NAND4_X4%VSS_7 0.264221
R_x_PM_NAND4_X4%VSS_r7 VSS x_PM_NAND4_X4%VSS_7 1.65412
R_x_PM_NAND4_X4%VSS_r8 x_PM_NAND4_X4%VSS_8 x_PM_NAND4_X4%VSS_3 0.264221
R_x_PM_NAND4_X4%VSS_r9 N_VSS_M8_s x_PM_NAND4_X4%VSS_3 0.230714
C_x_PM_NAND4_X4%VDD_c0 VSS x_PM_NAND4_X4%VDD_38 2.64443e-18
C_x_PM_NAND4_X4%VDD_c1 VSS x_PM_NAND4_X4%VDD_37 2.64443e-18
C_x_PM_NAND4_X4%VDD_c2 VSS x_PM_NAND4_X4%VDD_36 2.64443e-18
C_x_PM_NAND4_X4%VDD_c3 VSS N_VDD_M7_d 2.34474e-17
C_x_PM_NAND4_X4%VDD_c4 VSS x_PM_NAND4_X4%VDD_30 4.34218e-17
C_x_PM_NAND4_X4%VDD_c5 VSS N_VDD_M5_d 1.58672e-17
C_x_PM_NAND4_X4%VDD_c6 VSS x_PM_NAND4_X4%VDD_24 3.38725e-17
C_x_PM_NAND4_X4%VDD_c7 VSS N_VDD_M3_d 1.58956e-17
C_x_PM_NAND4_X4%VDD_c8 VSS x_PM_NAND4_X4%VDD_16 3.38689e-17
C_x_PM_NAND4_X4%VDD_c9 VSS N_VDD_M1_d 1.58419e-17
C_x_PM_NAND4_X4%VDD_c10 VSS x_PM_NAND4_X4%VDD_11 1.40236e-17
C_x_PM_NAND4_X4%VDD_c11 VSS x_PM_NAND4_X4%VDD_10 3.37872e-17
C_x_PM_NAND4_X4%VDD_c12 VSS N_VDD_M0_s 1.61372e-17
R_x_PM_NAND4_X4%VDD_r13 N_VDD_M7_d x_PM_NAND4_X4%VDD_32 0.230714
R_x_PM_NAND4_X4%VDD_r14 x_PM_NAND4_X4%VDD_38 x_PM_NAND4_X4%VDD_31 0.0731438
R_x_PM_NAND4_X4%VDD_r15 x_PM_NAND4_X4%VDD_32 x_PM_NAND4_X4%VDD_30 0.264221
R_x_PM_NAND4_X4%VDD_r16 x_PM_NAND4_X4%VDD_31 x_PM_NAND4_X4%VDD_30 0.692941
R_x_PM_NAND4_X4%VDD_r17 x_PM_NAND4_X4%VDD_38 x_PM_NAND4_X4%VDD_26 0.145286
R_x_PM_NAND4_X4%VDD_r18 N_VDD_M5_d x_PM_NAND4_X4%VDD_26 0.230714
R_x_PM_NAND4_X4%VDD_r19 x_PM_NAND4_X4%VDD_37 x_PM_NAND4_X4%VDD_25 0.0731438
R_x_PM_NAND4_X4%VDD_r20 x_PM_NAND4_X4%VDD_38 x_PM_NAND4_X4%VDD_24 0.0731438
R_x_PM_NAND4_X4%VDD_r21 x_PM_NAND4_X4%VDD_25 x_PM_NAND4_X4%VDD_24 0.692941
R_x_PM_NAND4_X4%VDD_r22 VDD N_VDD_M3_d 0.0135714
R_x_PM_NAND4_X4%VDD_r23 x_PM_NAND4_X4%VDD_37 x_PM_NAND4_X4%VDD_18 0.145286
R_x_PM_NAND4_X4%VDD_r24 VDD x_PM_NAND4_X4%VDD_18 0.217143
R_x_PM_NAND4_X4%VDD_r25 x_PM_NAND4_X4%VDD_36 x_PM_NAND4_X4%VDD_17 0.0731438
R_x_PM_NAND4_X4%VDD_r26 x_PM_NAND4_X4%VDD_37 x_PM_NAND4_X4%VDD_16 0.0731438
R_x_PM_NAND4_X4%VDD_r27 x_PM_NAND4_X4%VDD_17 x_PM_NAND4_X4%VDD_16 0.692941
R_x_PM_NAND4_X4%VDD_r28 x_PM_NAND4_X4%VDD_36 x_PM_NAND4_X4%VDD_12 0.145286
R_x_PM_NAND4_X4%VDD_r29 N_VDD_M1_d x_PM_NAND4_X4%VDD_12 0.230714
R_x_PM_NAND4_X4%VDD_r30 x_PM_NAND4_X4%VDD_36 x_PM_NAND4_X4%VDD_10 0.0731438
R_x_PM_NAND4_X4%VDD_r31 x_PM_NAND4_X4%VDD_11 x_PM_NAND4_X4%VDD_10 0.681765
R_x_PM_NAND4_X4%VDD_r32 x_PM_NAND4_X4%VDD_11 x_PM_NAND4_X4%VDD_6 0.264221
R_x_PM_NAND4_X4%VDD_r33 N_VDD_M0_s x_PM_NAND4_X4%VDD_6 0.230714
C_x_PM_NAND4_X4%ZN_c0 VSS N_ZN_M6_d 2.66236e-16
C_x_PM_NAND4_X4%ZN_c1 VSS x_PM_NAND4_X4%ZN_14 1.30753e-17
C_x_PM_NAND4_X4%ZN_c2 VSS N_ZN_M11_d 1.75234e-16
C_x_PM_NAND4_X4%ZN_c3 VSS x_PM_NAND4_X4%ZN_10 1.56085e-17
C_x_PM_NAND4_X4%ZN_c4 VSS ZN 7.91176e-17
R_x_PM_NAND4_X4%ZN_r5 N_ZN_M6_d N_ZN_M4_d 2.06286
R_x_PM_NAND4_X4%ZN_r6 N_ZN_M4_d N_ZN_M2_d 2.06286
R_x_PM_NAND4_X4%ZN_r7 N_ZN_M2_d N_ZN_M0_d 2.03571
R_x_PM_NAND4_X4%ZN_r8 N_ZN_M0_d x_PM_NAND4_X4%ZN_14 0.963571
R_x_PM_NAND4_X4%ZN_r9 N_ZN_M11_d x_PM_NAND4_X4%ZN_10 4.03071
R_x_PM_NAND4_X4%ZN_r10 x_PM_NAND4_X4%ZN_14 x_PM_NAND4_X4%ZN_7 0.212317
R_x_PM_NAND4_X4%ZN_r11 ZN x_PM_NAND4_X4%ZN_7 2.25286
R_x_PM_NAND4_X4%ZN_r12 x_PM_NAND4_X4%ZN_10 x_PM_NAND4_X4%ZN_6 0.212317
R_x_PM_NAND4_X4%ZN_r13 ZN x_PM_NAND4_X4%ZN_6 1.57429
C_x_PM_NAND4_X4%A4_c0 VSS x_PM_NAND4_X4%A4_29 1.82878e-17
C_x_PM_NAND4_X4%A4_c1 VSS A4 2.19468e-17
C_x_PM_NAND4_X4%A4_c2 VSS x_PM_NAND4_X4%A4_23 7.28778e-18
C_x_PM_NAND4_X4%A4_c3 VSS x_PM_NAND4_X4%A4_21 3.83813e-17
C_x_PM_NAND4_X4%A4_c4 VSS x_PM_NAND4_X4%A4_20 2.79774e-16
C_x_PM_NAND4_X4%A4_c5 VSS x_PM_NAND4_X4%A4_19 4.75548e-17
C_x_PM_NAND4_X4%A4_c6 VSS x_PM_NAND4_X4%A4_18 1.02283e-17
C_x_PM_NAND4_X4%A4_c7 VSS N_A4_M7_g 7.05401e-17
C_x_PM_NAND4_X4%A4_c8 VSS N_A4_M15_g 4.89216e-17
C_x_PM_NAND4_X4%A4_c9 VSS N_A4_M0_g 7.95287e-17
C_x_PM_NAND4_X4%A4_c10 VSS N_A4_M8_g 5.88224e-17
R_x_PM_NAND4_X4%A4_r11 x_PM_NAND4_X4%A4_29 x_PM_NAND4_X4%A4_28 0.213353
R_x_PM_NAND4_X4%A4_r12 x_PM_NAND4_X4%A4_28 A4 0.212353
R_x_PM_NAND4_X4%A4_r13 x_PM_NAND4_X4%A4_35 x_PM_NAND4_X4%A4_23 4.7687
R_x_PM_NAND4_X4%A4_r14 x_PM_NAND4_X4%A4_34 x_PM_NAND4_X4%A4_23 4.7687
R_x_PM_NAND4_X4%A4_r15 x_PM_NAND4_X4%A4_29 x_PM_NAND4_X4%A4_22 0.543196
R_x_PM_NAND4_X4%A4_r16 x_PM_NAND4_X4%A4_23 x_PM_NAND4_X4%A4_22 25.0012
R_x_PM_NAND4_X4%A4_r17 x_PM_NAND4_X4%A4_28 x_PM_NAND4_X4%A4_20 0.095
R_x_PM_NAND4_X4%A4_r18 x_PM_NAND4_X4%A4_21 x_PM_NAND4_X4%A4_20 6.10714
R_x_PM_NAND4_X4%A4_r19 x_PM_NAND4_X4%A4_21 x_PM_NAND4_X4%A4_19 0.212317
R_x_PM_NAND4_X4%A4_r20 x_PM_NAND4_X4%A4_32 x_PM_NAND4_X4%A4_18 4.74714
R_x_PM_NAND4_X4%A4_r21 x_PM_NAND4_X4%A4_31 x_PM_NAND4_X4%A4_18 4.74714
R_x_PM_NAND4_X4%A4_r22 x_PM_NAND4_X4%A4_19 x_PM_NAND4_X4%A4_17 0.543196
R_x_PM_NAND4_X4%A4_r23 x_PM_NAND4_X4%A4_18 x_PM_NAND4_X4%A4_17 25.0012
R_x_PM_NAND4_X4%A4_r24 N_A4_M7_g x_PM_NAND4_X4%A4_35 81.9
R_x_PM_NAND4_X4%A4_r25 N_A4_M15_g x_PM_NAND4_X4%A4_34 42.12
R_x_PM_NAND4_X4%A4_r26 N_A4_M0_g x_PM_NAND4_X4%A4_32 81.9
R_x_PM_NAND4_X4%A4_r27 N_A4_M8_g x_PM_NAND4_X4%A4_31 42.12
C_x_PM_NAND4_X4%A3_c0 VSS x_PM_NAND4_X4%A3_30 7.70321e-18
C_x_PM_NAND4_X4%A3_c1 VSS x_PM_NAND4_X4%A3_28 6.45866e-17
C_x_PM_NAND4_X4%A3_c2 VSS x_PM_NAND4_X4%A3_27 1.56965e-16
C_x_PM_NAND4_X4%A3_c3 VSS x_PM_NAND4_X4%A3_23 7.84128e-18
C_x_PM_NAND4_X4%A3_c4 VSS x_PM_NAND4_X4%A3_20 8.44894e-18
C_x_PM_NAND4_X4%A3_c5 VSS x_PM_NAND4_X4%A3_17 3.24212e-17
C_x_PM_NAND4_X4%A3_c6 VSS N_A3_M6_g 7.29531e-17
C_x_PM_NAND4_X4%A3_c7 VSS N_A3_M14_g 5.69607e-17
C_x_PM_NAND4_X4%A3_c8 VSS N_A3_M1_g 7.43059e-17
C_x_PM_NAND4_X4%A3_c9 VSS N_A3_M9_g 5.9886e-17
R_x_PM_NAND4_X4%A3_r10 x_PM_NAND4_X4%A3_37 x_PM_NAND4_X4%A3_30 4.7687
R_x_PM_NAND4_X4%A3_r11 x_PM_NAND4_X4%A3_36 x_PM_NAND4_X4%A3_30 4.7687
R_x_PM_NAND4_X4%A3_r12 x_PM_NAND4_X4%A3_30 x_PM_NAND4_X4%A3_28 25.0012
R_x_PM_NAND4_X4%A3_r13 x_PM_NAND4_X4%A3_28 A3 0.278214
R_x_PM_NAND4_X4%A3_r14 x_PM_NAND4_X4%A3_27 A3 0.176411
R_x_PM_NAND4_X4%A3_r15 x_PM_NAND4_X4%A3_23 x_PM_NAND4_X4%A3_27 3.648
R_x_PM_NAND4_X4%A3_r16 x_PM_NAND4_X4%A3_34 x_PM_NAND4_X4%A3_20 4.7687
R_x_PM_NAND4_X4%A3_r17 x_PM_NAND4_X4%A3_33 x_PM_NAND4_X4%A3_20 4.7687
R_x_PM_NAND4_X4%A3_r18 x_PM_NAND4_X4%A3_20 x_PM_NAND4_X4%A3_18 25.0012
R_x_PM_NAND4_X4%A3_r19 x_PM_NAND4_X4%A3_23 x_PM_NAND4_X4%A3_17 0.196207
R_x_PM_NAND4_X4%A3_r20 x_PM_NAND4_X4%A3_18 x_PM_NAND4_X4%A3_17 0.111765
R_x_PM_NAND4_X4%A3_r21 N_A3_M6_g x_PM_NAND4_X4%A3_37 81.9
R_x_PM_NAND4_X4%A3_r22 N_A3_M14_g x_PM_NAND4_X4%A3_36 42.12
R_x_PM_NAND4_X4%A3_r23 N_A3_M1_g x_PM_NAND4_X4%A3_34 81.9
R_x_PM_NAND4_X4%A3_r24 N_A3_M9_g x_PM_NAND4_X4%A3_33 42.12
C_x_PM_NAND4_X4%A2_c0 VSS x_PM_NAND4_X4%A2_28 5.76104e-17
C_x_PM_NAND4_X4%A2_c1 VSS x_PM_NAND4_X4%A2_27 8.28214e-18
C_x_PM_NAND4_X4%A2_c2 VSS x_PM_NAND4_X4%A2_20 8.40513e-18
C_x_PM_NAND4_X4%A2_c3 VSS x_PM_NAND4_X4%A2_18 1.52429e-16
C_x_PM_NAND4_X4%A2_c4 VSS N_A2_M5_g 4.30581e-17
C_x_PM_NAND4_X4%A2_c5 VSS N_A2_M13_g 9.13838e-17
C_x_PM_NAND4_X4%A2_c6 VSS N_A2_M2_g 4.54816e-17
C_x_PM_NAND4_X4%A2_c7 VSS N_A2_M10_g 9.07034e-17
R_x_PM_NAND4_X4%A2_r8 x_PM_NAND4_X4%A2_31 x_PM_NAND4_X4%A2_27 4.7687
R_x_PM_NAND4_X4%A2_r9 x_PM_NAND4_X4%A2_30 x_PM_NAND4_X4%A2_27 4.7687
R_x_PM_NAND4_X4%A2_r10 x_PM_NAND4_X4%A2_27 x_PM_NAND4_X4%A2_25 25.0012
R_x_PM_NAND4_X4%A2_r11 x_PM_NAND4_X4%A2_28 x_PM_NAND4_X4%A2_25 0.183151
R_x_PM_NAND4_X4%A2_r12 x_PM_NAND4_X4%A2_25 A2 0.346071
R_x_PM_NAND4_X4%A2_r13 x_PM_NAND4_X4%A2_34 x_PM_NAND4_X4%A2_20 4.7687
R_x_PM_NAND4_X4%A2_r14 x_PM_NAND4_X4%A2_33 x_PM_NAND4_X4%A2_20 4.7687
R_x_PM_NAND4_X4%A2_r15 x_PM_NAND4_X4%A2_20 x_PM_NAND4_X4%A2_18 25.0012
R_x_PM_NAND4_X4%A2_r16 x_PM_NAND4_X4%A2_18 x_PM_NAND4_X4%A2_28 2.91786
R_x_PM_NAND4_X4%A2_r17 N_A2_M5_g x_PM_NAND4_X4%A2_34 30.42
R_x_PM_NAND4_X4%A2_r18 N_A2_M13_g x_PM_NAND4_X4%A2_33 93.6
R_x_PM_NAND4_X4%A2_r19 N_A2_M2_g x_PM_NAND4_X4%A2_31 35.88
R_x_PM_NAND4_X4%A2_r20 N_A2_M10_g x_PM_NAND4_X4%A2_30 88.14
C_x_PM_NAND4_X4%A1_c0 VSS A1 6.80475e-17
C_x_PM_NAND4_X4%A1_c1 VSS x_PM_NAND4_X4%A1_22 3.54503e-18
C_x_PM_NAND4_X4%A1_c2 VSS x_PM_NAND4_X4%A1_19 4.24011e-18
C_x_PM_NAND4_X4%A1_c3 VSS N_A1_M4_g 5.09945e-17
C_x_PM_NAND4_X4%A1_c4 VSS N_A1_M12_g 5.53228e-17
C_x_PM_NAND4_X4%A1_c5 VSS x_PM_NAND4_X4%A1_9 7.35121e-18
C_x_PM_NAND4_X4%A1_c6 VSS N_A1_M3_g 5.03213e-17
C_x_PM_NAND4_X4%A1_c7 VSS N_A1_M11_g 5.87959e-17
R_x_PM_NAND4_X4%A1_r8 x_PM_NAND4_X4%A1_22 x_PM_NAND4_X4%A1_20 25.0012
R_x_PM_NAND4_X4%A1_r9 A1 x_PM_NAND4_X4%A1_20 0.169643
R_x_PM_NAND4_X4%A1_r10 x_PM_NAND4_X4%A1_19 x_PM_NAND4_X4%A1_15 4.56151
R_x_PM_NAND4_X4%A1_r11 N_A1_M4_g x_PM_NAND4_X4%A1_15 63.18
R_x_PM_NAND4_X4%A1_r12 x_PM_NAND4_X4%A1_19 x_PM_NAND4_X4%A1_11 4.56151
R_x_PM_NAND4_X4%A1_r13 N_A1_M12_g x_PM_NAND4_X4%A1_11 60.84
R_x_PM_NAND4_X4%A1_r14 x_PM_NAND4_X4%A1_22 x_PM_NAND4_X4%A1_10 0.043368
R_x_PM_NAND4_X4%A1_r15 x_PM_NAND4_X4%A1_19 x_PM_NAND4_X4%A1_9 0.043368
R_x_PM_NAND4_X4%A1_r16 x_PM_NAND4_X4%A1_10 x_PM_NAND4_X4%A1_9 14.56
R_x_PM_NAND4_X4%A1_r17 x_PM_NAND4_X4%A1_22 x_PM_NAND4_X4%A1_5 4.56151
R_x_PM_NAND4_X4%A1_r18 N_A1_M3_g x_PM_NAND4_X4%A1_5 63.18
R_x_PM_NAND4_X4%A1_r19 x_PM_NAND4_X4%A1_22 x_PM_NAND4_X4%A1_VSS 4.56151
R_x_PM_NAND4_X4%A1_r20 N_A1_M11_g x_PM_NAND4_X4%A1_VSS 60.84
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X1 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M2 6 N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M3 N_ZN_M1_d N_A1_M1_g 6 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_ZN_M2_d N_A2_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M3_d N_A1_M3_g N_ZN_M2_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_NOR2_X1%VSS_c0 VSS N_VSS_M3_d 2.60677e-17
C_x_PM_NOR2_X1%VSS_c1 VSS x_PM_NOR2_X1%VSS_8 1.06531e-17
C_x_PM_NOR2_X1%VSS_c2 VSS x_PM_NOR2_X1%VSS_7 5.20704e-17
C_x_PM_NOR2_X1%VSS_c3 VSS N_VSS_M2_s 1.85338e-17
R_x_PM_NOR2_X1%VSS_r4 N_VSS_M3_d x_PM_NOR2_X1%VSS_11 0.339286
R_x_PM_NOR2_X1%VSS_r5 VSS x_PM_NOR2_X1%VSS_8 0.391176
R_x_PM_NOR2_X1%VSS_r6 x_PM_NOR2_X1%VSS_11 x_PM_NOR2_X1%VSS_7 0.264221
R_x_PM_NOR2_X1%VSS_r7 VSS x_PM_NOR2_X1%VSS_7 0.335294
R_x_PM_NOR2_X1%VSS_r8 x_PM_NOR2_X1%VSS_8 x_PM_NOR2_X1%VSS_3 0.264221
R_x_PM_NOR2_X1%VSS_r9 N_VSS_M2_s x_PM_NOR2_X1%VSS_3 0.637857
C_x_PM_NOR2_X1%VDD_c0 VSS VDD 5.52816e-17
C_x_PM_NOR2_X1%VDD_c1 VSS x_PM_NOR2_X1%VDD_6 1.04465e-17
C_x_PM_NOR2_X1%VDD_c2 VSS N_VDD_M0_s 1.80692e-17
R_x_PM_NOR2_X1%VDD_r3 VDD x_PM_NOR2_X1%VDD_6 0.391176
R_x_PM_NOR2_X1%VDD_r4 x_PM_NOR2_X1%VDD_6 x_PM_NOR2_X1%VDD_2 0.264221
R_x_PM_NOR2_X1%VDD_r5 N_VDD_M0_s x_PM_NOR2_X1%VDD_2 0.230714
C_x_PM_NOR2_X1%A2_c0 VSS x_PM_NOR2_X1%A2_14 7.56511e-18
C_x_PM_NOR2_X1%A2_c1 VSS x_PM_NOR2_X1%A2_12 4.58819e-17
C_x_PM_NOR2_X1%A2_c2 VSS N_A2_M0_g 3.13264e-17
C_x_PM_NOR2_X1%A2_c3 VSS N_A2_M2_g 8.14668e-17
R_x_PM_NOR2_X1%A2_r4 x_PM_NOR2_X1%A2_18 x_PM_NOR2_X1%A2_14 4.74714
R_x_PM_NOR2_X1%A2_r5 x_PM_NOR2_X1%A2_17 x_PM_NOR2_X1%A2_14 4.74714
R_x_PM_NOR2_X1%A2_r6 x_PM_NOR2_X1%A2_14 x_PM_NOR2_X1%A2_12 25.0012
R_x_PM_NOR2_X1%A2_r7 x_PM_NOR2_X1%A2_12 A2 0.136562
R_x_PM_NOR2_X1%A2_r8 N_A2_M0_g x_PM_NOR2_X1%A2_18 23.01
R_x_PM_NOR2_X1%A2_r9 N_A2_M2_g x_PM_NOR2_X1%A2_17 121.68
C_x_PM_NOR2_X1%ZN_c0 VSS ZN 1.15489e-16
C_x_PM_NOR2_X1%ZN_c1 VSS x_PM_NOR2_X1%ZN_8 7.21363e-18
C_x_PM_NOR2_X1%ZN_c2 VSS x_PM_NOR2_X1%ZN_7 3.65428e-17
C_x_PM_NOR2_X1%ZN_c3 VSS N_ZN_M2_d 3.41469e-17
R_x_PM_NOR2_X1%ZN_r4 N_ZN_M1_d ZN 2.79722
R_x_PM_NOR2_X1%ZN_r5 ZN x_PM_NOR2_X1%ZN_9 0.591111
R_x_PM_NOR2_X1%ZN_r6 x_PM_NOR2_X1%ZN_9 x_PM_NOR2_X1%ZN_7 0.21666
R_x_PM_NOR2_X1%ZN_r7 x_PM_NOR2_X1%ZN_8 x_PM_NOR2_X1%ZN_7 0.624286
R_x_PM_NOR2_X1%ZN_r8 x_PM_NOR2_X1%ZN_8 x_PM_NOR2_X1%ZN_3 0.212317
R_x_PM_NOR2_X1%ZN_r9 N_ZN_M2_d x_PM_NOR2_X1%ZN_3 0.339286
C_x_PM_NOR2_X1%A1_c0 VSS x_PM_NOR2_X1%A1_18 1.23408e-17
C_x_PM_NOR2_X1%A1_c1 VSS x_PM_NOR2_X1%A1_12 6.46217e-17
C_x_PM_NOR2_X1%A1_c2 VSS N_A1_M1_g 3.31433e-17
C_x_PM_NOR2_X1%A1_c3 VSS N_A1_M3_g 1.02586e-16
R_x_PM_NOR2_X1%A1_r4 x_PM_NOR2_X1%A1_18 x_PM_NOR2_X1%A1_14 3.9
R_x_PM_NOR2_X1%A1_r5 x_PM_NOR2_X1%A1_14 x_PM_NOR2_X1%A1_12 25.0012
R_x_PM_NOR2_X1%A1_r6 x_PM_NOR2_X1%A1_12 A1 0.0890625
R_x_PM_NOR2_X1%A1_r7 x_PM_NOR2_X1%A1_18 x_PM_NOR2_X1%A1_5 1.95
R_x_PM_NOR2_X1%A1_r8 N_A1_M1_g x_PM_NOR2_X1%A1_5 23.01
R_x_PM_NOR2_X1%A1_r9 x_PM_NOR2_X1%A1_18 x_PM_NOR2_X1%A1_VSS 1.95
R_x_PM_NOR2_X1%A1_r10 N_A1_M3_g x_PM_NOR2_X1%A1_VSS 121.68
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X2 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M2 6 N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M3 N_ZN_M1_d N_A1_M1_g 6 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_ZN_M2_d N_A2_M2_g N_VSS_M2_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M3_d N_A1_M3_g N_ZN_M2_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_NOR2_X2%VSS_c0 VSS N_VSS_M3_d 1.9003e-17
C_x_PM_NOR2_X2%VSS_c1 VSS x_PM_NOR2_X2%VSS_8 1.14613e-17
C_x_PM_NOR2_X2%VSS_c2 VSS x_PM_NOR2_X2%VSS_7 5.12113e-17
C_x_PM_NOR2_X2%VSS_c3 VSS N_VSS_M2_s 1.7976e-17
R_x_PM_NOR2_X2%VSS_r4 N_VSS_M3_d x_PM_NOR2_X2%VSS_11 0.230714
R_x_PM_NOR2_X2%VSS_r5 VSS x_PM_NOR2_X2%VSS_8 0.357647
R_x_PM_NOR2_X2%VSS_r6 x_PM_NOR2_X2%VSS_11 x_PM_NOR2_X2%VSS_7 0.264221
R_x_PM_NOR2_X2%VSS_r7 VSS x_PM_NOR2_X2%VSS_7 0.324118
R_x_PM_NOR2_X2%VSS_r8 x_PM_NOR2_X2%VSS_8 x_PM_NOR2_X2%VSS_3 0.264221
R_x_PM_NOR2_X2%VSS_r9 N_VSS_M2_s x_PM_NOR2_X2%VSS_3 0.230714
C_x_PM_NOR2_X2%VDD_c0 VSS VDD 5.55967e-17
C_x_PM_NOR2_X2%VDD_c1 VSS N_VDD_M0_s 2.30938e-17
R_x_PM_NOR2_X2%VDD_r2 x_PM_NOR2_X2%VDD_10 VDD 0.0881799
R_x_PM_NOR2_X2%VDD_r3 N_VDD_M0_s x_PM_NOR2_X2%VDD_10 0.230714
C_x_PM_NOR2_X2%A2_c0 VSS x_PM_NOR2_X2%A2_18 8.24826e-18
C_x_PM_NOR2_X2%A2_c1 VSS x_PM_NOR2_X2%A2_12 4.45792e-17
C_x_PM_NOR2_X2%A2_c2 VSS N_A2_M0_g 9.21574e-17
C_x_PM_NOR2_X2%A2_c3 VSS N_A2_M2_g 3.09335e-17
R_x_PM_NOR2_X2%A2_r4 x_PM_NOR2_X2%A2_18 x_PM_NOR2_X2%A2_14 3.38
R_x_PM_NOR2_X2%A2_r5 x_PM_NOR2_X2%A2_14 x_PM_NOR2_X2%A2_12 25.0012
R_x_PM_NOR2_X2%A2_r6 x_PM_NOR2_X2%A2_12 A2 0.15069
R_x_PM_NOR2_X2%A2_r7 x_PM_NOR2_X2%A2_18 x_PM_NOR2_X2%A2_5 1.95
R_x_PM_NOR2_X2%A2_r8 N_A2_M0_g x_PM_NOR2_X2%A2_5 112.32
R_x_PM_NOR2_X2%A2_r9 x_PM_NOR2_X2%A2_18 x_PM_NOR2_X2%A2_VSS 1.95
R_x_PM_NOR2_X2%A2_r10 N_A2_M2_g x_PM_NOR2_X2%A2_VSS 21.84
C_x_PM_NOR2_X2%ZN_c0 VSS N_ZN_M1_d 5.96075e-17
C_x_PM_NOR2_X2%ZN_c1 VSS x_PM_NOR2_X2%ZN_9 3.74417e-17
C_x_PM_NOR2_X2%ZN_c2 VSS ZN 7.19517e-18
C_x_PM_NOR2_X2%ZN_c3 VSS N_ZN_M2_d 8.47483e-17
R_x_PM_NOR2_X2%ZN_r4 N_ZN_M1_d x_PM_NOR2_X2%ZN_11 2.91786
R_x_PM_NOR2_X2%ZN_r5 x_PM_NOR2_X2%ZN_11 x_PM_NOR2_X2%ZN_9 0.212317
R_x_PM_NOR2_X2%ZN_r6 x_PM_NOR2_X2%ZN_10 x_PM_NOR2_X2%ZN_9 0.597143
R_x_PM_NOR2_X2%ZN_r7 x_PM_NOR2_X2%ZN_10 ZN 0.212317
R_x_PM_NOR2_X2%ZN_r8 ZN x_PM_NOR2_X2%ZN_7 0.000542857
R_x_PM_NOR2_X2%ZN_r9 x_PM_NOR2_X2%ZN_7 N_ZN_M2_d 1.39731
C_x_PM_NOR2_X2%A1_c0 VSS A1 6.50458e-17
C_x_PM_NOR2_X2%A1_c1 VSS x_PM_NOR2_X2%A1_11 9.81933e-18
C_x_PM_NOR2_X2%A1_c2 VSS N_A1_M1_g 1.07185e-16
C_x_PM_NOR2_X2%A1_c3 VSS N_A1_M3_g 3.09279e-17
R_x_PM_NOR2_X2%A1_r4 x_PM_NOR2_X2%A1_11 x_PM_NOR2_X2%A1_16 4.42
R_x_PM_NOR2_X2%A1_r5 x_PM_NOR2_X2%A1_11 x_PM_NOR2_X2%A1_9 25.0012
R_x_PM_NOR2_X2%A1_r6 A1 x_PM_NOR2_X2%A1_9 0.15069
R_x_PM_NOR2_X2%A1_r7 x_PM_NOR2_X2%A1_16 x_PM_NOR2_X2%A1_5 1.95
R_x_PM_NOR2_X2%A1_r8 N_A1_M1_g x_PM_NOR2_X2%A1_5 112.32
R_x_PM_NOR2_X2%A1_r9 x_PM_NOR2_X2%A1_16 x_PM_NOR2_X2%A1_VSS 1.95
R_x_PM_NOR2_X2%A1_r10 N_A1_M3_g x_PM_NOR2_X2%A1_VSS 21.84
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR2_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR2_X4 VSS VDD A2 ZN A1
*.PININFO VSS:B VDD:B A2:I ZN:O A1:I
M_M2 6 N_A2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M3 N_ZN_M1_d N_A1_M1_g 6 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M4 7 N_A1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_VDD_M3_d N_A2_M3_g 7 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_ZN_M4_d N_A2_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_VSS_M5_d N_A1_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_NOR2_X4%VSS_c0 VSS x_PM_NOR2_X4%VSS_17 4.37615e-17
C_x_PM_NOR2_X4%VSS_c1 VSS VSS 1.01739e-17
C_x_PM_NOR2_X4%VSS_c2 VSS x_PM_NOR2_X4%VSS_8 1.2044e-17
C_x_PM_NOR2_X4%VSS_c3 VSS x_PM_NOR2_X4%VSS_7 3.21771e-17
C_x_PM_NOR2_X4%VSS_c4 VSS N_VSS_M4_s 2.3638e-17
R_x_PM_NOR2_X4%VSS_r5 N_VSS_M5_d VSS 0.0135714
R_x_PM_NOR2_X4%VSS_r6 x_PM_NOR2_X4%VSS_17 x_PM_NOR2_X4%VSS_9 0.145286
R_x_PM_NOR2_X4%VSS_r7 VSS x_PM_NOR2_X4%VSS_9 0.217143
R_x_PM_NOR2_X4%VSS_r8 x_PM_NOR2_X4%VSS_17 x_PM_NOR2_X4%VSS_7 0.0731438
R_x_PM_NOR2_X4%VSS_r9 x_PM_NOR2_X4%VSS_8 x_PM_NOR2_X4%VSS_7 0.681765
R_x_PM_NOR2_X4%VSS_r10 x_PM_NOR2_X4%VSS_8 x_PM_NOR2_X4%VSS_3 0.264221
R_x_PM_NOR2_X4%VSS_r11 N_VSS_M4_s x_PM_NOR2_X4%VSS_3 0.990714
C_x_PM_NOR2_X4%VDD_c0 VSS N_VDD_M3_d 3.65442e-17
C_x_PM_NOR2_X4%VDD_c1 VSS x_PM_NOR2_X4%VDD_7 1.51645e-16
C_x_PM_NOR2_X4%VDD_c2 VSS N_VDD_M0_s 5.13434e-17
C_x_PM_NOR2_X4%VDD_c3 VSS x_PM_NOR2_X4%VDD_3 1.08743e-17
R_x_PM_NOR2_X4%VDD_r4 N_VDD_M3_d x_PM_NOR2_X4%VDD_9 0.475
R_x_PM_NOR2_X4%VDD_r5 VDD x_PM_NOR2_X4%VDD_8 0.195294
R_x_PM_NOR2_X4%VDD_r6 x_PM_NOR2_X4%VDD_9 x_PM_NOR2_X4%VDD_7 0.264221
R_x_PM_NOR2_X4%VDD_r7 x_PM_NOR2_X4%VDD_8 x_PM_NOR2_X4%VDD_7 1.53118
R_x_PM_NOR2_X4%VDD_r8 VDD x_PM_NOR2_X4%VDD_3 0.0689273
R_x_PM_NOR2_X4%VDD_r9 N_VDD_M0_s x_PM_NOR2_X4%VDD_3 0.475
C_x_PM_NOR2_X4%A2_c0 VSS x_PM_NOR2_X4%A2_30 8.63732e-18
C_x_PM_NOR2_X4%A2_c1 VSS x_PM_NOR2_X4%A2_28 2.12203e-17
C_x_PM_NOR2_X4%A2_c2 VSS x_PM_NOR2_X4%A2_23 7.56272e-18
C_x_PM_NOR2_X4%A2_c3 VSS x_PM_NOR2_X4%A2_21 1.52127e-17
C_x_PM_NOR2_X4%A2_c4 VSS A2 4.36692e-17
C_x_PM_NOR2_X4%A2_c5 VSS x_PM_NOR2_X4%A2_16 3.71957e-17
C_x_PM_NOR2_X4%A2_c6 VSS x_PM_NOR2_X4%A2_15 1.40547e-16
C_x_PM_NOR2_X4%A2_c7 VSS x_PM_NOR2_X4%A2_14 4.7353e-17
C_x_PM_NOR2_X4%A2_c8 VSS N_A2_M3_g 5.1634e-17
C_x_PM_NOR2_X4%A2_c9 VSS N_A2_M4_g 7.04305e-17
C_x_PM_NOR2_X4%A2_c10 VSS N_A2_M0_g 4.85167e-17
R_x_PM_NOR2_X4%A2_r11 x_PM_NOR2_X4%A2_37 x_PM_NOR2_X4%A2_30 4.7687
R_x_PM_NOR2_X4%A2_r12 x_PM_NOR2_X4%A2_30 x_PM_NOR2_X4%A2_28 25.0012
R_x_PM_NOR2_X4%A2_r13 x_PM_NOR2_X4%A2_28 x_PM_NOR2_X4%A2_26 0.175926
R_x_PM_NOR2_X4%A2_r14 x_PM_NOR2_X4%A2_34 x_PM_NOR2_X4%A2_23 4.7687
R_x_PM_NOR2_X4%A2_r15 x_PM_NOR2_X4%A2_33 x_PM_NOR2_X4%A2_23 4.7687
R_x_PM_NOR2_X4%A2_r16 x_PM_NOR2_X4%A2_23 x_PM_NOR2_X4%A2_21 25.0012
R_x_PM_NOR2_X4%A2_r17 A2 x_PM_NOR2_X4%A2_18 1.46571
R_x_PM_NOR2_X4%A2_r18 x_PM_NOR2_X4%A2_26 x_PM_NOR2_X4%A2_17 0.095
R_x_PM_NOR2_X4%A2_r19 A2 x_PM_NOR2_X4%A2_17 0.325714
R_x_PM_NOR2_X4%A2_r20 x_PM_NOR2_X4%A2_18 x_PM_NOR2_X4%A2_15 0.212317
R_x_PM_NOR2_X4%A2_r21 x_PM_NOR2_X4%A2_16 x_PM_NOR2_X4%A2_15 2.09
R_x_PM_NOR2_X4%A2_r22 x_PM_NOR2_X4%A2_16 x_PM_NOR2_X4%A2_14 0.212317
R_x_PM_NOR2_X4%A2_r23 x_PM_NOR2_X4%A2_13 x_PM_NOR2_X4%A2_21 0.297071
R_x_PM_NOR2_X4%A2_r24 x_PM_NOR2_X4%A2_14 x_PM_NOR2_X4%A2_13 1.79143
R_x_PM_NOR2_X4%A2_r25 N_A2_M3_g x_PM_NOR2_X4%A2_37 39
R_x_PM_NOR2_X4%A2_r26 N_A2_M4_g x_PM_NOR2_X4%A2_33 74.1
R_x_PM_NOR2_X4%A2_r27 N_A2_M0_g x_PM_NOR2_X4%A2_34 39
C_x_PM_NOR2_X4%ZN_c0 VSS N_ZN_M1_d 8.30847e-17
C_x_PM_NOR2_X4%ZN_c1 VSS x_PM_NOR2_X4%ZN_12 2.83121e-17
C_x_PM_NOR2_X4%ZN_c2 VSS x_PM_NOR2_X4%ZN_7 8.67931e-17
C_x_PM_NOR2_X4%ZN_c3 VSS x_PM_NOR2_X4%ZN_3 3.55024e-17
R_x_PM_NOR2_X4%ZN_r4 x_PM_NOR2_X4%ZN_12 x_PM_NOR2_X4%ZN_11 0.542857
R_x_PM_NOR2_X4%ZN_r5 x_PM_NOR2_X4%ZN_11 N_ZN_M4_d 0.0135714
R_x_PM_NOR2_X4%ZN_r6 x_PM_NOR2_X4%ZN_7 N_ZN_M1_d 0.531883
R_x_PM_NOR2_X4%ZN_r7 x_PM_NOR2_X4%ZN_12 x_PM_NOR2_X4%ZN_6 0.095
R_x_PM_NOR2_X4%ZN_r8 x_PM_NOR2_X4%ZN_7 x_PM_NOR2_X4%ZN_6 2.14429
R_x_PM_NOR2_X4%ZN_r9 x_PM_NOR2_X4%ZN_11 x_PM_NOR2_X4%ZN_3 0.095
R_x_PM_NOR2_X4%ZN_r10 ZN x_PM_NOR2_X4%ZN_3 0.325714
C_x_PM_NOR2_X4%A1_c0 VSS A1 3.51175e-17
C_x_PM_NOR2_X4%A1_c1 VSS x_PM_NOR2_X4%A1_17 7.3035e-17
C_x_PM_NOR2_X4%A1_c2 VSS x_PM_NOR2_X4%A1_15 1.69619e-17
C_x_PM_NOR2_X4%A1_c3 VSS x_PM_NOR2_X4%A1_14 8.72478e-18
C_x_PM_NOR2_X4%A1_c4 VSS N_A1_M2_g 4.67796e-17
C_x_PM_NOR2_X4%A1_c5 VSS N_A1_M5_g 6.6408e-17
C_x_PM_NOR2_X4%A1_c6 VSS N_A1_M1_g 5.61018e-17
R_x_PM_NOR2_X4%A1_r7 A1 x_PM_NOR2_X4%A1_21 0.38
R_x_PM_NOR2_X4%A1_r8 x_PM_NOR2_X4%A1_19 x_PM_NOR2_X4%A1_17 25.0012
R_x_PM_NOR2_X4%A1_r9 x_PM_NOR2_X4%A1_21 x_PM_NOR2_X4%A1_16 0.095
R_x_PM_NOR2_X4%A1_r10 x_PM_NOR2_X4%A1_17 x_PM_NOR2_X4%A1_16 1.56071
R_x_PM_NOR2_X4%A1_r11 x_PM_NOR2_X4%A1_19 x_PM_NOR2_X4%A1_15 0.26
R_x_PM_NOR2_X4%A1_r12 x_PM_NOR2_X4%A1_19 x_PM_NOR2_X4%A1_13 12.22
R_x_PM_NOR2_X4%A1_r13 x_PM_NOR2_X4%A1_14 x_PM_NOR2_X4%A1_13 0.043368
R_x_PM_NOR2_X4%A1_r14 x_PM_NOR2_X4%A1_15 x_PM_NOR2_X4%A1_9 4.58872
R_x_PM_NOR2_X4%A1_r15 N_A1_M2_g x_PM_NOR2_X4%A1_9 50.7
R_x_PM_NOR2_X4%A1_r16 x_PM_NOR2_X4%A1_14 x_PM_NOR2_X4%A1_5 4.56151
R_x_PM_NOR2_X4%A1_r17 N_A1_M5_g x_PM_NOR2_X4%A1_5 62.4
R_x_PM_NOR2_X4%A1_r18 x_PM_NOR2_X4%A1_14 x_PM_NOR2_X4%A1_VSS 4.56151
R_x_PM_NOR2_X4%A1_r19 N_A1_M1_g x_PM_NOR2_X4%A1_VSS 50.7
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X1 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M3 7 N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M4 8 N_A2_M1_g 7 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M5 N_ZN_M2_d N_A1_M2_g 8 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M0 N_ZN_M3_d N_A3_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g N_ZN_M3_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_ZN_M5_d N_A1_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_NOR3_X1%VSS_c0 VSS x_PM_NOR3_X1%VSS_17 4.0526e-17
C_x_PM_NOR3_X1%VSS_c1 VSS N_VSS_M4_d 3.86446e-17
C_x_PM_NOR3_X1%VSS_c2 VSS x_PM_NOR3_X1%VSS_8 1.07554e-17
C_x_PM_NOR3_X1%VSS_c3 VSS x_PM_NOR3_X1%VSS_7 3.3794e-17
C_x_PM_NOR3_X1%VSS_c4 VSS N_VSS_M3_s 1.92434e-17
R_x_PM_NOR3_X1%VSS_r5 x_PM_NOR3_X1%VSS_17 x_PM_NOR3_X1%VSS_11 0.145286
R_x_PM_NOR3_X1%VSS_r6 N_VSS_M4_d x_PM_NOR3_X1%VSS_11 0.637857
R_x_PM_NOR3_X1%VSS_r7 VSS x_PM_NOR3_X1%VSS_8 0.603529
R_x_PM_NOR3_X1%VSS_r8 x_PM_NOR3_X1%VSS_17 x_PM_NOR3_X1%VSS_7 0.0731438
R_x_PM_NOR3_X1%VSS_r9 VSS x_PM_NOR3_X1%VSS_7 0.0894118
R_x_PM_NOR3_X1%VSS_r10 x_PM_NOR3_X1%VSS_8 x_PM_NOR3_X1%VSS_3 0.264221
R_x_PM_NOR3_X1%VSS_r11 N_VSS_M3_s x_PM_NOR3_X1%VSS_3 0.637857
C_x_PM_NOR3_X1%VDD_c0 VSS VDD 6.75722e-17
C_x_PM_NOR3_X1%VDD_c1 VSS N_VDD_M0_s 2.82296e-17
C_x_PM_NOR3_X1%VDD_c2 VSS x_PM_NOR3_X1%VDD_2 1.07936e-17
R_x_PM_NOR3_X1%VDD_r3 VDD x_PM_NOR3_X1%VDD_2 0.0689273
R_x_PM_NOR3_X1%VDD_r4 N_VDD_M0_s x_PM_NOR3_X1%VDD_2 0.475
C_x_PM_NOR3_X1%A3_c0 VSS x_PM_NOR3_X1%A3_14 6.45678e-18
C_x_PM_NOR3_X1%A3_c1 VSS x_PM_NOR3_X1%A3_12 1.21905e-17
C_x_PM_NOR3_X1%A3_c2 VSS N_A3_M0_g 6.56951e-17
C_x_PM_NOR3_X1%A3_c3 VSS N_A3_M3_g 4.72131e-17
R_x_PM_NOR3_X1%A3_r4 x_PM_NOR3_X1%A3_18 x_PM_NOR3_X1%A3_14 4.7687
R_x_PM_NOR3_X1%A3_r5 x_PM_NOR3_X1%A3_17 x_PM_NOR3_X1%A3_14 4.7687
R_x_PM_NOR3_X1%A3_r6 x_PM_NOR3_X1%A3_14 x_PM_NOR3_X1%A3_12 25.0012
R_x_PM_NOR3_X1%A3_r7 x_PM_NOR3_X1%A3_12 A3 0.169643
R_x_PM_NOR3_X1%A3_r8 N_A3_M0_g x_PM_NOR3_X1%A3_18 72.54
R_x_PM_NOR3_X1%A3_r9 N_A3_M3_g x_PM_NOR3_X1%A3_17 60.06
C_x_PM_NOR3_X1%ZN_c0 VSS x_PM_NOR3_X1%ZN_18 2.14222e-18
C_x_PM_NOR3_X1%ZN_c1 VSS N_ZN_M2_d 1.18691e-16
C_x_PM_NOR3_X1%ZN_c2 VSS x_PM_NOR3_X1%ZN_13 3.87762e-17
C_x_PM_NOR3_X1%ZN_c3 VSS x_PM_NOR3_X1%ZN_10 2.84995e-17
C_x_PM_NOR3_X1%ZN_c4 VSS ZN 8.42798e-18
C_x_PM_NOR3_X1%ZN_c5 VSS N_ZN_M3_d 4.92683e-17
R_x_PM_NOR3_X1%ZN_r6 x_PM_NOR3_X1%ZN_18 x_PM_NOR3_X1%ZN_14 0.160909
R_x_PM_NOR3_X1%ZN_r7 N_ZN_M2_d x_PM_NOR3_X1%ZN_14 4.13929
R_x_PM_NOR3_X1%ZN_r8 x_PM_NOR3_X1%ZN_18 x_PM_NOR3_X1%ZN_13 0.160909
R_x_PM_NOR3_X1%ZN_r9 x_PM_NOR3_X1%ZN_13 N_ZN_M5_d 0.543196
R_x_PM_NOR3_X1%ZN_r10 x_PM_NOR3_X1%ZN_18 x_PM_NOR3_X1%ZN_10 0.0418175
R_x_PM_NOR3_X1%ZN_r11 x_PM_NOR3_X1%ZN_11 x_PM_NOR3_X1%ZN_10 1.57429
R_x_PM_NOR3_X1%ZN_r12 x_PM_NOR3_X1%ZN_11 ZN 0.194115
R_x_PM_NOR3_X1%ZN_r13 ZN N_ZN_M3_d 0.591906
C_x_PM_NOR3_X1%A2_c0 VSS x_PM_NOR3_X1%A2_11 9.31336e-18
C_x_PM_NOR3_X1%A2_c1 VSS x_PM_NOR3_X1%A2_9 7.70507e-17
C_x_PM_NOR3_X1%A2_c2 VSS N_A2_M1_g 3.59653e-17
C_x_PM_NOR3_X1%A2_c3 VSS N_A2_M4_g 7.74139e-17
R_x_PM_NOR3_X1%A2_r4 x_PM_NOR3_X1%A2_18 x_PM_NOR3_X1%A2_11 4.74714
R_x_PM_NOR3_X1%A2_r5 x_PM_NOR3_X1%A2_17 x_PM_NOR3_X1%A2_11 4.74714
R_x_PM_NOR3_X1%A2_r6 x_PM_NOR3_X1%A2_11 x_PM_NOR3_X1%A2_9 25.0012
R_x_PM_NOR3_X1%A2_r7 A2 x_PM_NOR3_X1%A2_9 0.4028
R_x_PM_NOR3_X1%A2_r8 N_A2_M1_g x_PM_NOR3_X1%A2_18 28.08
R_x_PM_NOR3_X1%A2_r9 N_A2_M4_g x_PM_NOR3_X1%A2_17 104.52
C_x_PM_NOR3_X1%A1_c0 VSS x_PM_NOR3_X1%A1_18 1.22938e-17
C_x_PM_NOR3_X1%A1_c1 VSS x_PM_NOR3_X1%A1_9 1.04816e-16
C_x_PM_NOR3_X1%A1_c2 VSS N_A1_M2_g 4.07071e-17
C_x_PM_NOR3_X1%A1_c3 VSS N_A1_M5_g 9.08685e-17
R_x_PM_NOR3_X1%A1_r4 x_PM_NOR3_X1%A1_18 x_PM_NOR3_X1%A1_11 3.9
R_x_PM_NOR3_X1%A1_r5 x_PM_NOR3_X1%A1_11 x_PM_NOR3_X1%A1_9 25.0012
R_x_PM_NOR3_X1%A1_r6 A1 x_PM_NOR3_X1%A1_9 0.479524
R_x_PM_NOR3_X1%A1_r7 x_PM_NOR3_X1%A1_18 x_PM_NOR3_X1%A1_5 1.95
R_x_PM_NOR3_X1%A1_r8 N_A1_M2_g x_PM_NOR3_X1%A1_5 28.08
R_x_PM_NOR3_X1%A1_r9 x_PM_NOR3_X1%A1_18 x_PM_NOR3_X1%A1_VSS 1.95
R_x_PM_NOR3_X1%A1_r10 N_A1_M5_g x_PM_NOR3_X1%A1_VSS 104.52
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X2 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M3 7 N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M4 8 N_A2_M1_g 7 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M5 N_ZN_M2_d N_A1_M2_g 8 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 N_ZN_M3_d N_A3_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g N_ZN_M3_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_ZN_M5_d N_A1_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_NOR3_X2%VSS_c0 VSS x_PM_NOR3_X2%VSS_17 4.46075e-17
C_x_PM_NOR3_X2%VSS_c1 VSS N_VSS_M4_d 2.78358e-17
C_x_PM_NOR3_X2%VSS_c2 VSS x_PM_NOR3_X2%VSS_8 1.05487e-17
C_x_PM_NOR3_X2%VSS_c3 VSS x_PM_NOR3_X2%VSS_7 3.86305e-17
C_x_PM_NOR3_X2%VSS_c4 VSS N_VSS_M3_s 9.87304e-18
R_x_PM_NOR3_X2%VSS_r5 x_PM_NOR3_X2%VSS_17 x_PM_NOR3_X2%VSS_11 0.145286
R_x_PM_NOR3_X2%VSS_r6 N_VSS_M4_d x_PM_NOR3_X2%VSS_11 0.230714
R_x_PM_NOR3_X2%VSS_r7 VSS x_PM_NOR3_X2%VSS_8 0.603529
R_x_PM_NOR3_X2%VSS_r8 x_PM_NOR3_X2%VSS_17 x_PM_NOR3_X2%VSS_7 0.0731438
R_x_PM_NOR3_X2%VSS_r9 VSS x_PM_NOR3_X2%VSS_7 0.0782353
R_x_PM_NOR3_X2%VSS_r10 x_PM_NOR3_X2%VSS_8 x_PM_NOR3_X2%VSS_3 0.264221
R_x_PM_NOR3_X2%VSS_r11 N_VSS_M3_s x_PM_NOR3_X2%VSS_3 0.230714
C_x_PM_NOR3_X2%VDD_c0 VSS VDD 5.9596e-17
C_x_PM_NOR3_X2%VDD_c1 VSS N_VDD_M0_s 2.58417e-17
C_x_PM_NOR3_X2%VDD_c2 VSS x_PM_NOR3_X2%VDD_2 1.06055e-17
R_x_PM_NOR3_X2%VDD_r3 VDD x_PM_NOR3_X2%VDD_2 0.0689273
R_x_PM_NOR3_X2%VDD_r4 N_VDD_M0_s x_PM_NOR3_X2%VDD_2 0.230714
C_x_PM_NOR3_X2%A3_c0 VSS x_PM_NOR3_X2%A3_11 7.14715e-18
C_x_PM_NOR3_X2%A3_c1 VSS x_PM_NOR3_X2%A3_9 5.04542e-17
C_x_PM_NOR3_X2%A3_c2 VSS N_A3_M0_g 6.20936e-17
C_x_PM_NOR3_X2%A3_c3 VSS N_A3_M3_g 5.91756e-17
R_x_PM_NOR3_X2%A3_r4 x_PM_NOR3_X2%A3_18 x_PM_NOR3_X2%A3_11 4.74714
R_x_PM_NOR3_X2%A3_r5 x_PM_NOR3_X2%A3_17 x_PM_NOR3_X2%A3_11 4.74714
R_x_PM_NOR3_X2%A3_r6 x_PM_NOR3_X2%A3_11 x_PM_NOR3_X2%A3_9 25.0012
R_x_PM_NOR3_X2%A3_r7 A3 x_PM_NOR3_X2%A3_9 0.2204
R_x_PM_NOR3_X2%A3_r8 N_A3_M0_g x_PM_NOR3_X2%A3_18 49.14
R_x_PM_NOR3_X2%A3_r9 N_A3_M3_g x_PM_NOR3_X2%A3_17 74.88
C_x_PM_NOR3_X2%ZN_c0 VSS x_PM_NOR3_X2%ZN_22 2.56413e-18
C_x_PM_NOR3_X2%ZN_c1 VSS ZN 5.06951e-17
C_x_PM_NOR3_X2%ZN_c2 VSS N_ZN_M2_d 2.75881e-17
C_x_PM_NOR3_X2%ZN_c3 VSS x_PM_NOR3_X2%ZN_14 6.25994e-18
C_x_PM_NOR3_X2%ZN_c4 VSS N_ZN_M5_d 2.52851e-17
C_x_PM_NOR3_X2%ZN_c5 VSS x_PM_NOR3_X2%ZN_9 8.16416e-18
C_x_PM_NOR3_X2%ZN_c6 VSS x_PM_NOR3_X2%ZN_8 4.12951e-17
C_x_PM_NOR3_X2%ZN_c7 VSS N_ZN_M3_d 2.15312e-17
R_x_PM_NOR3_X2%ZN_r8 ZN x_PM_NOR3_X2%ZN_19 1.46571
R_x_PM_NOR3_X2%ZN_r9 x_PM_NOR3_X2%ZN_22 x_PM_NOR3_X2%ZN_18 0.143785
R_x_PM_NOR3_X2%ZN_r10 ZN x_PM_NOR3_X2%ZN_18 0.868571
R_x_PM_NOR3_X2%ZN_r11 x_PM_NOR3_X2%ZN_19 x_PM_NOR3_X2%ZN_14 0.20978
R_x_PM_NOR3_X2%ZN_r12 N_ZN_M2_d x_PM_NOR3_X2%ZN_14 0.686111
R_x_PM_NOR3_X2%ZN_r13 x_PM_NOR3_X2%ZN_22 x_PM_NOR3_X2%ZN_10 0.143785
R_x_PM_NOR3_X2%ZN_r14 N_ZN_M5_d x_PM_NOR3_X2%ZN_10 0.116111
R_x_PM_NOR3_X2%ZN_r15 x_PM_NOR3_X2%ZN_22 x_PM_NOR3_X2%ZN_8 0.0569232
R_x_PM_NOR3_X2%ZN_r16 x_PM_NOR3_X2%ZN_9 x_PM_NOR3_X2%ZN_8 1.65571
R_x_PM_NOR3_X2%ZN_r17 x_PM_NOR3_X2%ZN_9 x_PM_NOR3_X2%ZN_4 0.212317
R_x_PM_NOR3_X2%ZN_r18 N_ZN_M3_d x_PM_NOR3_X2%ZN_4 0.149286
C_x_PM_NOR3_X2%A2_c0 VSS x_PM_NOR3_X2%A2_11 8.98632e-18
C_x_PM_NOR3_X2%A2_c1 VSS x_PM_NOR3_X2%A2_9 8.53584e-17
C_x_PM_NOR3_X2%A2_c2 VSS N_A2_M1_g 6.12109e-17
C_x_PM_NOR3_X2%A2_c3 VSS N_A2_M4_g 6.60015e-17
R_x_PM_NOR3_X2%A2_r4 x_PM_NOR3_X2%A2_18 x_PM_NOR3_X2%A2_11 4.74714
R_x_PM_NOR3_X2%A2_r5 x_PM_NOR3_X2%A2_17 x_PM_NOR3_X2%A2_11 4.74714
R_x_PM_NOR3_X2%A2_r6 x_PM_NOR3_X2%A2_11 x_PM_NOR3_X2%A2_9 25.0012
R_x_PM_NOR3_X2%A2_r7 A2 x_PM_NOR3_X2%A2_9 0.2204
R_x_PM_NOR3_X2%A2_r8 N_A2_M1_g x_PM_NOR3_X2%A2_18 49.14
R_x_PM_NOR3_X2%A2_r9 N_A2_M4_g x_PM_NOR3_X2%A2_17 74.88
C_x_PM_NOR3_X2%A1_c0 VSS x_PM_NOR3_X2%A1_20 1.07269e-17
C_x_PM_NOR3_X2%A1_c1 VSS x_PM_NOR3_X2%A1_14 4.59258e-17
C_x_PM_NOR3_X2%A1_c2 VSS x_PM_NOR3_X2%A1_9 3.45973e-17
C_x_PM_NOR3_X2%A1_c3 VSS N_A1_M2_g 7.00434e-17
C_x_PM_NOR3_X2%A1_c4 VSS N_A1_M5_g 6.63408e-17
R_x_PM_NOR3_X2%A1_r5 x_PM_NOR3_X2%A1_20 x_PM_NOR3_X2%A1_16 2.34
R_x_PM_NOR3_X2%A1_r6 x_PM_NOR3_X2%A1_16 x_PM_NOR3_X2%A1_14 25.0012
R_x_PM_NOR3_X2%A1_r7 x_PM_NOR3_X2%A1_14 x_PM_NOR3_X2%A1_12 0.147778
R_x_PM_NOR3_X2%A1_r8 x_PM_NOR3_X2%A1_12 x_PM_NOR3_X2%A1_9 0.095
R_x_PM_NOR3_X2%A1_r9 A1 x_PM_NOR3_X2%A1_9 0.298571
R_x_PM_NOR3_X2%A1_r10 x_PM_NOR3_X2%A1_20 x_PM_NOR3_X2%A1_5 1.95
R_x_PM_NOR3_X2%A1_r11 N_A1_M2_g x_PM_NOR3_X2%A1_5 56.94
R_x_PM_NOR3_X2%A1_r12 x_PM_NOR3_X2%A1_20 x_PM_NOR3_X2%A1_VSS 1.95
R_x_PM_NOR3_X2%A1_r13 N_A1_M5_g x_PM_NOR3_X2%A1_VSS 67.08
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR3_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR3_X4 VSS VDD A3 ZN A2 A1
*.PININFO VSS:B VDD:B A3:I ZN:O A2:I A1:I
M_M3 7 N_A3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.520000U L=0.050000U
M_M4 8 N_A2_M1_g 7 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M5 N_ZN_M2_d N_A1_M2_g 8 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M6 9 N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.520000U L=0.050000U
M_M7 10 N_A2_M4_g 9 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M8 N_VDD_M5_d N_A3_M5_g 10 VDD PMOS_VTL W=0.520000U L=0.050000U
M_M0 N_ZN_M6_d N_A3_M6_g N_VSS_M6_s VSS NMOS_VTL W=0.360000U L=0.050000U
M_M1 N_VSS_M7_d N_A2_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.360000U L=0.050000U
M_M2 N_ZN_M8_d N_A1_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_NOR3_X4%VSS_c0 VSS x_PM_NOR3_X4%VSS_15 2.96668e-17
C_x_PM_NOR3_X4%VSS_c1 VSS VSS 6.97626e-17
C_x_PM_NOR3_X4%VSS_c2 VSS x_PM_NOR3_X4%VSS_9 2.50768e-17
C_x_PM_NOR3_X4%VSS_c3 VSS x_PM_NOR3_X4%VSS_8 1.08104e-17
C_x_PM_NOR3_X4%VSS_c4 VSS N_VSS_M6_s 2.43441e-17
R_x_PM_NOR3_X4%VSS_r5 x_PM_NOR3_X4%VSS_15 N_VSS_M7_d 0.140674
R_x_PM_NOR3_X4%VSS_r6 x_PM_NOR3_X4%VSS_9 N_VSS_M7_d 0.140674
R_x_PM_NOR3_X4%VSS_r7 VSS x_PM_NOR3_X4%VSS_9 0.312941
R_x_PM_NOR3_X4%VSS_r8 x_PM_NOR3_X4%VSS_8 x_PM_NOR3_X4%VSS_15 0.625882
R_x_PM_NOR3_X4%VSS_r9 x_PM_NOR3_X4%VSS_8 x_PM_NOR3_X4%VSS_3 0.264221
R_x_PM_NOR3_X4%VSS_r10 N_VSS_M6_s x_PM_NOR3_X4%VSS_3 0.990714
C_x_PM_NOR3_X4%VDD_c0 VSS N_VDD_M5_d 1.03668e-17
C_x_PM_NOR3_X4%VDD_c1 VSS x_PM_NOR3_X4%VDD_8 1.07537e-17
C_x_PM_NOR3_X4%VDD_c2 VSS x_PM_NOR3_X4%VDD_7 1.40253e-16
C_x_PM_NOR3_X4%VDD_c3 VSS N_VDD_M0_s 1.03476e-17
R_x_PM_NOR3_X4%VDD_r4 N_VDD_M5_d x_PM_NOR3_X4%VDD_11 0.230714
R_x_PM_NOR3_X4%VDD_r5 VDD x_PM_NOR3_X4%VDD_8 1.24059
R_x_PM_NOR3_X4%VDD_r6 x_PM_NOR3_X4%VDD_11 x_PM_NOR3_X4%VDD_7 0.264221
R_x_PM_NOR3_X4%VDD_r7 VDD x_PM_NOR3_X4%VDD_7 1.14
R_x_PM_NOR3_X4%VDD_r8 x_PM_NOR3_X4%VDD_8 x_PM_NOR3_X4%VDD_3 0.264221
R_x_PM_NOR3_X4%VDD_r9 N_VDD_M0_s x_PM_NOR3_X4%VDD_3 0.230714
C_x_PM_NOR3_X4%A3_c0 VSS x_PM_NOR3_X4%A3_31 8.44616e-18
C_x_PM_NOR3_X4%A3_c1 VSS x_PM_NOR3_X4%A3_29 1.93749e-17
C_x_PM_NOR3_X4%A3_c2 VSS x_PM_NOR3_X4%A3_28 4.13794e-18
C_x_PM_NOR3_X4%A3_c3 VSS x_PM_NOR3_X4%A3_25 7.48869e-18
C_x_PM_NOR3_X4%A3_c4 VSS x_PM_NOR3_X4%A3_23 1.7263e-17
C_x_PM_NOR3_X4%A3_c5 VSS A3 1.33607e-17
C_x_PM_NOR3_X4%A3_c6 VSS x_PM_NOR3_X4%A3_17 5.78711e-18
C_x_PM_NOR3_X4%A3_c7 VSS x_PM_NOR3_X4%A3_16 5.70988e-18
C_x_PM_NOR3_X4%A3_c8 VSS x_PM_NOR3_X4%A3_15 1.67931e-16
C_x_PM_NOR3_X4%A3_c9 VSS x_PM_NOR3_X4%A3_14 2.79386e-17
C_x_PM_NOR3_X4%A3_c10 VSS N_A3_M5_g 5.54321e-17
C_x_PM_NOR3_X4%A3_c11 VSS N_A3_M0_g 5.54819e-17
C_x_PM_NOR3_X4%A3_c12 VSS N_A3_M6_g 6.30167e-17
R_x_PM_NOR3_X4%A3_r13 x_PM_NOR3_X4%A3_39 x_PM_NOR3_X4%A3_31 4.7687
R_x_PM_NOR3_X4%A3_r14 x_PM_NOR3_X4%A3_31 x_PM_NOR3_X4%A3_29 25.0012
R_x_PM_NOR3_X4%A3_r15 x_PM_NOR3_X4%A3_36 x_PM_NOR3_X4%A3_25 4.7687
R_x_PM_NOR3_X4%A3_r16 x_PM_NOR3_X4%A3_35 x_PM_NOR3_X4%A3_25 4.7687
R_x_PM_NOR3_X4%A3_r17 x_PM_NOR3_X4%A3_25 x_PM_NOR3_X4%A3_23 25.0012
R_x_PM_NOR3_X4%A3_r18 x_PM_NOR3_X4%A3_21 x_PM_NOR3_X4%A3_29 0.30478
R_x_PM_NOR3_X4%A3_r19 x_PM_NOR3_X4%A3_28 x_PM_NOR3_X4%A3_21 0.407143
R_x_PM_NOR3_X4%A3_r20 A3 x_PM_NOR3_X4%A3_18 0.621818
R_x_PM_NOR3_X4%A3_r21 x_PM_NOR3_X4%A3_28 x_PM_NOR3_X4%A3_17 0.240055
R_x_PM_NOR3_X4%A3_r22 A3 x_PM_NOR3_X4%A3_17 0.0518182
R_x_PM_NOR3_X4%A3_r23 x_PM_NOR3_X4%A3_18 x_PM_NOR3_X4%A3_15 0.226245
R_x_PM_NOR3_X4%A3_r24 x_PM_NOR3_X4%A3_16 x_PM_NOR3_X4%A3_15 4.15286
R_x_PM_NOR3_X4%A3_r25 x_PM_NOR3_X4%A3_16 x_PM_NOR3_X4%A3_14 0.212317
R_x_PM_NOR3_X4%A3_r26 x_PM_NOR3_X4%A3_13 x_PM_NOR3_X4%A3_23 0.297071
R_x_PM_NOR3_X4%A3_r27 x_PM_NOR3_X4%A3_14 x_PM_NOR3_X4%A3_13 1.76429
R_x_PM_NOR3_X4%A3_r28 N_A3_M5_g x_PM_NOR3_X4%A3_39 49.14
R_x_PM_NOR3_X4%A3_r29 N_A3_M0_g x_PM_NOR3_X4%A3_36 49.14
R_x_PM_NOR3_X4%A3_r30 N_A3_M6_g x_PM_NOR3_X4%A3_35 60.84
C_x_PM_NOR3_X4%ZN_c0 VSS x_PM_NOR3_X4%ZN_13 5.86385e-17
C_x_PM_NOR3_X4%ZN_c1 VSS ZN 4.67599e-17
C_x_PM_NOR3_X4%ZN_c2 VSS x_PM_NOR3_X4%ZN_8 1.31027e-17
C_x_PM_NOR3_X4%ZN_c3 VSS x_PM_NOR3_X4%ZN_4 4.98058e-17
R_x_PM_NOR3_X4%ZN_r4 N_ZN_M2_d ZN 0.161852
R_x_PM_NOR3_X4%ZN_r5 x_PM_NOR3_X4%ZN_13 ZN 0.284786
R_x_PM_NOR3_X4%ZN_r6 N_ZN_M8_d x_PM_NOR3_X4%ZN_8 0.102227
R_x_PM_NOR3_X4%ZN_r7 x_PM_NOR3_X4%ZN_13 x_PM_NOR3_X4%ZN_8 1.9
R_x_PM_NOR3_X4%ZN_r8 N_ZN_M8_d x_PM_NOR3_X4%ZN_4 0.11009
R_x_PM_NOR3_X4%ZN_r9 N_ZN_M6_d x_PM_NOR3_X4%ZN_4 1.66929
C_x_PM_NOR3_X4%A2_c0 VSS x_PM_NOR3_X4%A2_27 1.07122e-17
C_x_PM_NOR3_X4%A2_c1 VSS x_PM_NOR3_X4%A2_25 1.70211e-17
C_x_PM_NOR3_X4%A2_c2 VSS x_PM_NOR3_X4%A2_24 1.47132e-17
C_x_PM_NOR3_X4%A2_c3 VSS A2 2.89619e-17
C_x_PM_NOR3_X4%A2_c4 VSS x_PM_NOR3_X4%A2_19 2.82807e-17
C_x_PM_NOR3_X4%A2_c5 VSS x_PM_NOR3_X4%A2_18 1.39055e-16
C_x_PM_NOR3_X4%A2_c6 VSS x_PM_NOR3_X4%A2_16 8.5176e-18
C_x_PM_NOR3_X4%A2_c7 VSS x_PM_NOR3_X4%A2_14 4.43846e-17
C_x_PM_NOR3_X4%A2_c8 VSS N_A2_M4_g 6.54404e-17
C_x_PM_NOR3_X4%A2_c9 VSS N_A2_M1_g 6.21994e-17
C_x_PM_NOR3_X4%A2_c10 VSS N_A2_M7_g 6.52386e-17
R_x_PM_NOR3_X4%A2_r11 x_PM_NOR3_X4%A2_34 x_PM_NOR3_X4%A2_27 4.7687
R_x_PM_NOR3_X4%A2_r12 x_PM_NOR3_X4%A2_27 x_PM_NOR3_X4%A2_25 25.0012
R_x_PM_NOR3_X4%A2_r13 x_PM_NOR3_X4%A2_25 x_PM_NOR3_X4%A2_24 0.149286
R_x_PM_NOR3_X4%A2_r14 A2 x_PM_NOR3_X4%A2_21 1.00429
R_x_PM_NOR3_X4%A2_r15 x_PM_NOR3_X4%A2_24 x_PM_NOR3_X4%A2_20 0.212317
R_x_PM_NOR3_X4%A2_r16 A2 x_PM_NOR3_X4%A2_20 0.19
R_x_PM_NOR3_X4%A2_r17 x_PM_NOR3_X4%A2_21 x_PM_NOR3_X4%A2_18 0.212317
R_x_PM_NOR3_X4%A2_r18 x_PM_NOR3_X4%A2_19 x_PM_NOR3_X4%A2_18 2.22571
R_x_PM_NOR3_X4%A2_r19 x_PM_NOR3_X4%A2_31 x_PM_NOR3_X4%A2_16 4.7687
R_x_PM_NOR3_X4%A2_r20 x_PM_NOR3_X4%A2_30 x_PM_NOR3_X4%A2_16 4.7687
R_x_PM_NOR3_X4%A2_r21 x_PM_NOR3_X4%A2_16 x_PM_NOR3_X4%A2_14 25.0012
R_x_PM_NOR3_X4%A2_r22 x_PM_NOR3_X4%A2_19 x_PM_NOR3_X4%A2_13 0.212317
R_x_PM_NOR3_X4%A2_r23 x_PM_NOR3_X4%A2_14 x_PM_NOR3_X4%A2_13 1.39786
R_x_PM_NOR3_X4%A2_r24 N_A2_M4_g x_PM_NOR3_X4%A2_34 49.14
R_x_PM_NOR3_X4%A2_r25 N_A2_M1_g x_PM_NOR3_X4%A2_31 49.14
R_x_PM_NOR3_X4%A2_r26 N_A2_M7_g x_PM_NOR3_X4%A2_30 60.84
C_x_PM_NOR3_X4%A1_c0 VSS x_PM_NOR3_X4%A1_16 5.87755e-17
C_x_PM_NOR3_X4%A1_c1 VSS x_PM_NOR3_X4%A1_15 6.54461e-18
C_x_PM_NOR3_X4%A1_c2 VSS N_A1_M3_g 6.39275e-17
C_x_PM_NOR3_X4%A1_c3 VSS x_PM_NOR3_X4%A1_11 4.0486e-18
C_x_PM_NOR3_X4%A1_c4 VSS x_PM_NOR3_X4%A1_9 1.5074e-17
C_x_PM_NOR3_X4%A1_c5 VSS N_A1_M2_g 6.35629e-17
C_x_PM_NOR3_X4%A1_c6 VSS N_A1_M8_g 4.99006e-17
R_x_PM_NOR3_X4%A1_r7 x_PM_NOR3_X4%A1_18 x_PM_NOR3_X4%A1_16 25.0012
R_x_PM_NOR3_X4%A1_r8 A1 x_PM_NOR3_X4%A1_16 0.268193
R_x_PM_NOR3_X4%A1_r9 x_PM_NOR3_X4%A1_18 x_PM_NOR3_X4%A1_11 2.71924
R_x_PM_NOR3_X4%A1_r10 N_A1_M3_g x_PM_NOR3_X4%A1_11 73.32
R_x_PM_NOR3_X4%A1_r11 x_PM_NOR3_X4%A1_15 x_PM_NOR3_X4%A1_10 0.043368
R_x_PM_NOR3_X4%A1_r12 x_PM_NOR3_X4%A1_18 x_PM_NOR3_X4%A1_9 1.86948
R_x_PM_NOR3_X4%A1_r13 x_PM_NOR3_X4%A1_10 x_PM_NOR3_X4%A1_9 14.56
R_x_PM_NOR3_X4%A1_r14 x_PM_NOR3_X4%A1_15 x_PM_NOR3_X4%A1_5 4.56151
R_x_PM_NOR3_X4%A1_r15 N_A1_M2_g x_PM_NOR3_X4%A1_5 73.32
R_x_PM_NOR3_X4%A1_r16 x_PM_NOR3_X4%A1_15 x_PM_NOR3_X4%A1_VSS 4.56151
R_x_PM_NOR3_X4%A1_r17 N_A1_M8_g x_PM_NOR3_X4%A1_VSS 36.66
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X1 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B A4:I ZN:O A3:I A2:I A1:I
M_M4 8 N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.325000U L=0.050000U
M_M5 9 N_A3_M1_g 8 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M6 10 N_A2_M2_g 9 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M7 N_ZN_M3_d N_A1_M3_g 10 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M0 N_ZN_M4_d N_A4_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M5_d N_A3_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_ZN_M6_d N_A2_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_VSS_M7_d N_A1_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_NOR4_X1%VSS_c0 VSS x_PM_NOR4_X1%VSS_22 2.92048e-18
C_x_PM_NOR4_X1%VSS_c1 VSS N_VSS_M7_d 2.93338e-17
C_x_PM_NOR4_X1%VSS_c2 VSS x_PM_NOR4_X1%VSS_16 4.53899e-17
C_x_PM_NOR4_X1%VSS_c3 VSS VSS 3.74633e-17
C_x_PM_NOR4_X1%VSS_c4 VSS x_PM_NOR4_X1%VSS_9 1.08361e-17
C_x_PM_NOR4_X1%VSS_c5 VSS x_PM_NOR4_X1%VSS_8 3.37896e-17
C_x_PM_NOR4_X1%VSS_c6 VSS N_VSS_M4_s 1.9238e-17
R_x_PM_NOR4_X1%VSS_r7 N_VSS_M7_d x_PM_NOR4_X1%VSS_18 0.637857
R_x_PM_NOR4_X1%VSS_r8 x_PM_NOR4_X1%VSS_22 x_PM_NOR4_X1%VSS_17 0.0731438
R_x_PM_NOR4_X1%VSS_r9 x_PM_NOR4_X1%VSS_18 x_PM_NOR4_X1%VSS_16 0.264221
R_x_PM_NOR4_X1%VSS_r10 x_PM_NOR4_X1%VSS_17 x_PM_NOR4_X1%VSS_16 0.681765
R_x_PM_NOR4_X1%VSS_r11 N_VSS_M5_d VSS 0.597143
R_x_PM_NOR4_X1%VSS_r12 x_PM_NOR4_X1%VSS_22 x_PM_NOR4_X1%VSS_10 0.145286
R_x_PM_NOR4_X1%VSS_r13 VSS x_PM_NOR4_X1%VSS_10 0.0407143
R_x_PM_NOR4_X1%VSS_r14 x_PM_NOR4_X1%VSS_22 x_PM_NOR4_X1%VSS_8 0.0731438
R_x_PM_NOR4_X1%VSS_r15 x_PM_NOR4_X1%VSS_9 x_PM_NOR4_X1%VSS_8 0.692941
R_x_PM_NOR4_X1%VSS_r16 x_PM_NOR4_X1%VSS_9 x_PM_NOR4_X1%VSS_4 0.264221
R_x_PM_NOR4_X1%VSS_r17 N_VSS_M4_s x_PM_NOR4_X1%VSS_4 0.637857
C_x_PM_NOR4_X1%VDD_c0 VSS VDD 8.39162e-17
C_x_PM_NOR4_X1%VDD_c1 VSS N_VDD_M0_s 2.2536e-17
C_x_PM_NOR4_X1%VDD_c2 VSS x_PM_NOR4_X1%VDD_2 1.06862e-17
R_x_PM_NOR4_X1%VDD_r3 VDD x_PM_NOR4_X1%VDD_2 0.0689273
R_x_PM_NOR4_X1%VDD_r4 N_VDD_M0_s x_PM_NOR4_X1%VDD_2 0.230714
C_x_PM_NOR4_X1%A4_c0 VSS x_PM_NOR4_X1%A4_14 6.45648e-18
C_x_PM_NOR4_X1%A4_c1 VSS x_PM_NOR4_X1%A4_12 1.16085e-17
C_x_PM_NOR4_X1%A4_c2 VSS N_A4_M0_g 6.86794e-17
C_x_PM_NOR4_X1%A4_c3 VSS N_A4_M4_g 4.71407e-17
R_x_PM_NOR4_X1%A4_r4 x_PM_NOR4_X1%A4_18 x_PM_NOR4_X1%A4_14 4.7687
R_x_PM_NOR4_X1%A4_r5 x_PM_NOR4_X1%A4_17 x_PM_NOR4_X1%A4_14 4.7687
R_x_PM_NOR4_X1%A4_r6 x_PM_NOR4_X1%A4_14 x_PM_NOR4_X1%A4_12 25.0012
R_x_PM_NOR4_X1%A4_r7 x_PM_NOR4_X1%A4_12 A4 0.169643
R_x_PM_NOR4_X1%A4_r8 N_A4_M0_g x_PM_NOR4_X1%A4_18 74.49
R_x_PM_NOR4_X1%A4_r9 N_A4_M4_g x_PM_NOR4_X1%A4_17 60.06
C_x_PM_NOR4_X1%ZN_c0 VSS x_PM_NOR4_X1%ZN_20 2.32022e-18
C_x_PM_NOR4_X1%ZN_c1 VSS N_ZN_M3_d 9.73565e-17
C_x_PM_NOR4_X1%ZN_c2 VSS x_PM_NOR4_X1%ZN_14 2.86752e-17
C_x_PM_NOR4_X1%ZN_c3 VSS x_PM_NOR4_X1%ZN_13 4.32525e-17
C_x_PM_NOR4_X1%ZN_c4 VSS x_PM_NOR4_X1%ZN_10 2.73229e-17
C_x_PM_NOR4_X1%ZN_c5 VSS ZN 8.81943e-18
C_x_PM_NOR4_X1%ZN_c6 VSS N_ZN_M4_d 4.92481e-17
R_x_PM_NOR4_X1%ZN_r7 N_ZN_M3_d x_PM_NOR4_X1%ZN_16 4.03071
R_x_PM_NOR4_X1%ZN_r8 x_PM_NOR4_X1%ZN_20 x_PM_NOR4_X1%ZN_15 0.160909
R_x_PM_NOR4_X1%ZN_r9 x_PM_NOR4_X1%ZN_16 x_PM_NOR4_X1%ZN_14 0.212317
R_x_PM_NOR4_X1%ZN_r10 x_PM_NOR4_X1%ZN_15 x_PM_NOR4_X1%ZN_14 0.678571
R_x_PM_NOR4_X1%ZN_r11 x_PM_NOR4_X1%ZN_20 x_PM_NOR4_X1%ZN_13 0.0418175
R_x_PM_NOR4_X1%ZN_r12 x_PM_NOR4_X1%ZN_13 N_ZN_M6_d 0.543196
R_x_PM_NOR4_X1%ZN_r13 x_PM_NOR4_X1%ZN_20 x_PM_NOR4_X1%ZN_10 0.160909
R_x_PM_NOR4_X1%ZN_r14 x_PM_NOR4_X1%ZN_11 x_PM_NOR4_X1%ZN_10 1.54714
R_x_PM_NOR4_X1%ZN_r15 x_PM_NOR4_X1%ZN_11 ZN 0.194115
R_x_PM_NOR4_X1%ZN_r16 ZN N_ZN_M4_d 0.591906
C_x_PM_NOR4_X1%A3_c0 VSS x_PM_NOR4_X1%A3_14 8.94508e-18
C_x_PM_NOR4_X1%A3_c1 VSS x_PM_NOR4_X1%A3_12 4.30191e-17
C_x_PM_NOR4_X1%A3_c2 VSS N_A3_M1_g 4.31424e-17
C_x_PM_NOR4_X1%A3_c3 VSS N_A3_M5_g 7.51703e-17
R_x_PM_NOR4_X1%A3_r4 x_PM_NOR4_X1%A3_18 x_PM_NOR4_X1%A3_14 4.74714
R_x_PM_NOR4_X1%A3_r5 x_PM_NOR4_X1%A3_17 x_PM_NOR4_X1%A3_14 4.74714
R_x_PM_NOR4_X1%A3_r6 x_PM_NOR4_X1%A3_14 x_PM_NOR4_X1%A3_12 25.0012
R_x_PM_NOR4_X1%A3_r7 x_PM_NOR4_X1%A3_12 A3 0.145667
R_x_PM_NOR4_X1%A3_r8 N_A3_M1_g x_PM_NOR4_X1%A3_18 33.15
R_x_PM_NOR4_X1%A3_r9 N_A3_M5_g x_PM_NOR4_X1%A3_17 101.4
C_x_PM_NOR4_X1%A2_c0 VSS x_PM_NOR4_X1%A2_14 9.34215e-18
C_x_PM_NOR4_X1%A2_c1 VSS x_PM_NOR4_X1%A2_12 6.2531e-17
C_x_PM_NOR4_X1%A2_c2 VSS N_A2_M2_g 4.31624e-17
C_x_PM_NOR4_X1%A2_c3 VSS N_A2_M6_g 7.56943e-17
R_x_PM_NOR4_X1%A2_r4 x_PM_NOR4_X1%A2_18 x_PM_NOR4_X1%A2_14 4.74714
R_x_PM_NOR4_X1%A2_r5 x_PM_NOR4_X1%A2_17 x_PM_NOR4_X1%A2_14 4.74714
R_x_PM_NOR4_X1%A2_r6 x_PM_NOR4_X1%A2_14 x_PM_NOR4_X1%A2_12 25.0012
R_x_PM_NOR4_X1%A2_r7 x_PM_NOR4_X1%A2_12 A2 0.145667
R_x_PM_NOR4_X1%A2_r8 N_A2_M2_g x_PM_NOR4_X1%A2_18 33.15
R_x_PM_NOR4_X1%A2_r9 N_A2_M6_g x_PM_NOR4_X1%A2_17 101.4
C_x_PM_NOR4_X1%A1_c0 VSS x_PM_NOR4_X1%A1_18 1.2289e-17
C_x_PM_NOR4_X1%A1_c1 VSS x_PM_NOR4_X1%A1_12 5.94854e-17
C_x_PM_NOR4_X1%A1_c2 VSS N_A1_M3_g 4.80038e-17
C_x_PM_NOR4_X1%A1_c3 VSS N_A1_M7_g 8.68714e-17
R_x_PM_NOR4_X1%A1_r4 x_PM_NOR4_X1%A1_18 x_PM_NOR4_X1%A1_14 3.9
R_x_PM_NOR4_X1%A1_r5 x_PM_NOR4_X1%A1_14 x_PM_NOR4_X1%A1_12 25.0012
R_x_PM_NOR4_X1%A1_r6 x_PM_NOR4_X1%A1_12 A1 0.095
R_x_PM_NOR4_X1%A1_r7 x_PM_NOR4_X1%A1_18 x_PM_NOR4_X1%A1_5 1.95
R_x_PM_NOR4_X1%A1_r8 N_A1_M3_g x_PM_NOR4_X1%A1_5 33.15
R_x_PM_NOR4_X1%A1_r9 x_PM_NOR4_X1%A1_18 x_PM_NOR4_X1%A1_VSS 1.95
R_x_PM_NOR4_X1%A1_r10 N_A1_M7_g x_PM_NOR4_X1%A1_VSS 101.4
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X2 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B A4:I ZN:O A3:I A2:I A1:I
M_M4 8 N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.650000U L=0.050000U
M_M5 9 N_A3_M1_g 8 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M6 10 N_A2_M2_g 9 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M7 N_ZN_M3_d N_A1_M3_g 10 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M0 N_ZN_M4_d N_A4_M4_g N_VSS_M4_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M5_d N_A3_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_ZN_M6_d N_A2_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_VSS_M7_d N_A1_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_NOR4_X2%VSS_c0 VSS VSS 2.64443e-18
C_x_PM_NOR4_X2%VSS_c1 VSS N_VSS_M7_d 1.30717e-17
C_x_PM_NOR4_X2%VSS_c2 VSS x_PM_NOR4_X2%VSS_14 5.3438e-17
C_x_PM_NOR4_X2%VSS_c3 VSS N_VSS_M5_d 2.04204e-17
C_x_PM_NOR4_X2%VSS_c4 VSS x_PM_NOR4_X2%VSS_9 1.06295e-17
C_x_PM_NOR4_X2%VSS_c5 VSS x_PM_NOR4_X2%VSS_8 3.88904e-17
C_x_PM_NOR4_X2%VSS_c6 VSS N_VSS_M4_s 1.0831e-17
R_x_PM_NOR4_X2%VSS_r7 N_VSS_M7_d x_PM_NOR4_X2%VSS_16 0.230714
R_x_PM_NOR4_X2%VSS_r8 VSS x_PM_NOR4_X2%VSS_15 0.0731438
R_x_PM_NOR4_X2%VSS_r9 x_PM_NOR4_X2%VSS_16 x_PM_NOR4_X2%VSS_14 0.264221
R_x_PM_NOR4_X2%VSS_r10 x_PM_NOR4_X2%VSS_15 x_PM_NOR4_X2%VSS_14 0.681765
R_x_PM_NOR4_X2%VSS_r11 VSS x_PM_NOR4_X2%VSS_10 0.145286
R_x_PM_NOR4_X2%VSS_r12 N_VSS_M5_d x_PM_NOR4_X2%VSS_10 0.230714
R_x_PM_NOR4_X2%VSS_r13 VSS x_PM_NOR4_X2%VSS_8 0.0731438
R_x_PM_NOR4_X2%VSS_r14 x_PM_NOR4_X2%VSS_9 x_PM_NOR4_X2%VSS_8 0.692941
R_x_PM_NOR4_X2%VSS_r15 x_PM_NOR4_X2%VSS_9 x_PM_NOR4_X2%VSS_4 0.264221
R_x_PM_NOR4_X2%VSS_r16 N_VSS_M4_s x_PM_NOR4_X2%VSS_4 0.230714
C_x_PM_NOR4_X2%VDD_c0 VSS VDD 7.40695e-17
C_x_PM_NOR4_X2%VDD_c1 VSS N_VDD_M0_s 2.4691e-17
C_x_PM_NOR4_X2%VDD_c2 VSS x_PM_NOR4_X2%VDD_2 1.06862e-17
R_x_PM_NOR4_X2%VDD_r3 VDD x_PM_NOR4_X2%VDD_2 0.0689273
R_x_PM_NOR4_X2%VDD_r4 N_VDD_M0_s x_PM_NOR4_X2%VDD_2 0.230714
C_x_PM_NOR4_X2%A4_c0 VSS x_PM_NOR4_X2%A4_14 7.18659e-18
C_x_PM_NOR4_X2%A4_c1 VSS x_PM_NOR4_X2%A4_12 3.56769e-17
C_x_PM_NOR4_X2%A4_c2 VSS N_A4_M0_g 7.98018e-17
C_x_PM_NOR4_X2%A4_c3 VSS N_A4_M4_g 4.23053e-17
R_x_PM_NOR4_X2%A4_r4 x_PM_NOR4_X2%A4_18 x_PM_NOR4_X2%A4_14 4.74714
R_x_PM_NOR4_X2%A4_r5 x_PM_NOR4_X2%A4_17 x_PM_NOR4_X2%A4_14 4.74714
R_x_PM_NOR4_X2%A4_r6 x_PM_NOR4_X2%A4_14 x_PM_NOR4_X2%A4_12 25.0012
R_x_PM_NOR4_X2%A4_r7 x_PM_NOR4_X2%A4_12 A4 0.156071
R_x_PM_NOR4_X2%A4_r8 N_A4_M0_g x_PM_NOR4_X2%A4_18 70.98
R_x_PM_NOR4_X2%A4_r9 N_A4_M4_g x_PM_NOR4_X2%A4_17 42.9
C_x_PM_NOR4_X2%ZN_c0 VSS x_PM_NOR4_X2%ZN_27 1.32309e-17
C_x_PM_NOR4_X2%ZN_c1 VSS x_PM_NOR4_X2%ZN_26 2.32902e-17
C_x_PM_NOR4_X2%ZN_c2 VSS x_PM_NOR4_X2%ZN_23 4.60612e-17
C_x_PM_NOR4_X2%ZN_c3 VSS N_ZN_M3_d 2.50235e-17
C_x_PM_NOR4_X2%ZN_c4 VSS x_PM_NOR4_X2%ZN_18 3.46798e-18
C_x_PM_NOR4_X2%ZN_c5 VSS x_PM_NOR4_X2%ZN_16 2.65091e-17
C_x_PM_NOR4_X2%ZN_c6 VSS N_ZN_M6_d 2.42211e-17
C_x_PM_NOR4_X2%ZN_c7 VSS x_PM_NOR4_X2%ZN_11 2.27649e-17
C_x_PM_NOR4_X2%ZN_c8 VSS x_PM_NOR4_X2%ZN_10 1.9661e-17
C_x_PM_NOR4_X2%ZN_c9 VSS x_PM_NOR4_X2%ZN_9 1.62159e-17
C_x_PM_NOR4_X2%ZN_c10 VSS N_ZN_M4_d 2.33665e-17
R_x_PM_NOR4_X2%ZN_r11 x_PM_NOR4_X2%ZN_26 ZN 0.189936
R_x_PM_NOR4_X2%ZN_r12 x_PM_NOR4_X2%ZN_23 x_PM_NOR4_X2%ZN_22 1.65571
R_x_PM_NOR4_X2%ZN_r13 x_PM_NOR4_X2%ZN_23 x_PM_NOR4_X2%ZN_18 0.192227
R_x_PM_NOR4_X2%ZN_r14 N_ZN_M3_d x_PM_NOR4_X2%ZN_18 0.861333
R_x_PM_NOR4_X2%ZN_r15 x_PM_NOR4_X2%ZN_27 x_PM_NOR4_X2%ZN_17 0.113465
R_x_PM_NOR4_X2%ZN_r16 x_PM_NOR4_X2%ZN_22 x_PM_NOR4_X2%ZN_16 0.212317
R_x_PM_NOR4_X2%ZN_r17 x_PM_NOR4_X2%ZN_17 x_PM_NOR4_X2%ZN_16 0.705714
R_x_PM_NOR4_X2%ZN_r18 x_PM_NOR4_X2%ZN_27 x_PM_NOR4_X2%ZN_12 0.0883294
R_x_PM_NOR4_X2%ZN_r19 N_ZN_M6_d x_PM_NOR4_X2%ZN_12 0.257857
R_x_PM_NOR4_X2%ZN_r20 ZN x_PM_NOR4_X2%ZN_11 0.095
R_x_PM_NOR4_X2%ZN_r21 x_PM_NOR4_X2%ZN_27 x_PM_NOR4_X2%ZN_10 0.113465
R_x_PM_NOR4_X2%ZN_r22 x_PM_NOR4_X2%ZN_11 x_PM_NOR4_X2%ZN_10 0.257857
R_x_PM_NOR4_X2%ZN_r23 x_PM_NOR4_X2%ZN_9 x_PM_NOR4_X2%ZN_26 0.732857
R_x_PM_NOR4_X2%ZN_r24 x_PM_NOR4_X2%ZN_9 x_PM_NOR4_X2%ZN_4 0.212317
R_x_PM_NOR4_X2%ZN_r25 N_ZN_M4_d x_PM_NOR4_X2%ZN_4 0.257857
C_x_PM_NOR4_X2%A3_c0 VSS x_PM_NOR4_X2%A3_14 8.988e-18
C_x_PM_NOR4_X2%A3_c1 VSS x_PM_NOR4_X2%A3_12 6.21612e-17
C_x_PM_NOR4_X2%A3_c2 VSS N_A3_M1_g 8.04354e-17
C_x_PM_NOR4_X2%A3_c3 VSS N_A3_M5_g 4.7e-17
R_x_PM_NOR4_X2%A3_r4 x_PM_NOR4_X2%A3_18 x_PM_NOR4_X2%A3_14 4.74714
R_x_PM_NOR4_X2%A3_r5 x_PM_NOR4_X2%A3_17 x_PM_NOR4_X2%A3_14 4.74714
R_x_PM_NOR4_X2%A3_r6 x_PM_NOR4_X2%A3_14 x_PM_NOR4_X2%A3_12 25.0012
R_x_PM_NOR4_X2%A3_r7 x_PM_NOR4_X2%A3_12 A3 0.156071
R_x_PM_NOR4_X2%A3_r8 N_A3_M1_g x_PM_NOR4_X2%A3_18 70.98
R_x_PM_NOR4_X2%A3_r9 N_A3_M5_g x_PM_NOR4_X2%A3_17 42.9
C_x_PM_NOR4_X2%A2_c0 VSS x_PM_NOR4_X2%A2_11 9.40823e-18
C_x_PM_NOR4_X2%A2_c1 VSS x_PM_NOR4_X2%A2_9 7.48156e-17
C_x_PM_NOR4_X2%A2_c2 VSS N_A2_M2_g 7.24567e-17
C_x_PM_NOR4_X2%A2_c3 VSS N_A2_M6_g 5.58007e-17
R_x_PM_NOR4_X2%A2_r4 x_PM_NOR4_X2%A2_18 x_PM_NOR4_X2%A2_11 4.74714
R_x_PM_NOR4_X2%A2_r5 x_PM_NOR4_X2%A2_17 x_PM_NOR4_X2%A2_11 4.74714
R_x_PM_NOR4_X2%A2_r6 x_PM_NOR4_X2%A2_11 x_PM_NOR4_X2%A2_9 25.0012
R_x_PM_NOR4_X2%A2_r7 A2 x_PM_NOR4_X2%A2_9 0.1748
R_x_PM_NOR4_X2%A2_r8 N_A2_M2_g x_PM_NOR4_X2%A2_18 58.5
R_x_PM_NOR4_X2%A2_r9 N_A2_M6_g x_PM_NOR4_X2%A2_17 55.38
C_x_PM_NOR4_X2%A1_c0 VSS x_PM_NOR4_X2%A1_18 1.20639e-17
C_x_PM_NOR4_X2%A1_c1 VSS x_PM_NOR4_X2%A1_9 8.8423e-17
C_x_PM_NOR4_X2%A1_c2 VSS N_A1_M3_g 7.69685e-17
C_x_PM_NOR4_X2%A1_c3 VSS N_A1_M7_g 5.68099e-17
R_x_PM_NOR4_X2%A1_r4 x_PM_NOR4_X2%A1_18 x_PM_NOR4_X2%A1_11 3.38
R_x_PM_NOR4_X2%A1_r5 x_PM_NOR4_X2%A1_11 x_PM_NOR4_X2%A1_9 25.0012
R_x_PM_NOR4_X2%A1_r6 A1 x_PM_NOR4_X2%A1_9 0.198636
R_x_PM_NOR4_X2%A1_r7 x_PM_NOR4_X2%A1_18 x_PM_NOR4_X2%A1_5 1.95
R_x_PM_NOR4_X2%A1_r8 N_A1_M3_g x_PM_NOR4_X2%A1_5 58.5
R_x_PM_NOR4_X2%A1_r9 x_PM_NOR4_X2%A1_18 x_PM_NOR4_X2%A1_VSS 1.95
R_x_PM_NOR4_X2%A1_r10 N_A1_M7_g x_PM_NOR4_X2%A1_VSS 55.38
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   NOR4_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT NOR4_X4 VSS VDD A4 ZN A3 A2 A1
*.PININFO VSS:B VDD:B ZN:O A4:I A3:I A2:I A1:I
M_M8 8 N_A4_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.650000U L=0.050000U
M_M9 9 N_A3_M1_g 8 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M10 10 N_A2_M2_g 9 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M11 N_ZN_M3_d N_A1_M3_g 10 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M12 11 N_A1_M4_g N_ZN_M3_d VDD PMOS_VTL W=0.650000U L=0.050000U
M_M13 12 N_A2_M5_g 11 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M14 13 N_A3_M6_g 12 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M15 N_VDD_M7_d N_A4_M7_g 13 VDD PMOS_VTL W=0.650000U L=0.050000U
M_M0 N_ZN_M8_d N_A4_M8_g N_VSS_M8_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_VSS_M9_d N_A3_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_ZN_M10_d N_A2_M10_g N_VSS_M9_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_VSS_M11_d N_A1_M11_g N_ZN_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_ZN_M12_d N_A1_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M13_d N_A2_M13_g N_ZN_M12_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_ZN_M14_d N_A3_M14_g N_VSS_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 N_VSS_M15_d N_A4_M15_g N_ZN_M14_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_NOR4_X4%VSS_c0 VSS x_PM_NOR4_X4%VSS_33 2.51362e-17
C_x_PM_NOR4_X4%VSS_c1 VSS x_PM_NOR4_X4%VSS_29 2.50466e-17
C_x_PM_NOR4_X4%VSS_c2 VSS x_PM_NOR4_X4%VSS_26 3.52687e-17
C_x_PM_NOR4_X4%VSS_c3 VSS x_PM_NOR4_X4%VSS_22 3.41697e-17
C_x_PM_NOR4_X4%VSS_c4 VSS N_VSS_M15_d 9.79457e-18
C_x_PM_NOR4_X4%VSS_c5 VSS x_PM_NOR4_X4%VSS_12 4.70086e-17
C_x_PM_NOR4_X4%VSS_c6 VSS x_PM_NOR4_X4%VSS_10 3.5268e-17
C_x_PM_NOR4_X4%VSS_c7 VSS x_PM_NOR4_X4%VSS_9 2.49897e-17
C_x_PM_NOR4_X4%VSS_c8 VSS x_PM_NOR4_X4%VSS_7 3.41376e-17
R_x_PM_NOR4_X4%VSS_r9 x_PM_NOR4_X4%VSS_33 N_VSS_M13_d 0.140674
R_x_PM_NOR4_X4%VSS_r10 x_PM_NOR4_X4%VSS_29 N_VSS_M11_d 0.140674
R_x_PM_NOR4_X4%VSS_r11 N_VSS_M11_d VSS 0.0271429
R_x_PM_NOR4_X4%VSS_r12 x_PM_NOR4_X4%VSS_26 VSS 0.113531
R_x_PM_NOR4_X4%VSS_r13 x_PM_NOR4_X4%VSS_22 N_VSS_M9_d 0.140674
R_x_PM_NOR4_X4%VSS_r14 N_VSS_M15_d x_PM_NOR4_X4%VSS_14 0.230714
R_x_PM_NOR4_X4%VSS_r15 x_PM_NOR4_X4%VSS_14 x_PM_NOR4_X4%VSS_12 0.264221
R_x_PM_NOR4_X4%VSS_r16 x_PM_NOR4_X4%VSS_33 x_PM_NOR4_X4%VSS_12 0.614706
R_x_PM_NOR4_X4%VSS_r17 x_PM_NOR4_X4%VSS_10 N_VSS_M13_d 0.140674
R_x_PM_NOR4_X4%VSS_r18 x_PM_NOR4_X4%VSS_29 x_PM_NOR4_X4%VSS_10 0.547647
R_x_PM_NOR4_X4%VSS_r19 x_PM_NOR4_X4%VSS_9 N_VSS_M9_d 0.140674
R_x_PM_NOR4_X4%VSS_r20 x_PM_NOR4_X4%VSS_9 x_PM_NOR4_X4%VSS_26 0.547647
R_x_PM_NOR4_X4%VSS_r21 N_VSS_M8_s x_PM_NOR4_X4%VSS_7 0.114152
R_x_PM_NOR4_X4%VSS_r22 x_PM_NOR4_X4%VSS_7 x_PM_NOR4_X4%VSS_22 0.536471
C_x_PM_NOR4_X4%VDD_c0 VSS VDD 1.35516e-17
C_x_PM_NOR4_X4%VDD_c1 VSS N_VDD_M7_d 4.13172e-17
C_x_PM_NOR4_X4%VDD_c2 VSS x_PM_NOR4_X4%VDD_7 2.63747e-16
C_x_PM_NOR4_X4%VDD_c3 VSS N_VDD_M0_s 4.14199e-17
R_x_PM_NOR4_X4%VDD_r4 x_PM_NOR4_X4%VDD_16 VDD 0.202667
R_x_PM_NOR4_X4%VDD_r5 x_PM_NOR4_X4%VDD_15 VDD 0.12156
R_x_PM_NOR4_X4%VDD_r6 N_VDD_M7_d x_PM_NOR4_X4%VDD_9 0.230714
R_x_PM_NOR4_X4%VDD_r7 x_PM_NOR4_X4%VDD_16 x_PM_NOR4_X4%VDD_8 0.095
R_x_PM_NOR4_X4%VDD_r8 x_PM_NOR4_X4%VDD_9 x_PM_NOR4_X4%VDD_7 0.264221
R_x_PM_NOR4_X4%VDD_r9 x_PM_NOR4_X4%VDD_8 x_PM_NOR4_X4%VDD_7 3.24118
R_x_PM_NOR4_X4%VDD_r10 N_VDD_M0_s x_PM_NOR4_X4%VDD_15 0.230714
C_x_PM_NOR4_X4%ZN_c0 VSS x_PM_NOR4_X4%ZN_42 2.03834e-18
C_x_PM_NOR4_X4%ZN_c1 VSS x_PM_NOR4_X4%ZN_41 2.80716e-18
C_x_PM_NOR4_X4%ZN_c2 VSS x_PM_NOR4_X4%ZN_36 1.92191e-17
C_x_PM_NOR4_X4%ZN_c3 VSS N_ZN_M14_d 2.03172e-17
C_x_PM_NOR4_X4%ZN_c4 VSS x_PM_NOR4_X4%ZN_31 7.48514e-18
C_x_PM_NOR4_X4%ZN_c5 VSS x_PM_NOR4_X4%ZN_30 5.32635e-17
C_x_PM_NOR4_X4%ZN_c6 VSS N_ZN_M12_d 1.66727e-17
C_x_PM_NOR4_X4%ZN_c7 VSS x_PM_NOR4_X4%ZN_25 6.74483e-17
C_x_PM_NOR4_X4%ZN_c8 VSS x_PM_NOR4_X4%ZN_20 4.81586e-17
C_x_PM_NOR4_X4%ZN_c9 VSS x_PM_NOR4_X4%ZN_18 4.19444e-17
C_x_PM_NOR4_X4%ZN_c10 VSS N_ZN_M10_d 1.60544e-17
C_x_PM_NOR4_X4%ZN_c11 VSS x_PM_NOR4_X4%ZN_12 4.28085e-17
C_x_PM_NOR4_X4%ZN_c12 VSS N_ZN_M8_d 1.96698e-17
C_x_PM_NOR4_X4%ZN_c13 VSS x_PM_NOR4_X4%ZN_6 2.01268e-17
R_x_PM_NOR4_X4%ZN_r14 x_PM_NOR4_X4%ZN_44 x_PM_NOR4_X4%ZN_43 0.245882
R_x_PM_NOR4_X4%ZN_r15 ZN x_PM_NOR4_X4%ZN_36 0.215333
R_x_PM_NOR4_X4%ZN_r16 N_ZN_M14_d x_PM_NOR4_X4%ZN_32 0.176429
R_x_PM_NOR4_X4%ZN_r17 x_PM_NOR4_X4%ZN_44 x_PM_NOR4_X4%ZN_31 0.156471
R_x_PM_NOR4_X4%ZN_r18 x_PM_NOR4_X4%ZN_32 x_PM_NOR4_X4%ZN_30 0.214913
R_x_PM_NOR4_X4%ZN_r19 x_PM_NOR4_X4%ZN_31 x_PM_NOR4_X4%ZN_30 1.38588
R_x_PM_NOR4_X4%ZN_r20 x_PM_NOR4_X4%ZN_44 x_PM_NOR4_X4%ZN_26 0.095
R_x_PM_NOR4_X4%ZN_r21 N_ZN_M12_d x_PM_NOR4_X4%ZN_26 0.176429
R_x_PM_NOR4_X4%ZN_r22 x_PM_NOR4_X4%ZN_43 x_PM_NOR4_X4%ZN_24 0.095
R_x_PM_NOR4_X4%ZN_r23 x_PM_NOR4_X4%ZN_25 x_PM_NOR4_X4%ZN_24 1.71
R_x_PM_NOR4_X4%ZN_r24 x_PM_NOR4_X4%ZN_25 x_PM_NOR4_X4%ZN_20 0.212317
R_x_PM_NOR4_X4%ZN_r25 N_ZN_M3_d x_PM_NOR4_X4%ZN_20 0.502143
R_x_PM_NOR4_X4%ZN_r26 x_PM_NOR4_X4%ZN_42 x_PM_NOR4_X4%ZN_19 0.136506
R_x_PM_NOR4_X4%ZN_r27 x_PM_NOR4_X4%ZN_43 x_PM_NOR4_X4%ZN_18 0.156471
R_x_PM_NOR4_X4%ZN_r28 x_PM_NOR4_X4%ZN_19 x_PM_NOR4_X4%ZN_18 1.14
R_x_PM_NOR4_X4%ZN_r29 x_PM_NOR4_X4%ZN_42 x_PM_NOR4_X4%ZN_14 0.0638579
R_x_PM_NOR4_X4%ZN_r30 N_ZN_M10_d x_PM_NOR4_X4%ZN_14 0.176429
R_x_PM_NOR4_X4%ZN_r31 x_PM_NOR4_X4%ZN_41 x_PM_NOR4_X4%ZN_13 0.136506
R_x_PM_NOR4_X4%ZN_r32 x_PM_NOR4_X4%ZN_42 x_PM_NOR4_X4%ZN_12 0.136506
R_x_PM_NOR4_X4%ZN_r33 x_PM_NOR4_X4%ZN_13 x_PM_NOR4_X4%ZN_12 1.38588
R_x_PM_NOR4_X4%ZN_r34 x_PM_NOR4_X4%ZN_41 x_PM_NOR4_X4%ZN_8 0.0638579
R_x_PM_NOR4_X4%ZN_r35 N_ZN_M8_d x_PM_NOR4_X4%ZN_8 0.176429
R_x_PM_NOR4_X4%ZN_r36 x_PM_NOR4_X4%ZN_36 x_PM_NOR4_X4%ZN_7 0.095
R_x_PM_NOR4_X4%ZN_r37 x_PM_NOR4_X4%ZN_41 x_PM_NOR4_X4%ZN_6 0.136506
R_x_PM_NOR4_X4%ZN_r38 x_PM_NOR4_X4%ZN_7 x_PM_NOR4_X4%ZN_6 0.603529
C_x_PM_NOR4_X4%A4_c0 VSS x_PM_NOR4_X4%A4_32 7.4242e-18
C_x_PM_NOR4_X4%A4_c1 VSS x_PM_NOR4_X4%A4_30 1.65234e-17
C_x_PM_NOR4_X4%A4_c2 VSS x_PM_NOR4_X4%A4_27 7.58266e-18
C_x_PM_NOR4_X4%A4_c3 VSS x_PM_NOR4_X4%A4_25 2.16009e-17
C_x_PM_NOR4_X4%A4_c4 VSS x_PM_NOR4_X4%A4_24 5.80006e-17
C_x_PM_NOR4_X4%A4_c5 VSS x_PM_NOR4_X4%A4_20 3.65458e-17
C_x_PM_NOR4_X4%A4_c6 VSS x_PM_NOR4_X4%A4_19 3.4931e-16
C_x_PM_NOR4_X4%A4_c7 VSS x_PM_NOR4_X4%A4_18 6.07483e-17
C_x_PM_NOR4_X4%A4_c8 VSS N_A4_M7_g 6.76399e-17
C_x_PM_NOR4_X4%A4_c9 VSS N_A4_M15_g 4.89818e-17
C_x_PM_NOR4_X4%A4_c10 VSS N_A4_M0_g 6.76496e-17
C_x_PM_NOR4_X4%A4_c11 VSS N_A4_M8_g 5.31477e-17
R_x_PM_NOR4_X4%A4_r12 x_PM_NOR4_X4%A4_40 x_PM_NOR4_X4%A4_32 4.7687
R_x_PM_NOR4_X4%A4_r13 x_PM_NOR4_X4%A4_39 x_PM_NOR4_X4%A4_32 4.7687
R_x_PM_NOR4_X4%A4_r14 x_PM_NOR4_X4%A4_32 x_PM_NOR4_X4%A4_30 25.0012
R_x_PM_NOR4_X4%A4_r15 x_PM_NOR4_X4%A4_37 x_PM_NOR4_X4%A4_27 4.7687
R_x_PM_NOR4_X4%A4_r16 x_PM_NOR4_X4%A4_36 x_PM_NOR4_X4%A4_27 4.7687
R_x_PM_NOR4_X4%A4_r17 x_PM_NOR4_X4%A4_27 x_PM_NOR4_X4%A4_25 25.0012
R_x_PM_NOR4_X4%A4_r18 x_PM_NOR4_X4%A4_23 x_PM_NOR4_X4%A4_30 0.297071
R_x_PM_NOR4_X4%A4_r19 x_PM_NOR4_X4%A4_24 x_PM_NOR4_X4%A4_23 2.79571
R_x_PM_NOR4_X4%A4_r20 A4 x_PM_NOR4_X4%A4_20 3.09429
R_x_PM_NOR4_X4%A4_r21 x_PM_NOR4_X4%A4_24 x_PM_NOR4_X4%A4_19 0.212317
R_x_PM_NOR4_X4%A4_r22 A4 x_PM_NOR4_X4%A4_19 3.31143
R_x_PM_NOR4_X4%A4_r23 x_PM_NOR4_X4%A4_20 x_PM_NOR4_X4%A4_18 0.212317
R_x_PM_NOR4_X4%A4_r24 x_PM_NOR4_X4%A4_17 x_PM_NOR4_X4%A4_25 0.297071
R_x_PM_NOR4_X4%A4_r25 x_PM_NOR4_X4%A4_18 x_PM_NOR4_X4%A4_17 2.79571
R_x_PM_NOR4_X4%A4_r26 N_A4_M7_g x_PM_NOR4_X4%A4_40 58.5
R_x_PM_NOR4_X4%A4_r27 N_A4_M15_g x_PM_NOR4_X4%A4_39 55.38
R_x_PM_NOR4_X4%A4_r28 N_A4_M0_g x_PM_NOR4_X4%A4_37 58.5
R_x_PM_NOR4_X4%A4_r29 N_A4_M8_g x_PM_NOR4_X4%A4_36 55.38
C_x_PM_NOR4_X4%A3_c0 VSS x_PM_NOR4_X4%A3_29 8.99116e-18
C_x_PM_NOR4_X4%A3_c1 VSS x_PM_NOR4_X4%A3_27 8.26037e-17
C_x_PM_NOR4_X4%A3_c2 VSS x_PM_NOR4_X4%A3_23 2.99822e-17
C_x_PM_NOR4_X4%A3_c3 VSS x_PM_NOR4_X4%A3_22 2.83502e-16
C_x_PM_NOR4_X4%A3_c4 VSS x_PM_NOR4_X4%A3_20 8.56165e-18
C_x_PM_NOR4_X4%A3_c5 VSS x_PM_NOR4_X4%A3_18 8.40852e-17
C_x_PM_NOR4_X4%A3_c6 VSS N_A3_M6_g 7.20811e-17
C_x_PM_NOR4_X4%A3_c7 VSS N_A3_M14_g 5.43625e-17
C_x_PM_NOR4_X4%A3_c8 VSS N_A3_M1_g 7.20348e-17
C_x_PM_NOR4_X4%A3_c9 VSS N_A3_M9_g 5.35457e-17
R_x_PM_NOR4_X4%A3_r10 x_PM_NOR4_X4%A3_36 x_PM_NOR4_X4%A3_29 4.74714
R_x_PM_NOR4_X4%A3_r11 x_PM_NOR4_X4%A3_35 x_PM_NOR4_X4%A3_29 4.74714
R_x_PM_NOR4_X4%A3_r12 x_PM_NOR4_X4%A3_29 x_PM_NOR4_X4%A3_27 25.0012
R_x_PM_NOR4_X4%A3_r13 x_PM_NOR4_X4%A3_27 x_PM_NOR4_X4%A3_26 2.40214
R_x_PM_NOR4_X4%A3_r14 A3 x_PM_NOR4_X4%A3_23 2.19857
R_x_PM_NOR4_X4%A3_r15 x_PM_NOR4_X4%A3_26 x_PM_NOR4_X4%A3_22 0.212317
R_x_PM_NOR4_X4%A3_r16 A3 x_PM_NOR4_X4%A3_22 2.38857
R_x_PM_NOR4_X4%A3_r17 x_PM_NOR4_X4%A3_33 x_PM_NOR4_X4%A3_20 4.7687
R_x_PM_NOR4_X4%A3_r18 x_PM_NOR4_X4%A3_32 x_PM_NOR4_X4%A3_20 4.7687
R_x_PM_NOR4_X4%A3_r19 x_PM_NOR4_X4%A3_20 x_PM_NOR4_X4%A3_18 25.0012
R_x_PM_NOR4_X4%A3_r20 x_PM_NOR4_X4%A3_23 x_PM_NOR4_X4%A3_17 0.212317
R_x_PM_NOR4_X4%A3_r21 x_PM_NOR4_X4%A3_18 x_PM_NOR4_X4%A3_17 2.40214
R_x_PM_NOR4_X4%A3_r22 N_A3_M6_g x_PM_NOR4_X4%A3_36 58.5
R_x_PM_NOR4_X4%A3_r23 N_A3_M14_g x_PM_NOR4_X4%A3_35 55.38
R_x_PM_NOR4_X4%A3_r24 N_A3_M1_g x_PM_NOR4_X4%A3_33 58.5
R_x_PM_NOR4_X4%A3_r25 N_A3_M9_g x_PM_NOR4_X4%A3_32 55.38
C_x_PM_NOR4_X4%A2_c0 VSS x_PM_NOR4_X4%A2_29 8.39837e-18
C_x_PM_NOR4_X4%A2_c1 VSS x_PM_NOR4_X4%A2_27 6.6948e-17
C_x_PM_NOR4_X4%A2_c2 VSS x_PM_NOR4_X4%A2_23 2.39277e-17
C_x_PM_NOR4_X4%A2_c3 VSS x_PM_NOR4_X4%A2_22 1.38156e-16
C_x_PM_NOR4_X4%A2_c4 VSS x_PM_NOR4_X4%A2_20 8.47083e-18
C_x_PM_NOR4_X4%A2_c5 VSS x_PM_NOR4_X4%A2_18 3.98111e-17
C_x_PM_NOR4_X4%A2_c6 VSS N_A2_M5_g 7.64074e-17
C_x_PM_NOR4_X4%A2_c7 VSS N_A2_M13_g 5.32865e-17
C_x_PM_NOR4_X4%A2_c8 VSS N_A2_M2_g 7.65955e-17
C_x_PM_NOR4_X4%A2_c9 VSS N_A2_M10_g 5.4051e-17
R_x_PM_NOR4_X4%A2_r10 x_PM_NOR4_X4%A2_36 x_PM_NOR4_X4%A2_29 4.7687
R_x_PM_NOR4_X4%A2_r11 x_PM_NOR4_X4%A2_35 x_PM_NOR4_X4%A2_29 4.7687
R_x_PM_NOR4_X4%A2_r12 x_PM_NOR4_X4%A2_29 x_PM_NOR4_X4%A2_27 25.0012
R_x_PM_NOR4_X4%A2_r13 x_PM_NOR4_X4%A2_27 x_PM_NOR4_X4%A2_26 1.64214
R_x_PM_NOR4_X4%A2_r14 A2 x_PM_NOR4_X4%A2_23 1.16714
R_x_PM_NOR4_X4%A2_r15 x_PM_NOR4_X4%A2_26 x_PM_NOR4_X4%A2_22 0.212317
R_x_PM_NOR4_X4%A2_r16 A2 x_PM_NOR4_X4%A2_22 1.38429
R_x_PM_NOR4_X4%A2_r17 x_PM_NOR4_X4%A2_33 x_PM_NOR4_X4%A2_20 4.7687
R_x_PM_NOR4_X4%A2_r18 x_PM_NOR4_X4%A2_32 x_PM_NOR4_X4%A2_20 4.7687
R_x_PM_NOR4_X4%A2_r19 x_PM_NOR4_X4%A2_20 x_PM_NOR4_X4%A2_18 25.0012
R_x_PM_NOR4_X4%A2_r20 x_PM_NOR4_X4%A2_23 x_PM_NOR4_X4%A2_17 0.212317
R_x_PM_NOR4_X4%A2_r21 x_PM_NOR4_X4%A2_18 x_PM_NOR4_X4%A2_17 1.64214
R_x_PM_NOR4_X4%A2_r22 N_A2_M5_g x_PM_NOR4_X4%A2_36 58.5
R_x_PM_NOR4_X4%A2_r23 N_A2_M13_g x_PM_NOR4_X4%A2_35 55.38
R_x_PM_NOR4_X4%A2_r24 N_A2_M2_g x_PM_NOR4_X4%A2_33 58.5
R_x_PM_NOR4_X4%A2_r25 N_A2_M10_g x_PM_NOR4_X4%A2_32 55.38
C_x_PM_NOR4_X4%A1_c0 VSS x_PM_NOR4_X4%A1_21 4.28507e-17
C_x_PM_NOR4_X4%A1_c1 VSS x_PM_NOR4_X4%A1_20 6.33378e-18
C_x_PM_NOR4_X4%A1_c2 VSS x_PM_NOR4_X4%A1_19 6.02463e-18
C_x_PM_NOR4_X4%A1_c3 VSS x_PM_NOR4_X4%A1_18 4.20539e-18
C_x_PM_NOR4_X4%A1_c4 VSS N_A1_M4_g 7.63086e-17
C_x_PM_NOR4_X4%A1_c5 VSS N_A1_M12_g 3.67989e-17
C_x_PM_NOR4_X4%A1_c6 VSS N_A1_M3_g 7.07318e-17
C_x_PM_NOR4_X4%A1_c7 VSS N_A1_M11_g 3.61766e-17
R_x_PM_NOR4_X4%A1_r8 x_PM_NOR4_X4%A1_23 x_PM_NOR4_X4%A1_21 25.0012
R_x_PM_NOR4_X4%A1_r9 A1 x_PM_NOR4_X4%A1_21 0.011875
R_x_PM_NOR4_X4%A1_r10 x_PM_NOR4_X4%A1_23 x_PM_NOR4_X4%A1_19 9.62
R_x_PM_NOR4_X4%A1_r11 x_PM_NOR4_X4%A1_20 x_PM_NOR4_X4%A1_19 0.043368
R_x_PM_NOR4_X4%A1_r12 x_PM_NOR4_X4%A1_23 x_PM_NOR4_X4%A1_17 4.94
R_x_PM_NOR4_X4%A1_r13 x_PM_NOR4_X4%A1_18 x_PM_NOR4_X4%A1_17 0.043368
R_x_PM_NOR4_X4%A1_r14 x_PM_NOR4_X4%A1_20 x_PM_NOR4_X4%A1_13 4.56151
R_x_PM_NOR4_X4%A1_r15 N_A1_M4_g x_PM_NOR4_X4%A1_13 71.76
R_x_PM_NOR4_X4%A1_r16 x_PM_NOR4_X4%A1_20 x_PM_NOR4_X4%A1_9 4.56151
R_x_PM_NOR4_X4%A1_r17 N_A1_M12_g x_PM_NOR4_X4%A1_9 42.12
R_x_PM_NOR4_X4%A1_r18 x_PM_NOR4_X4%A1_18 x_PM_NOR4_X4%A1_5 4.56151
R_x_PM_NOR4_X4%A1_r19 N_A1_M3_g x_PM_NOR4_X4%A1_5 71.76
R_x_PM_NOR4_X4%A1_r20 x_PM_NOR4_X4%A1_18 x_PM_NOR4_X4%A1_VSS 4.56151
R_x_PM_NOR4_X4%A1_r21 N_A1_M11_g x_PM_NOR4_X4%A1_VSS 42.12
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X1 VSS VDD C2 ZN C1 A B
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I A:I B:I
M_M4 noxref_9 N_C2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M1_d N_C1_M1_g noxref_9 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M3_d N_B_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_ZN_M4_d N_C2_M4_g N_4_M4_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 N_4_M5_d N_C1_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 noxref_10 N_A_M6_g N_4_M5_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_VSS_M7_d N_B_M7_g noxref_10 VSS NMOS_VTL W=0.170000U L=0.050000U
C_x_PM_OAI211_X1%VSS_c0 VSS N_VSS_M7_d 2.64297e-17
C_x_PM_OAI211_X1%VSS_c1 VSS x_PM_OAI211_X1%VSS_2 1.54645e-16
R_x_PM_OAI211_X1%VSS_r2 N_VSS_M7_d x_PM_OAI211_X1%VSS_6 0.936429
R_x_PM_OAI211_X1%VSS_r3 x_PM_OAI211_X1%VSS_6 x_PM_OAI211_X1%VSS_2 0.264221
R_x_PM_OAI211_X1%VSS_r4 VSS x_PM_OAI211_X1%VSS_2 0.804706
C_x_PM_OAI211_X1%VDD_c0 VSS x_PM_OAI211_X1%VDD_17 3.93303e-17
C_x_PM_OAI211_X1%VDD_c1 VSS N_VDD_M2_d 3.51798e-17
C_x_PM_OAI211_X1%VDD_c2 VSS x_PM_OAI211_X1%VDD_8 1.34805e-17
C_x_PM_OAI211_X1%VDD_c3 VSS x_PM_OAI211_X1%VDD_7 5.23045e-17
C_x_PM_OAI211_X1%VDD_c4 VSS N_VDD_M0_s 1.1756e-17
R_x_PM_OAI211_X1%VDD_r5 x_PM_OAI211_X1%VDD_17 x_PM_OAI211_X1%VDD_11 0.145286
R_x_PM_OAI211_X1%VDD_r6 N_VDD_M2_d x_PM_OAI211_X1%VDD_11 0.393571
R_x_PM_OAI211_X1%VDD_r7 VDD x_PM_OAI211_X1%VDD_8 0.726471
R_x_PM_OAI211_X1%VDD_r8 x_PM_OAI211_X1%VDD_17 x_PM_OAI211_X1%VDD_7 0.0731438
R_x_PM_OAI211_X1%VDD_r9 VDD x_PM_OAI211_X1%VDD_7 0.38
R_x_PM_OAI211_X1%VDD_r10 x_PM_OAI211_X1%VDD_8 x_PM_OAI211_X1%VDD_3 0.264221
R_x_PM_OAI211_X1%VDD_r11 N_VDD_M0_s x_PM_OAI211_X1%VDD_3 0.393571
C_x_PM_OAI211_X1%C2_c0 VSS x_PM_OAI211_X1%C2_18 1.00437e-17
C_x_PM_OAI211_X1%C2_c1 VSS x_PM_OAI211_X1%C2_12 4.34966e-17
C_x_PM_OAI211_X1%C2_c2 VSS N_C2_M0_g 7.48867e-17
C_x_PM_OAI211_X1%C2_c3 VSS N_C2_M4_g 3.27175e-17
R_x_PM_OAI211_X1%C2_r4 x_PM_OAI211_X1%C2_18 x_PM_OAI211_X1%C2_14 5.98
R_x_PM_OAI211_X1%C2_r5 x_PM_OAI211_X1%C2_14 x_PM_OAI211_X1%C2_12 25.0012
R_x_PM_OAI211_X1%C2_r6 x_PM_OAI211_X1%C2_12 C2 0.156071
R_x_PM_OAI211_X1%C2_r7 x_PM_OAI211_X1%C2_18 x_PM_OAI211_X1%C2_5 1.95
R_x_PM_OAI211_X1%C2_r8 N_C2_M0_g x_PM_OAI211_X1%C2_5 101.79
R_x_PM_OAI211_X1%C2_r9 x_PM_OAI211_X1%C2_18 x_PM_OAI211_X1%C2_VSS 1.95
R_x_PM_OAI211_X1%C2_r10 N_C2_M4_g x_PM_OAI211_X1%C2_VSS 23.4
C_x_PM_OAI211_X1%4_c0 VSS x_PM_OAI211_X1%4_8 1.64267e-17
C_x_PM_OAI211_X1%4_c1 VSS x_PM_OAI211_X1%4_7 9.77257e-17
C_x_PM_OAI211_X1%4_c2 VSS N_4_M4_s 1.74563e-17
C_x_PM_OAI211_X1%4_c3 VSS N_4_M5_d 1.91528e-17
R_x_PM_OAI211_X1%4_r4 x_PM_OAI211_X1%4_9 x_PM_OAI211_X1%4_7 0.212317
R_x_PM_OAI211_X1%4_r5 x_PM_OAI211_X1%4_8 x_PM_OAI211_X1%4_7 1.62857
R_x_PM_OAI211_X1%4_r6 x_PM_OAI211_X1%4_8 x_PM_OAI211_X1%4_3 0.212317
R_x_PM_OAI211_X1%4_r7 N_4_M4_s x_PM_OAI211_X1%4_3 0.203571
R_x_PM_OAI211_X1%4_r8 N_4_M5_d x_PM_OAI211_X1%4_9 0.203571
C_x_PM_OAI211_X1%ZN_c0 VSS x_PM_OAI211_X1%ZN_22 2.18375e-18
C_x_PM_OAI211_X1%ZN_c1 VSS N_ZN_M3_d 2.67712e-17
C_x_PM_OAI211_X1%ZN_c2 VSS x_PM_OAI211_X1%ZN_16 3.69353e-17
C_x_PM_OAI211_X1%ZN_c3 VSS N_ZN_M1_d 3.05135e-17
C_x_PM_OAI211_X1%ZN_c4 VSS x_PM_OAI211_X1%ZN_11 1.24155e-17
C_x_PM_OAI211_X1%ZN_c5 VSS x_PM_OAI211_X1%ZN_10 1.25191e-17
C_x_PM_OAI211_X1%ZN_c6 VSS N_ZN_M4_d 1.54062e-16
R_x_PM_OAI211_X1%ZN_r7 N_ZN_M3_d x_PM_OAI211_X1%ZN_18 0.393571
R_x_PM_OAI211_X1%ZN_r8 x_PM_OAI211_X1%ZN_22 x_PM_OAI211_X1%ZN_17 0.160909
R_x_PM_OAI211_X1%ZN_r9 x_PM_OAI211_X1%ZN_18 x_PM_OAI211_X1%ZN_16 0.212317
R_x_PM_OAI211_X1%ZN_r10 x_PM_OAI211_X1%ZN_17 x_PM_OAI211_X1%ZN_16 1.65571
R_x_PM_OAI211_X1%ZN_r11 x_PM_OAI211_X1%ZN_22 x_PM_OAI211_X1%ZN_12 0.0418175
R_x_PM_OAI211_X1%ZN_r12 N_ZN_M1_d x_PM_OAI211_X1%ZN_12 0.393571
R_x_PM_OAI211_X1%ZN_r13 x_PM_OAI211_X1%ZN_22 x_PM_OAI211_X1%ZN_10 0.160909
R_x_PM_OAI211_X1%ZN_r14 x_PM_OAI211_X1%ZN_11 x_PM_OAI211_X1%ZN_10 0.678571
R_x_PM_OAI211_X1%ZN_r15 ZN N_ZN_M4_d 2.49235
R_x_PM_OAI211_X1%ZN_r16 x_PM_OAI211_X1%ZN_11 x_PM_OAI211_X1%ZN_4 0.214913
R_x_PM_OAI211_X1%ZN_r17 ZN x_PM_OAI211_X1%ZN_4 0.581176
C_x_PM_OAI211_X1%C1_c0 VSS C1 5.98662e-17
C_x_PM_OAI211_X1%C1_c1 VSS x_PM_OAI211_X1%C1_11 1.0478e-17
C_x_PM_OAI211_X1%C1_c2 VSS N_C1_M1_g 8.30473e-17
C_x_PM_OAI211_X1%C1_c3 VSS N_C1_M5_g 3.23163e-17
R_x_PM_OAI211_X1%C1_r4 x_PM_OAI211_X1%C1_11 x_PM_OAI211_X1%C1_16 3.38
R_x_PM_OAI211_X1%C1_r5 x_PM_OAI211_X1%C1_11 x_PM_OAI211_X1%C1_9 25.0012
R_x_PM_OAI211_X1%C1_r6 C1 x_PM_OAI211_X1%C1_9 0.115357
R_x_PM_OAI211_X1%C1_r7 x_PM_OAI211_X1%C1_16 x_PM_OAI211_X1%C1_5 1.95
R_x_PM_OAI211_X1%C1_r8 N_C1_M1_g x_PM_OAI211_X1%C1_5 101.79
R_x_PM_OAI211_X1%C1_r9 x_PM_OAI211_X1%C1_16 x_PM_OAI211_X1%C1_VSS 1.95
R_x_PM_OAI211_X1%C1_r10 N_C1_M5_g x_PM_OAI211_X1%C1_VSS 23.4
C_x_PM_OAI211_X1%A_c0 VSS x_PM_OAI211_X1%A_16 5.16146e-17
C_x_PM_OAI211_X1%A_c1 VSS x_PM_OAI211_X1%A_14 9.16587e-18
C_x_PM_OAI211_X1%A_c2 VSS x_PM_OAI211_X1%A_9 1.99586e-17
C_x_PM_OAI211_X1%A_c3 VSS N_A_M2_g 8.20297e-17
C_x_PM_OAI211_X1%A_c4 VSS N_A_M6_g 2.88014e-17
R_x_PM_OAI211_X1%A_r5 x_PM_OAI211_X1%A_20 x_PM_OAI211_X1%A_14 4.74714
R_x_PM_OAI211_X1%A_r6 x_PM_OAI211_X1%A_19 x_PM_OAI211_X1%A_14 4.74714
R_x_PM_OAI211_X1%A_r7 x_PM_OAI211_X1%A_14 x_PM_OAI211_X1%A_12 25.0012
R_x_PM_OAI211_X1%A_r8 x_PM_OAI211_X1%A_16 x_PM_OAI211_X1%A_12 0.161852
R_x_PM_OAI211_X1%A_r9 x_PM_OAI211_X1%A_16 x_PM_OAI211_X1%A_9 0.095
R_x_PM_OAI211_X1%A_r10 A x_PM_OAI211_X1%A_9 0.325714
R_x_PM_OAI211_X1%A_r11 N_A_M2_g x_PM_OAI211_X1%A_20 108.81
R_x_PM_OAI211_X1%A_r12 N_A_M6_g x_PM_OAI211_X1%A_19 21.06
C_x_PM_OAI211_X1%B_c0 VSS B 3.77842e-17
C_x_PM_OAI211_X1%B_c1 VSS x_PM_OAI211_X1%B_11 7.2433e-18
C_x_PM_OAI211_X1%B_c2 VSS N_B_M3_g 7.80101e-17
C_x_PM_OAI211_X1%B_c3 VSS N_B_M7_g 3.15986e-17
R_x_PM_OAI211_X1%B_r4 x_PM_OAI211_X1%B_18 x_PM_OAI211_X1%B_11 4.74714
R_x_PM_OAI211_X1%B_r5 x_PM_OAI211_X1%B_17 x_PM_OAI211_X1%B_11 4.74714
R_x_PM_OAI211_X1%B_r6 x_PM_OAI211_X1%B_11 x_PM_OAI211_X1%B_9 25.0012
R_x_PM_OAI211_X1%B_r7 B x_PM_OAI211_X1%B_9 0.156071
R_x_PM_OAI211_X1%B_r8 N_B_M3_g x_PM_OAI211_X1%B_18 107.25
R_x_PM_OAI211_X1%B_r9 N_B_M7_g x_PM_OAI211_X1%B_17 22.62
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X2 VSS VDD C2 ZN C1 A B
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I A:I B:I
M_M4 noxref_9 N_C2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_ZN_M1_d N_C1_M1_g noxref_9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M7 N_ZN_M3_d N_B_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_ZN_M4_d N_C2_M4_g N_3_M4_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_3_M5_d N_C1_M5_g N_ZN_M4_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 noxref_10 N_A_M6_g N_3_M5_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_VSS_M7_d N_B_M7_g noxref_10 VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI211_X2%VSS_c0 VSS N_VSS_M7_d 1.96106e-17
C_x_PM_OAI211_X2%VSS_c1 VSS x_PM_OAI211_X2%VSS_2 1.69952e-16
R_x_PM_OAI211_X2%VSS_r2 N_VSS_M7_d x_PM_OAI211_X2%VSS_6 0.230714
R_x_PM_OAI211_X2%VSS_r3 x_PM_OAI211_X2%VSS_6 x_PM_OAI211_X2%VSS_2 0.264221
R_x_PM_OAI211_X2%VSS_r4 VSS x_PM_OAI211_X2%VSS_2 0.782353
C_x_PM_OAI211_X2%VDD_c0 VSS x_PM_OAI211_X2%VDD_20 3.3675e-17
C_x_PM_OAI211_X2%VDD_c1 VSS VDD 1.29186e-17
C_x_PM_OAI211_X2%VDD_c2 VSS N_VDD_M2_d 6.27492e-17
C_x_PM_OAI211_X2%VDD_c3 VSS x_PM_OAI211_X2%VDD_7 4.11049e-17
C_x_PM_OAI211_X2%VDD_c4 VSS N_VDD_M0_s 2.43654e-17
R_x_PM_OAI211_X2%VDD_r5 x_PM_OAI211_X2%VDD_18 VDD 0.217143
R_x_PM_OAI211_X2%VDD_r6 x_PM_OAI211_X2%VDD_17 VDD 0.108508
R_x_PM_OAI211_X2%VDD_r7 x_PM_OAI211_X2%VDD_20 x_PM_OAI211_X2%VDD_9 0.145286
R_x_PM_OAI211_X2%VDD_r8 N_VDD_M2_d x_PM_OAI211_X2%VDD_9 0.556429
R_x_PM_OAI211_X2%VDD_r9 x_PM_OAI211_X2%VDD_18 x_PM_OAI211_X2%VDD_8 0.095
R_x_PM_OAI211_X2%VDD_r10 x_PM_OAI211_X2%VDD_20 x_PM_OAI211_X2%VDD_7 0.0731438
R_x_PM_OAI211_X2%VDD_r11 x_PM_OAI211_X2%VDD_8 x_PM_OAI211_X2%VDD_7 1.10647
R_x_PM_OAI211_X2%VDD_r12 N_VDD_M0_s x_PM_OAI211_X2%VDD_17 0.556429
C_x_PM_OAI211_X2%3_c0 VSS x_PM_OAI211_X2%3_3 1.16491e-16
C_x_PM_OAI211_X2%3_c1 VSS N_3_M5_d 3.13481e-17
R_x_PM_OAI211_X2%3_r2 x_PM_OAI211_X2%3_7 x_PM_OAI211_X2%3_3 0.212317
R_x_PM_OAI211_X2%3_r3 N_3_M4_s x_PM_OAI211_X2%3_3 1.83214
R_x_PM_OAI211_X2%3_r4 N_3_M5_d x_PM_OAI211_X2%3_7 0.746429
C_x_PM_OAI211_X2%C2_c0 VSS x_PM_OAI211_X2%C2_18 9.19337e-18
C_x_PM_OAI211_X2%C2_c1 VSS x_PM_OAI211_X2%C2_12 4.54929e-17
C_x_PM_OAI211_X2%C2_c2 VSS N_C2_M0_g 7.37023e-17
C_x_PM_OAI211_X2%C2_c3 VSS N_C2_M4_g 4.48079e-17
R_x_PM_OAI211_X2%C2_r4 x_PM_OAI211_X2%C2_18 x_PM_OAI211_X2%C2_14 4.94
R_x_PM_OAI211_X2%C2_r5 x_PM_OAI211_X2%C2_14 x_PM_OAI211_X2%C2_12 25.0012
R_x_PM_OAI211_X2%C2_r6 x_PM_OAI211_X2%C2_12 C2 0.128529
R_x_PM_OAI211_X2%C2_r7 x_PM_OAI211_X2%C2_18 x_PM_OAI211_X2%C2_5 1.95
R_x_PM_OAI211_X2%C2_r8 N_C2_M0_g x_PM_OAI211_X2%C2_5 77.22
R_x_PM_OAI211_X2%C2_r9 x_PM_OAI211_X2%C2_18 x_PM_OAI211_X2%C2_VSS 1.95
R_x_PM_OAI211_X2%C2_r10 N_C2_M4_g x_PM_OAI211_X2%C2_VSS 35.1
C_x_PM_OAI211_X2%ZN_c0 VSS x_PM_OAI211_X2%ZN_22 4.93936e-18
C_x_PM_OAI211_X2%ZN_c1 VSS N_ZN_M3_d 3.91988e-17
C_x_PM_OAI211_X2%ZN_c2 VSS x_PM_OAI211_X2%ZN_16 3.96734e-17
C_x_PM_OAI211_X2%ZN_c3 VSS N_ZN_M1_d 4.5314e-17
C_x_PM_OAI211_X2%ZN_c4 VSS x_PM_OAI211_X2%ZN_11 9.31818e-18
C_x_PM_OAI211_X2%ZN_c5 VSS x_PM_OAI211_X2%ZN_10 1.18857e-17
C_x_PM_OAI211_X2%ZN_c6 VSS N_ZN_M4_d 1.12275e-16
R_x_PM_OAI211_X2%ZN_r7 N_ZN_M3_d x_PM_OAI211_X2%ZN_18 1.18071
R_x_PM_OAI211_X2%ZN_r8 x_PM_OAI211_X2%ZN_22 x_PM_OAI211_X2%ZN_17 0.160909
R_x_PM_OAI211_X2%ZN_r9 x_PM_OAI211_X2%ZN_18 x_PM_OAI211_X2%ZN_16 0.212317
R_x_PM_OAI211_X2%ZN_r10 x_PM_OAI211_X2%ZN_17 x_PM_OAI211_X2%ZN_16 1.68286
R_x_PM_OAI211_X2%ZN_r11 x_PM_OAI211_X2%ZN_22 x_PM_OAI211_X2%ZN_12 0.0418175
R_x_PM_OAI211_X2%ZN_r12 N_ZN_M1_d x_PM_OAI211_X2%ZN_12 1.18071
R_x_PM_OAI211_X2%ZN_r13 x_PM_OAI211_X2%ZN_22 x_PM_OAI211_X2%ZN_10 0.160909
R_x_PM_OAI211_X2%ZN_r14 x_PM_OAI211_X2%ZN_11 x_PM_OAI211_X2%ZN_10 0.651429
R_x_PM_OAI211_X2%ZN_r15 ZN N_ZN_M4_d 1.91267
R_x_PM_OAI211_X2%ZN_r16 x_PM_OAI211_X2%ZN_11 x_PM_OAI211_X2%ZN_4 0.212645
R_x_PM_OAI211_X2%ZN_r17 ZN x_PM_OAI211_X2%ZN_4 0.506667
C_x_PM_OAI211_X2%C1_c0 VSS C1 5.0824e-17
C_x_PM_OAI211_X2%C1_c1 VSS x_PM_OAI211_X2%C1_11 1.06008e-17
C_x_PM_OAI211_X2%C1_c2 VSS N_C1_M1_g 6.81886e-17
C_x_PM_OAI211_X2%C1_c3 VSS N_C1_M5_g 5.98522e-17
R_x_PM_OAI211_X2%C1_r4 x_PM_OAI211_X2%C1_11 x_PM_OAI211_X2%C1_16 3.38
R_x_PM_OAI211_X2%C1_r5 x_PM_OAI211_X2%C1_11 x_PM_OAI211_X2%C1_9 25.0012
R_x_PM_OAI211_X2%C1_r6 C1 x_PM_OAI211_X2%C1_9 0.1425
R_x_PM_OAI211_X2%C1_r7 x_PM_OAI211_X2%C1_16 x_PM_OAI211_X2%C1_5 1.95
R_x_PM_OAI211_X2%C1_r8 N_C1_M1_g x_PM_OAI211_X2%C1_5 60.84
R_x_PM_OAI211_X2%C1_r9 x_PM_OAI211_X2%C1_16 x_PM_OAI211_X2%C1_VSS 1.95
R_x_PM_OAI211_X2%C1_r10 N_C1_M5_g x_PM_OAI211_X2%C1_VSS 51.48
C_x_PM_OAI211_X2%A_c0 VSS x_PM_OAI211_X2%A_11 9.72005e-18
C_x_PM_OAI211_X2%A_c1 VSS x_PM_OAI211_X2%A_9 4.96045e-17
C_x_PM_OAI211_X2%A_c2 VSS N_A_M2_g 7.65583e-17
C_x_PM_OAI211_X2%A_c3 VSS N_A_M6_g 4.59382e-17
R_x_PM_OAI211_X2%A_r4 x_PM_OAI211_X2%A_11 x_PM_OAI211_X2%A_14 2.86
R_x_PM_OAI211_X2%A_r5 x_PM_OAI211_X2%A_11 x_PM_OAI211_X2%A_9 25.0012
R_x_PM_OAI211_X2%A_r6 A x_PM_OAI211_X2%A_9 0.141332
R_x_PM_OAI211_X2%A_r7 x_PM_OAI211_X2%A_14 x_PM_OAI211_X2%A_5 1.95
R_x_PM_OAI211_X2%A_r8 N_A_M2_g x_PM_OAI211_X2%A_5 86.58
R_x_PM_OAI211_X2%A_r9 x_PM_OAI211_X2%A_14 x_PM_OAI211_X2%A_VSS 1.95
R_x_PM_OAI211_X2%A_r10 N_A_M6_g x_PM_OAI211_X2%A_VSS 35.1
C_x_PM_OAI211_X2%B_c0 VSS B 6.13771e-17
C_x_PM_OAI211_X2%B_c1 VSS x_PM_OAI211_X2%B_11 8.16651e-18
C_x_PM_OAI211_X2%B_c2 VSS N_B_M3_g 7.81574e-17
C_x_PM_OAI211_X2%B_c3 VSS N_B_M7_g 4.18853e-17
R_x_PM_OAI211_X2%B_r4 x_PM_OAI211_X2%B_11 x_PM_OAI211_X2%B_16 2.86
R_x_PM_OAI211_X2%B_r5 x_PM_OAI211_X2%B_11 x_PM_OAI211_X2%B_9 25.0012
R_x_PM_OAI211_X2%B_r6 B x_PM_OAI211_X2%B_9 0.0704839
R_x_PM_OAI211_X2%B_r7 x_PM_OAI211_X2%B_16 x_PM_OAI211_X2%B_5 1.95
R_x_PM_OAI211_X2%B_r8 N_B_M3_g x_PM_OAI211_X2%B_5 86.58
R_x_PM_OAI211_X2%B_r9 x_PM_OAI211_X2%B_16 x_PM_OAI211_X2%B_VSS 1.95
R_x_PM_OAI211_X2%B_r10 N_B_M7_g x_PM_OAI211_X2%B_VSS 35.1
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI211_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI211_X4 VSS VDD C2 ZN C1 A B
*.PININFO VSS:B VDD:B C2:I ZN:O C1:I A:I B:I
M_M8 9 N_C2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_ZN_M1_d N_C1_M1_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 10 N_C1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_VDD_M3_d N_C2_M3_g 10 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M12 N_ZN_M4_d N_A_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M13 N_VDD_M5_d N_B_M5_g N_ZN_M4_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_ZN_M6_d N_C2_M6_g N_3_M6_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_3_M7_d N_C1_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_ZN_M8_d N_C1_M8_g N_3_M7_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_3_M9_d N_C2_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 noxref_11 N_A_M10_g N_3_M9_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M5 N_VSS_M11_d N_B_M11_g noxref_11 VSS NMOS_VTL W=0.340000U L=0.050000U
M_M6 noxref_12 N_B_M12_g N_VSS_M11_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M7 N_3_M13_d N_A_M13_g noxref_12 VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI211_X4%VSS_c0 VSS x_PM_OAI211_X4%VSS_12 5.74094e-17
C_x_PM_OAI211_X4%VSS_c1 VSS N_VSS_M11_d 2.84958e-17
C_x_PM_OAI211_X4%VSS_c2 VSS x_PM_OAI211_X4%VSS_2 2.56685e-16
R_x_PM_OAI211_X4%VSS_r3 x_PM_OAI211_X4%VSS_12 x_PM_OAI211_X4%VSS_6 0.145286
R_x_PM_OAI211_X4%VSS_r4 N_VSS_M11_d x_PM_OAI211_X4%VSS_6 0.230714
R_x_PM_OAI211_X4%VSS_r5 x_PM_OAI211_X4%VSS_12 x_PM_OAI211_X4%VSS_2 0.0731438
R_x_PM_OAI211_X4%VSS_r6 VSS x_PM_OAI211_X4%VSS_2 0.748824
C_x_PM_OAI211_X4%VDD_c0 VSS x_PM_OAI211_X4%VDD_25 3.90429e-17
C_x_PM_OAI211_X4%VDD_c1 VSS x_PM_OAI211_X4%VDD_24 2.64443e-18
C_x_PM_OAI211_X4%VDD_c2 VSS N_VDD_M5_d 2.73622e-17
C_x_PM_OAI211_X4%VDD_c3 VSS x_PM_OAI211_X4%VDD_16 4.14514e-17
C_x_PM_OAI211_X4%VDD_c4 VSS N_VDD_M3_d 2.09451e-17
C_x_PM_OAI211_X4%VDD_c5 VSS x_PM_OAI211_X4%VDD_9 1.1514e-17
C_x_PM_OAI211_X4%VDD_c6 VSS x_PM_OAI211_X4%VDD_8 6.91501e-17
C_x_PM_OAI211_X4%VDD_c7 VSS N_VDD_M0_s 2.0218e-17
R_x_PM_OAI211_X4%VDD_r8 x_PM_OAI211_X4%VDD_25 x_PM_OAI211_X4%VDD_18 0.145286
R_x_PM_OAI211_X4%VDD_r9 N_VDD_M5_d x_PM_OAI211_X4%VDD_18 0.230714
R_x_PM_OAI211_X4%VDD_r10 x_PM_OAI211_X4%VDD_24 x_PM_OAI211_X4%VDD_17 0.0731438
R_x_PM_OAI211_X4%VDD_r11 x_PM_OAI211_X4%VDD_25 x_PM_OAI211_X4%VDD_16 0.0731438
R_x_PM_OAI211_X4%VDD_r12 x_PM_OAI211_X4%VDD_17 x_PM_OAI211_X4%VDD_16 0.681765
R_x_PM_OAI211_X4%VDD_r13 VDD N_VDD_M3_d 0.0135714
R_x_PM_OAI211_X4%VDD_r14 x_PM_OAI211_X4%VDD_24 x_PM_OAI211_X4%VDD_10 0.145286
R_x_PM_OAI211_X4%VDD_r15 VDD x_PM_OAI211_X4%VDD_10 0.217143
R_x_PM_OAI211_X4%VDD_r16 x_PM_OAI211_X4%VDD_24 x_PM_OAI211_X4%VDD_8 0.0731438
R_x_PM_OAI211_X4%VDD_r17 x_PM_OAI211_X4%VDD_9 x_PM_OAI211_X4%VDD_8 1.55353
R_x_PM_OAI211_X4%VDD_r18 x_PM_OAI211_X4%VDD_9 x_PM_OAI211_X4%VDD_4 0.264221
R_x_PM_OAI211_X4%VDD_r19 N_VDD_M0_s x_PM_OAI211_X4%VDD_4 0.230714
C_x_PM_OAI211_X4%3_c0 VSS x_PM_OAI211_X4%3_17 3.96586e-17
C_x_PM_OAI211_X4%3_c1 VSS x_PM_OAI211_X4%3_10 1.78497e-17
C_x_PM_OAI211_X4%3_c2 VSS x_PM_OAI211_X4%3_9 1.68526e-16
C_x_PM_OAI211_X4%3_c3 VSS N_3_M6_s 2.32036e-17
C_x_PM_OAI211_X4%3_c4 VSS N_3_M13_d 1.71543e-16
R_x_PM_OAI211_X4%3_r5 x_PM_OAI211_X4%3_21 N_3_M9_d 0.176429
R_x_PM_OAI211_X4%3_r6 N_3_M9_d x_PM_OAI211_X4%3_17 0.420714
R_x_PM_OAI211_X4%3_r7 x_PM_OAI211_X4%3_21 x_PM_OAI211_X4%3_13 0.095
R_x_PM_OAI211_X4%3_r8 N_3_M7_d x_PM_OAI211_X4%3_10 1.85929
R_x_PM_OAI211_X4%3_r9 x_PM_OAI211_X4%3_17 x_PM_OAI211_X4%3_9 0.095
R_x_PM_OAI211_X4%3_r10 N_3_M7_d x_PM_OAI211_X4%3_9 1.83214
R_x_PM_OAI211_X4%3_r11 x_PM_OAI211_X4%3_10 x_PM_OAI211_X4%3_5 0.212317
R_x_PM_OAI211_X4%3_r12 N_3_M6_s x_PM_OAI211_X4%3_5 0.746429
R_x_PM_OAI211_X4%3_r13 N_3_M13_d x_PM_OAI211_X4%3_13 3.97643
C_x_PM_OAI211_X4%C2_c0 VSS x_PM_OAI211_X4%C2_35 1.25879e-17
C_x_PM_OAI211_X4%C2_c1 VSS x_PM_OAI211_X4%C2_22 5.08974e-17
C_x_PM_OAI211_X4%C2_c2 VSS x_PM_OAI211_X4%C2_20 6.36402e-18
C_x_PM_OAI211_X4%C2_c3 VSS x_PM_OAI211_X4%C2_17 8.61406e-17
C_x_PM_OAI211_X4%C2_c4 VSS N_C2_M3_g 7.2358e-17
C_x_PM_OAI211_X4%C2_c5 VSS N_C2_M9_g 6.247e-17
C_x_PM_OAI211_X4%C2_c6 VSS N_C2_M0_g 7.23563e-17
C_x_PM_OAI211_X4%C2_c7 VSS N_C2_M6_g 5.73515e-17
R_x_PM_OAI211_X4%C2_r8 x_PM_OAI211_X4%C2_35 x_PM_OAI211_X4%C2_28 5.46
R_x_PM_OAI211_X4%C2_r9 x_PM_OAI211_X4%C2_28 x_PM_OAI211_X4%C2_26 25.0012
R_x_PM_OAI211_X4%C2_r10 x_PM_OAI211_X4%C2_26 C2 0.0095
R_x_PM_OAI211_X4%C2_r11 C2 x_PM_OAI211_X4%C2_22 0.133
R_x_PM_OAI211_X4%C2_r12 x_PM_OAI211_X4%C2_32 x_PM_OAI211_X4%C2_20 4.7687
R_x_PM_OAI211_X4%C2_r13 x_PM_OAI211_X4%C2_31 x_PM_OAI211_X4%C2_20 4.7687
R_x_PM_OAI211_X4%C2_r14 x_PM_OAI211_X4%C2_20 x_PM_OAI211_X4%C2_18 25.0012
R_x_PM_OAI211_X4%C2_r15 x_PM_OAI211_X4%C2_22 x_PM_OAI211_X4%C2_17 0.095
R_x_PM_OAI211_X4%C2_r16 x_PM_OAI211_X4%C2_18 x_PM_OAI211_X4%C2_17 2.51071
R_x_PM_OAI211_X4%C2_r17 x_PM_OAI211_X4%C2_35 x_PM_OAI211_X4%C2_13 1.95
R_x_PM_OAI211_X4%C2_r18 N_C2_M3_g x_PM_OAI211_X4%C2_13 69.42
R_x_PM_OAI211_X4%C2_r19 x_PM_OAI211_X4%C2_35 x_PM_OAI211_X4%C2_9 1.95
R_x_PM_OAI211_X4%C2_r20 N_C2_M9_g x_PM_OAI211_X4%C2_9 52.26
R_x_PM_OAI211_X4%C2_r21 N_C2_M0_g x_PM_OAI211_X4%C2_32 75.66
R_x_PM_OAI211_X4%C2_r22 N_C2_M6_g x_PM_OAI211_X4%C2_31 46.02
C_x_PM_OAI211_X4%ZN_c0 VSS x_PM_OAI211_X4%ZN_26 4.80552e-17
C_x_PM_OAI211_X4%ZN_c1 VSS x_PM_OAI211_X4%ZN_23 4.26576e-17
C_x_PM_OAI211_X4%ZN_c2 VSS N_ZN_M4_d 3.48712e-17
C_x_PM_OAI211_X4%ZN_c3 VSS x_PM_OAI211_X4%ZN_16 7.95941e-17
C_x_PM_OAI211_X4%ZN_c4 VSS x_PM_OAI211_X4%ZN_5 1.60076e-16
R_x_PM_OAI211_X4%ZN_r5 x_PM_OAI211_X4%ZN_26 ZN 0.471724
R_x_PM_OAI211_X4%ZN_r6 ZN x_PM_OAI211_X4%ZN_22 0.0655172
R_x_PM_OAI211_X4%ZN_r7 x_PM_OAI211_X4%ZN_23 x_PM_OAI211_X4%ZN_22 0.193709
R_x_PM_OAI211_X4%ZN_r8 x_PM_OAI211_X4%ZN_26 x_PM_OAI211_X4%ZN_17 0.095
R_x_PM_OAI211_X4%ZN_r9 N_ZN_M4_d x_PM_OAI211_X4%ZN_17 0.339286
R_x_PM_OAI211_X4%ZN_r10 x_PM_OAI211_X4%ZN_22 x_PM_OAI211_X4%ZN_16 0.095
R_x_PM_OAI211_X4%ZN_r11 x_PM_OAI211_X4%ZN_21 x_PM_OAI211_X4%ZN_15 0.125472
R_x_PM_OAI211_X4%ZN_r12 x_PM_OAI211_X4%ZN_16 x_PM_OAI211_X4%ZN_15 2.76857
R_x_PM_OAI211_X4%ZN_r13 N_ZN_M1_d x_PM_OAI211_X4%ZN_23 1.77786
R_x_PM_OAI211_X4%ZN_r14 N_ZN_M8_d N_ZN_M6_d 1.37524
R_x_PM_OAI211_X4%ZN_r15 x_PM_OAI211_X4%ZN_21 x_PM_OAI211_X4%ZN_5 0.593312
R_x_PM_OAI211_X4%ZN_r16 N_ZN_M8_d x_PM_OAI211_X4%ZN_5 0.0542857
C_x_PM_OAI211_X4%C1_c0 VSS x_PM_OAI211_X4%C1_25 5.53686e-18
C_x_PM_OAI211_X4%C1_c1 VSS x_PM_OAI211_X4%C1_23 3.78894e-17
C_x_PM_OAI211_X4%C1_c2 VSS x_PM_OAI211_X4%C1_19 4.36208e-18
C_x_PM_OAI211_X4%C1_c3 VSS N_C1_M2_g 4.44356e-17
C_x_PM_OAI211_X4%C1_c4 VSS N_C1_M8_g 6.33637e-17
C_x_PM_OAI211_X4%C1_c5 VSS x_PM_OAI211_X4%C1_9 7.81248e-18
C_x_PM_OAI211_X4%C1_c6 VSS N_C1_M1_g 4.00337e-17
C_x_PM_OAI211_X4%C1_c7 VSS N_C1_M7_g 6.2268e-17
R_x_PM_OAI211_X4%C1_r8 x_PM_OAI211_X4%C1_25 x_PM_OAI211_X4%C1_23 25.0012
R_x_PM_OAI211_X4%C1_r9 x_PM_OAI211_X4%C1_23 C1 0.196786
R_x_PM_OAI211_X4%C1_r10 x_PM_OAI211_X4%C1_19 x_PM_OAI211_X4%C1_15 4.56151
R_x_PM_OAI211_X4%C1_r11 N_C1_M2_g x_PM_OAI211_X4%C1_15 48.36
R_x_PM_OAI211_X4%C1_r12 x_PM_OAI211_X4%C1_19 x_PM_OAI211_X4%C1_11 4.56151
R_x_PM_OAI211_X4%C1_r13 N_C1_M8_g x_PM_OAI211_X4%C1_11 73.32
R_x_PM_OAI211_X4%C1_r14 x_PM_OAI211_X4%C1_25 x_PM_OAI211_X4%C1_10 0.043368
R_x_PM_OAI211_X4%C1_r15 x_PM_OAI211_X4%C1_19 x_PM_OAI211_X4%C1_9 0.043368
R_x_PM_OAI211_X4%C1_r16 x_PM_OAI211_X4%C1_10 x_PM_OAI211_X4%C1_9 14.56
R_x_PM_OAI211_X4%C1_r17 x_PM_OAI211_X4%C1_25 x_PM_OAI211_X4%C1_5 4.56151
R_x_PM_OAI211_X4%C1_r18 N_C1_M1_g x_PM_OAI211_X4%C1_5 48.36
R_x_PM_OAI211_X4%C1_r19 x_PM_OAI211_X4%C1_25 x_PM_OAI211_X4%C1_VSS 4.56151
R_x_PM_OAI211_X4%C1_r20 N_C1_M7_g x_PM_OAI211_X4%C1_VSS 73.32
C_x_PM_OAI211_X4%A_c0 VSS x_PM_OAI211_X4%A_25 8.53507e-18
C_x_PM_OAI211_X4%A_c1 VSS x_PM_OAI211_X4%A_23 7.16423e-18
C_x_PM_OAI211_X4%A_c2 VSS x_PM_OAI211_X4%A_21 3.39552e-17
C_x_PM_OAI211_X4%A_c3 VSS x_PM_OAI211_X4%A_20 1.21011e-16
C_x_PM_OAI211_X4%A_c4 VSS x_PM_OAI211_X4%A_18 1.25828e-17
C_x_PM_OAI211_X4%A_c5 VSS A 2.85281e-17
C_x_PM_OAI211_X4%A_c6 VSS N_A_M13_g 4.27121e-17
C_x_PM_OAI211_X4%A_c7 VSS N_A_M4_g 8.47541e-17
C_x_PM_OAI211_X4%A_c8 VSS N_A_M10_g 4.85895e-17
R_x_PM_OAI211_X4%A_r9 x_PM_OAI211_X4%A_32 x_PM_OAI211_X4%A_25 4.7687
R_x_PM_OAI211_X4%A_r10 x_PM_OAI211_X4%A_25 x_PM_OAI211_X4%A_23 25.0012
R_x_PM_OAI211_X4%A_r11 x_PM_OAI211_X4%A_23 x_PM_OAI211_X4%A_22 0.312143
R_x_PM_OAI211_X4%A_r12 x_PM_OAI211_X4%A_22 x_PM_OAI211_X4%A_20 0.212317
R_x_PM_OAI211_X4%A_r13 x_PM_OAI211_X4%A_21 x_PM_OAI211_X4%A_20 2.22571
R_x_PM_OAI211_X4%A_r14 x_PM_OAI211_X4%A_18 x_PM_OAI211_X4%A_27 5.46
R_x_PM_OAI211_X4%A_r15 x_PM_OAI211_X4%A_18 x_PM_OAI211_X4%A_16 25.0012
R_x_PM_OAI211_X4%A_r16 x_PM_OAI211_X4%A_16 A 0.107391
R_x_PM_OAI211_X4%A_r17 x_PM_OAI211_X4%A_21 x_PM_OAI211_X4%A_13 0.229077
R_x_PM_OAI211_X4%A_r18 A x_PM_OAI211_X4%A_13 0.0826087
R_x_PM_OAI211_X4%A_r19 N_A_M13_g x_PM_OAI211_X4%A_32 35.1
R_x_PM_OAI211_X4%A_r20 x_PM_OAI211_X4%A_27 x_PM_OAI211_X4%A_5 1.95
R_x_PM_OAI211_X4%A_r21 N_A_M4_g x_PM_OAI211_X4%A_5 74.88
R_x_PM_OAI211_X4%A_r22 x_PM_OAI211_X4%A_27 x_PM_OAI211_X4%A_VSS 1.95
R_x_PM_OAI211_X4%A_r23 N_A_M10_g x_PM_OAI211_X4%A_VSS 35.1
C_x_PM_OAI211_X4%B_c0 VSS B 4.61971e-17
C_x_PM_OAI211_X4%B_c1 VSS x_PM_OAI211_X4%B_15 1.37191e-17
C_x_PM_OAI211_X4%B_c2 VSS x_PM_OAI211_X4%B_14 4.53489e-18
C_x_PM_OAI211_X4%B_c3 VSS N_B_M12_g 4.65819e-17
C_x_PM_OAI211_X4%B_c4 VSS N_B_M5_g 7.2295e-17
C_x_PM_OAI211_X4%B_c5 VSS N_B_M11_g 4.78533e-17
R_x_PM_OAI211_X4%B_r6 x_PM_OAI211_X4%B_18 x_PM_OAI211_X4%B_16 25.0012
R_x_PM_OAI211_X4%B_r7 B x_PM_OAI211_X4%B_16 0.128529
R_x_PM_OAI211_X4%B_r8 x_PM_OAI211_X4%B_18 x_PM_OAI211_X4%B_15 12.74
R_x_PM_OAI211_X4%B_r9 x_PM_OAI211_X4%B_18 x_PM_OAI211_X4%B_13 1.82
R_x_PM_OAI211_X4%B_r10 x_PM_OAI211_X4%B_14 x_PM_OAI211_X4%B_13 0.043368
R_x_PM_OAI211_X4%B_r11 x_PM_OAI211_X4%B_15 x_PM_OAI211_X4%B_9 4.58872
R_x_PM_OAI211_X4%B_r12 N_B_M12_g x_PM_OAI211_X4%B_9 46.8
R_x_PM_OAI211_X4%B_r13 x_PM_OAI211_X4%B_14 x_PM_OAI211_X4%B_5 4.56151
R_x_PM_OAI211_X4%B_r14 N_B_M5_g x_PM_OAI211_X4%B_5 63.18
R_x_PM_OAI211_X4%B_r15 x_PM_OAI211_X4%B_14 x_PM_OAI211_X4%B_VSS 4.56151
R_x_PM_OAI211_X4%B_r16 N_B_M11_g x_PM_OAI211_X4%B_VSS 46.8
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X1 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B B2:I ZN:O B1:I A:I
M_M3 noxref_8 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M4 N_ZN_M1_d N_B1_M1_g noxref_8 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_ZN_M3_d N_B2_M3_g N_4_M3_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_4_M4_d N_B1_M4_g N_ZN_M3_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_VSS_M5_d N_A_M5_g N_4_M4_d VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_OAI21_X1%VSS_c0 VSS N_VSS_M5_d 3.07755e-17
C_x_PM_OAI21_X1%VSS_c1 VSS x_PM_OAI21_X1%VSS_2 1.37878e-16
R_x_PM_OAI21_X1%VSS_r2 N_VSS_M5_d x_PM_OAI21_X1%VSS_6 1.15357
R_x_PM_OAI21_X1%VSS_r3 x_PM_OAI21_X1%VSS_6 x_PM_OAI21_X1%VSS_2 0.264221
R_x_PM_OAI21_X1%VSS_r4 VSS x_PM_OAI21_X1%VSS_2 0.558824
C_x_PM_OAI21_X1%VDD_c0 VSS VDD 1.22485e-17
C_x_PM_OAI21_X1%VDD_c1 VSS N_VDD_M2_d 1.72784e-17
C_x_PM_OAI21_X1%VDD_c2 VSS x_PM_OAI21_X1%VDD_7 7.7773e-17
C_x_PM_OAI21_X1%VDD_c3 VSS N_VDD_M0_s 9.86768e-18
R_x_PM_OAI21_X1%VDD_r4 x_PM_OAI21_X1%VDD_16 VDD 0.225185
R_x_PM_OAI21_X1%VDD_r5 x_PM_OAI21_X1%VDD_15 VDD 0.101823
R_x_PM_OAI21_X1%VDD_r6 N_VDD_M2_d x_PM_OAI21_X1%VDD_9 0.556429
R_x_PM_OAI21_X1%VDD_r7 x_PM_OAI21_X1%VDD_16 x_PM_OAI21_X1%VDD_8 0.095
R_x_PM_OAI21_X1%VDD_r8 x_PM_OAI21_X1%VDD_9 x_PM_OAI21_X1%VDD_7 0.264221
R_x_PM_OAI21_X1%VDD_r9 x_PM_OAI21_X1%VDD_8 x_PM_OAI21_X1%VDD_7 1.10647
R_x_PM_OAI21_X1%VDD_r10 N_VDD_M0_s x_PM_OAI21_X1%VDD_15 0.230714
C_x_PM_OAI21_X1%B2_c0 VSS x_PM_OAI21_X1%B2_18 8.84191e-18
C_x_PM_OAI21_X1%B2_c1 VSS x_PM_OAI21_X1%B2_12 3.74924e-17
C_x_PM_OAI21_X1%B2_c2 VSS N_B2_M0_g 6.62282e-17
C_x_PM_OAI21_X1%B2_c3 VSS N_B2_M3_g 4.03532e-17
R_x_PM_OAI21_X1%B2_r4 x_PM_OAI21_X1%B2_18 x_PM_OAI21_X1%B2_14 4.42
R_x_PM_OAI21_X1%B2_r5 x_PM_OAI21_X1%B2_14 x_PM_OAI21_X1%B2_12 25.0012
R_x_PM_OAI21_X1%B2_r6 x_PM_OAI21_X1%B2_12 B2 0.156071
R_x_PM_OAI21_X1%B2_r7 x_PM_OAI21_X1%B2_18 x_PM_OAI21_X1%B2_5 1.95
R_x_PM_OAI21_X1%B2_r8 N_B2_M0_g x_PM_OAI21_X1%B2_5 84.63
R_x_PM_OAI21_X1%B2_r9 x_PM_OAI21_X1%B2_18 x_PM_OAI21_X1%B2_VSS 1.95
R_x_PM_OAI21_X1%B2_r10 N_B2_M3_g x_PM_OAI21_X1%B2_VSS 42.12
C_x_PM_OAI21_X1%4_c0 VSS x_PM_OAI21_X1%4_8 1.72248e-17
C_x_PM_OAI21_X1%4_c1 VSS x_PM_OAI21_X1%4_7 1.11356e-16
C_x_PM_OAI21_X1%4_c2 VSS N_4_M3_s 1.72772e-17
C_x_PM_OAI21_X1%4_c3 VSS N_4_M4_d 2.48288e-17
R_x_PM_OAI21_X1%4_r4 x_PM_OAI21_X1%4_9 x_PM_OAI21_X1%4_7 0.212317
R_x_PM_OAI21_X1%4_r5 x_PM_OAI21_X1%4_8 x_PM_OAI21_X1%4_7 1.62857
R_x_PM_OAI21_X1%4_r6 x_PM_OAI21_X1%4_8 x_PM_OAI21_X1%4_3 0.212317
R_x_PM_OAI21_X1%4_r7 N_4_M3_s x_PM_OAI21_X1%4_3 0.420714
R_x_PM_OAI21_X1%4_r8 N_4_M4_d x_PM_OAI21_X1%4_9 0.420714
C_x_PM_OAI21_X1%ZN_c0 VSS x_PM_OAI21_X1%ZN_10 6.95027e-17
C_x_PM_OAI21_X1%ZN_c1 VSS N_ZN_M3_d 1.49991e-16
R_x_PM_OAI21_X1%ZN_r2 x_PM_OAI21_X1%ZN_10 N_ZN_M1_d 0.375435
R_x_PM_OAI21_X1%ZN_r3 ZN N_ZN_M3_d 3.02643
R_x_PM_OAI21_X1%ZN_r4 x_PM_OAI21_X1%ZN_10 x_PM_OAI21_X1%ZN_3 0.241334
R_x_PM_OAI21_X1%ZN_r5 ZN x_PM_OAI21_X1%ZN_3 0.95
C_x_PM_OAI21_X1%B1_c0 VSS B1 4.2673e-17
C_x_PM_OAI21_X1%B1_c1 VSS x_PM_OAI21_X1%B1_11 1.02811e-17
C_x_PM_OAI21_X1%B1_c2 VSS N_B1_M1_g 7.46608e-17
C_x_PM_OAI21_X1%B1_c3 VSS N_B1_M4_g 3.95942e-17
R_x_PM_OAI21_X1%B1_r4 x_PM_OAI21_X1%B1_11 x_PM_OAI21_X1%B1_16 3.38
R_x_PM_OAI21_X1%B1_r5 x_PM_OAI21_X1%B1_11 x_PM_OAI21_X1%B1_9 25.0012
R_x_PM_OAI21_X1%B1_r6 B1 x_PM_OAI21_X1%B1_9 0.156071
R_x_PM_OAI21_X1%B1_r7 x_PM_OAI21_X1%B1_16 x_PM_OAI21_X1%B1_5 1.95
R_x_PM_OAI21_X1%B1_r8 N_B1_M1_g x_PM_OAI21_X1%B1_5 85.41
R_x_PM_OAI21_X1%B1_r9 x_PM_OAI21_X1%B1_16 x_PM_OAI21_X1%B1_VSS 1.95
R_x_PM_OAI21_X1%B1_r10 N_B1_M4_g x_PM_OAI21_X1%B1_VSS 41.34
C_x_PM_OAI21_X1%A_c0 VSS A 1.48771e-17
C_x_PM_OAI21_X1%A_c1 VSS x_PM_OAI21_X1%A_11 7.94985e-18
C_x_PM_OAI21_X1%A_c2 VSS N_A_M2_g 4.97768e-17
C_x_PM_OAI21_X1%A_c3 VSS N_A_M5_g 5.18832e-17
R_x_PM_OAI21_X1%A_r4 x_PM_OAI21_X1%A_11 x_PM_OAI21_X1%A_16 3.38
R_x_PM_OAI21_X1%A_r5 x_PM_OAI21_X1%A_11 x_PM_OAI21_X1%A_9 25.0012
R_x_PM_OAI21_X1%A_r6 A x_PM_OAI21_X1%A_9 0.156071
R_x_PM_OAI21_X1%A_r7 x_PM_OAI21_X1%A_16 x_PM_OAI21_X1%A_5 1.95
R_x_PM_OAI21_X1%A_r8 N_A_M2_g x_PM_OAI21_X1%A_5 58.89
R_x_PM_OAI21_X1%A_r9 x_PM_OAI21_X1%A_16 x_PM_OAI21_X1%A_VSS 1.95
R_x_PM_OAI21_X1%A_r10 N_A_M5_g x_PM_OAI21_X1%A_VSS 63.18
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X2 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B B2:I ZN:O B1:I A:I
M_M3 noxref_8 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M4 N_ZN_M1_d N_B1_M1_g noxref_8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_ZN_M3_d N_B2_M3_g N_3_M3_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_3_M4_d N_B1_M4_g N_ZN_M3_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_VSS_M5_d N_A_M5_g N_3_M4_d VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_OAI21_X2%VSS_c0 VSS N_VSS_M5_d 2.20348e-17
C_x_PM_OAI21_X2%VSS_c1 VSS x_PM_OAI21_X2%VSS_2 1.54775e-16
R_x_PM_OAI21_X2%VSS_r2 N_VSS_M5_d x_PM_OAI21_X2%VSS_6 0.447857
R_x_PM_OAI21_X2%VSS_r3 x_PM_OAI21_X2%VSS_6 x_PM_OAI21_X2%VSS_2 0.264221
R_x_PM_OAI21_X2%VSS_r4 VSS x_PM_OAI21_X2%VSS_2 0.558824
C_x_PM_OAI21_X2%VDD_c0 VSS VDD 1.24485e-17
C_x_PM_OAI21_X2%VDD_c1 VSS N_VDD_M2_d 3.14319e-17
C_x_PM_OAI21_X2%VDD_c2 VSS x_PM_OAI21_X2%VDD_7 6.1596e-17
C_x_PM_OAI21_X2%VDD_c3 VSS N_VDD_M0_s 2.3501e-17
R_x_PM_OAI21_X2%VDD_r4 x_PM_OAI21_X2%VDD_16 VDD 0.225185
R_x_PM_OAI21_X2%VDD_r5 x_PM_OAI21_X2%VDD_15 VDD 0.101823
R_x_PM_OAI21_X2%VDD_r6 N_VDD_M2_d x_PM_OAI21_X2%VDD_9 0.420714
R_x_PM_OAI21_X2%VDD_r7 x_PM_OAI21_X2%VDD_16 x_PM_OAI21_X2%VDD_8 0.095
R_x_PM_OAI21_X2%VDD_r8 x_PM_OAI21_X2%VDD_9 x_PM_OAI21_X2%VDD_7 0.264221
R_x_PM_OAI21_X2%VDD_r9 x_PM_OAI21_X2%VDD_8 x_PM_OAI21_X2%VDD_7 1.10647
R_x_PM_OAI21_X2%VDD_r10 N_VDD_M0_s x_PM_OAI21_X2%VDD_15 0.420714
C_x_PM_OAI21_X2%3_c0 VSS N_3_M4_d 1.36966e-16
R_x_PM_OAI21_X2%3_r1 N_3_M4_d N_3_M3_s 2.03571
C_x_PM_OAI21_X2%B2_c0 VSS x_PM_OAI21_X2%B2_18 8.8921e-18
C_x_PM_OAI21_X2%B2_c1 VSS x_PM_OAI21_X2%B2_12 3.8522e-17
C_x_PM_OAI21_X2%B2_c2 VSS N_B2_M0_g 7.84586e-17
C_x_PM_OAI21_X2%B2_c3 VSS N_B2_M3_g 3.85693e-17
R_x_PM_OAI21_X2%B2_r4 x_PM_OAI21_X2%B2_18 x_PM_OAI21_X2%B2_14 4.42
R_x_PM_OAI21_X2%B2_r5 x_PM_OAI21_X2%B2_14 x_PM_OAI21_X2%B2_12 25.0012
R_x_PM_OAI21_X2%B2_r6 x_PM_OAI21_X2%B2_12 B2 0.156071
R_x_PM_OAI21_X2%B2_r7 x_PM_OAI21_X2%B2_18 x_PM_OAI21_X2%B2_5 1.95
R_x_PM_OAI21_X2%B2_r8 N_B2_M0_g x_PM_OAI21_X2%B2_5 85.8
R_x_PM_OAI21_X2%B2_r9 x_PM_OAI21_X2%B2_18 x_PM_OAI21_X2%B2_VSS 1.95
R_x_PM_OAI21_X2%B2_r10 N_B2_M3_g x_PM_OAI21_X2%B2_VSS 30.42
C_x_PM_OAI21_X2%ZN_c0 VSS N_ZN_M1_d 4.25468e-17
C_x_PM_OAI21_X2%ZN_c1 VSS x_PM_OAI21_X2%ZN_10 9.63135e-18
C_x_PM_OAI21_X2%ZN_c2 VSS x_PM_OAI21_X2%ZN_9 1.9166e-17
C_x_PM_OAI21_X2%ZN_c3 VSS N_ZN_M3_d 1.33496e-16
R_x_PM_OAI21_X2%ZN_r4 N_ZN_M1_d x_PM_OAI21_X2%ZN_11 0.746429
R_x_PM_OAI21_X2%ZN_r5 x_PM_OAI21_X2%ZN_11 x_PM_OAI21_X2%ZN_9 0.212317
R_x_PM_OAI21_X2%ZN_r6 x_PM_OAI21_X2%ZN_10 x_PM_OAI21_X2%ZN_9 0.651429
R_x_PM_OAI21_X2%ZN_r7 ZN N_ZN_M3_d 3.02643
R_x_PM_OAI21_X2%ZN_r8 x_PM_OAI21_X2%ZN_10 x_PM_OAI21_X2%ZN_3 0.212317
R_x_PM_OAI21_X2%ZN_r9 ZN x_PM_OAI21_X2%ZN_3 0.352857
C_x_PM_OAI21_X2%B1_c0 VSS B1 6.15349e-17
C_x_PM_OAI21_X2%B1_c1 VSS x_PM_OAI21_X2%B1_11 1.04443e-17
C_x_PM_OAI21_X2%B1_c2 VSS N_B1_M1_g 8.33914e-17
C_x_PM_OAI21_X2%B1_c3 VSS N_B1_M4_g 4.15528e-17
R_x_PM_OAI21_X2%B1_r4 x_PM_OAI21_X2%B1_11 x_PM_OAI21_X2%B1_16 3.38
R_x_PM_OAI21_X2%B1_r5 x_PM_OAI21_X2%B1_11 x_PM_OAI21_X2%B1_9 25.0012
R_x_PM_OAI21_X2%B1_r6 B1 x_PM_OAI21_X2%B1_9 0.156071
R_x_PM_OAI21_X2%B1_r7 x_PM_OAI21_X2%B1_16 x_PM_OAI21_X2%B1_5 1.95
R_x_PM_OAI21_X2%B1_r8 N_B1_M1_g x_PM_OAI21_X2%B1_5 86.58
R_x_PM_OAI21_X2%B1_r9 x_PM_OAI21_X2%B1_16 x_PM_OAI21_X2%B1_VSS 1.95
R_x_PM_OAI21_X2%B1_r10 N_B1_M4_g x_PM_OAI21_X2%B1_VSS 29.64
C_x_PM_OAI21_X2%A_c0 VSS A 3.72975e-17
C_x_PM_OAI21_X2%A_c1 VSS x_PM_OAI21_X2%A_11 8.36959e-18
C_x_PM_OAI21_X2%A_c2 VSS N_A_M2_g 7.78115e-17
C_x_PM_OAI21_X2%A_c3 VSS N_A_M5_g 3.90983e-17
R_x_PM_OAI21_X2%A_r4 x_PM_OAI21_X2%A_11 x_PM_OAI21_X2%A_16 3.38
R_x_PM_OAI21_X2%A_r5 x_PM_OAI21_X2%A_11 x_PM_OAI21_X2%A_9 25.0012
R_x_PM_OAI21_X2%A_r6 A x_PM_OAI21_X2%A_9 0.156071
R_x_PM_OAI21_X2%A_r7 x_PM_OAI21_X2%A_16 x_PM_OAI21_X2%A_5 1.95
R_x_PM_OAI21_X2%A_r8 N_A_M2_g x_PM_OAI21_X2%A_5 95.16
R_x_PM_OAI21_X2%A_r9 x_PM_OAI21_X2%A_16 x_PM_OAI21_X2%A_VSS 1.95
R_x_PM_OAI21_X2%A_r10 N_A_M5_g x_PM_OAI21_X2%A_VSS 30.42
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI21_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI21_X4 VSS VDD B2 ZN B1 A
*.PININFO VSS:B VDD:B ZN:O B1:I B2:I A:I
M_M6 8 N_B1_M0_g N_ZN_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_VDD_M1_d N_B2_M1_g 8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M8 9 N_B2_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_ZN_M3_d N_B1_M3_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 N_VDD_M4_d N_A_M4_g N_ZN_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_ZN_M5_d N_B1_M5_g N_3_M5_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_3_M6_d N_B2_M6_g N_ZN_M5_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_ZN_M7_d N_B2_M7_g N_3_M6_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_3_M8_d N_B1_M8_g N_ZN_M7_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M9_d N_A_M9_g N_3_M8_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_3_M10_d N_A_M10_g N_VSS_M9_d VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_OAI21_X4%VSS_c0 VSS x_PM_OAI21_X4%VSS_12 3.8103e-17
C_x_PM_OAI21_X4%VSS_c1 VSS N_VSS_M9_d 6.46119e-17
C_x_PM_OAI21_X4%VSS_c2 VSS x_PM_OAI21_X4%VSS_2 2.22948e-16
R_x_PM_OAI21_X4%VSS_r3 x_PM_OAI21_X4%VSS_12 x_PM_OAI21_X4%VSS_6 0.145286
R_x_PM_OAI21_X4%VSS_r4 N_VSS_M9_d x_PM_OAI21_X4%VSS_6 1.235
R_x_PM_OAI21_X4%VSS_r5 x_PM_OAI21_X4%VSS_12 x_PM_OAI21_X4%VSS_2 0.0731438
R_x_PM_OAI21_X4%VSS_r6 VSS x_PM_OAI21_X4%VSS_2 0.771176
C_x_PM_OAI21_X4%VDD_c0 VSS x_PM_OAI21_X4%VDD_20 2.53556e-17
C_x_PM_OAI21_X4%VDD_c1 VSS x_PM_OAI21_X4%VDD_19 2.64443e-18
C_x_PM_OAI21_X4%VDD_c2 VSS N_VDD_M4_d 2.49048e-17
C_x_PM_OAI21_X4%VDD_c3 VSS x_PM_OAI21_X4%VDD_11 5.2931e-17
C_x_PM_OAI21_X4%VDD_c4 VSS N_VDD_M1_d 2.07364e-17
C_x_PM_OAI21_X4%VDD_c5 VSS x_PM_OAI21_X4%VDD_3 5.00929e-17
R_x_PM_OAI21_X4%VDD_r6 x_PM_OAI21_X4%VDD_20 x_PM_OAI21_X4%VDD_13 0.145286
R_x_PM_OAI21_X4%VDD_r7 N_VDD_M4_d x_PM_OAI21_X4%VDD_13 0.230714
R_x_PM_OAI21_X4%VDD_r8 x_PM_OAI21_X4%VDD_19 x_PM_OAI21_X4%VDD_12 0.0731438
R_x_PM_OAI21_X4%VDD_r9 x_PM_OAI21_X4%VDD_20 x_PM_OAI21_X4%VDD_11 0.0731438
R_x_PM_OAI21_X4%VDD_r10 x_PM_OAI21_X4%VDD_12 x_PM_OAI21_X4%VDD_11 1.11765
R_x_PM_OAI21_X4%VDD_r11 x_PM_OAI21_X4%VDD_19 x_PM_OAI21_X4%VDD_7 0.145286
R_x_PM_OAI21_X4%VDD_r12 N_VDD_M1_d x_PM_OAI21_X4%VDD_7 0.230714
R_x_PM_OAI21_X4%VDD_r13 x_PM_OAI21_X4%VDD_19 x_PM_OAI21_X4%VDD_3 0.0731438
R_x_PM_OAI21_X4%VDD_r14 VDD x_PM_OAI21_X4%VDD_3 0.491765
C_x_PM_OAI21_X4%3_c0 VSS x_PM_OAI21_X4%3_16 9.46093e-18
C_x_PM_OAI21_X4%3_c1 VSS x_PM_OAI21_X4%3_15 5.30128e-17
C_x_PM_OAI21_X4%3_c2 VSS N_3_M8_d 3.30442e-17
C_x_PM_OAI21_X4%3_c3 VSS x_PM_OAI21_X4%3_5 2.38562e-16
C_x_PM_OAI21_X4%3_c4 VSS N_3_M10_d 4.61726e-17
R_x_PM_OAI21_X4%3_r5 x_PM_OAI21_X4%3_17 x_PM_OAI21_X4%3_15 0.212317
R_x_PM_OAI21_X4%3_r6 x_PM_OAI21_X4%3_16 x_PM_OAI21_X4%3_15 1.68286
R_x_PM_OAI21_X4%3_r7 x_PM_OAI21_X4%3_16 x_PM_OAI21_X4%3_12 0.212317
R_x_PM_OAI21_X4%3_r8 N_3_M8_d x_PM_OAI21_X4%3_12 0.475
R_x_PM_OAI21_X4%3_r9 N_3_M8_d x_PM_OAI21_X4%3_11 0.746429
R_x_PM_OAI21_X4%3_r10 N_3_M6_d N_3_M5_s 2.03571
R_x_PM_OAI21_X4%3_r11 x_PM_OAI21_X4%3_11 x_PM_OAI21_X4%3_5 0.212317
R_x_PM_OAI21_X4%3_r12 N_3_M6_d x_PM_OAI21_X4%3_5 1.85929
R_x_PM_OAI21_X4%3_r13 N_3_M10_d x_PM_OAI21_X4%3_17 0.475
C_x_PM_OAI21_X4%ZN_c0 VSS N_ZN_M3_d 1.31057e-16
C_x_PM_OAI21_X4%ZN_c1 VSS x_PM_OAI21_X4%ZN_17 7.63798e-18
C_x_PM_OAI21_X4%ZN_c2 VSS N_ZN_M7_d 1.04072e-16
C_x_PM_OAI21_X4%ZN_c3 VSS x_PM_OAI21_X4%ZN_11 1.34146e-17
C_x_PM_OAI21_X4%ZN_c4 VSS ZN 6.80979e-17
R_x_PM_OAI21_X4%ZN_r5 N_ZN_M3_d x_PM_OAI21_X4%ZN_17 3.92214
R_x_PM_OAI21_X4%ZN_r6 N_ZN_M7_d N_ZN_M5_d 2.06286
R_x_PM_OAI21_X4%ZN_r7 N_ZN_M5_d x_PM_OAI21_X4%ZN_11 0.827857
R_x_PM_OAI21_X4%ZN_r8 N_ZN_M0_s ZN 0.95
R_x_PM_OAI21_X4%ZN_r9 x_PM_OAI21_X4%ZN_17 x_PM_OAI21_X4%ZN_6 0.212645
R_x_PM_OAI21_X4%ZN_r10 N_ZN_M0_s x_PM_OAI21_X4%ZN_6 0.443333
R_x_PM_OAI21_X4%ZN_r11 x_PM_OAI21_X4%ZN_11 x_PM_OAI21_X4%ZN_5 0.212645
R_x_PM_OAI21_X4%ZN_r12 ZN x_PM_OAI21_X4%ZN_5 1.9
C_x_PM_OAI21_X4%B1_c0 VSS x_PM_OAI21_X4%B1_24 1.24907e-17
C_x_PM_OAI21_X4%B1_c1 VSS x_PM_OAI21_X4%B1_22 4.9253e-17
C_x_PM_OAI21_X4%B1_c2 VSS x_PM_OAI21_X4%B1_20 7.69374e-18
C_x_PM_OAI21_X4%B1_c3 VSS x_PM_OAI21_X4%B1_18 6.82598e-17
C_x_PM_OAI21_X4%B1_c4 VSS N_B1_M3_g 6.96771e-17
C_x_PM_OAI21_X4%B1_c5 VSS N_B1_M8_g 5.74865e-17
C_x_PM_OAI21_X4%B1_c6 VSS N_B1_M0_g 7.53633e-17
C_x_PM_OAI21_X4%B1_c7 VSS N_B1_M5_g 5.67572e-17
R_x_PM_OAI21_X4%B1_r8 x_PM_OAI21_X4%B1_28 B1 0.095
R_x_PM_OAI21_X4%B1_r9 x_PM_OAI21_X4%B1_24 x_PM_OAI21_X4%B1_30 3.9
R_x_PM_OAI21_X4%B1_r10 x_PM_OAI21_X4%B1_24 x_PM_OAI21_X4%B1_22 25.0012
R_x_PM_OAI21_X4%B1_r11 B1 x_PM_OAI21_X4%B1_22 0.00791667
R_x_PM_OAI21_X4%B1_r12 x_PM_OAI21_X4%B1_36 x_PM_OAI21_X4%B1_20 4.7687
R_x_PM_OAI21_X4%B1_r13 x_PM_OAI21_X4%B1_35 x_PM_OAI21_X4%B1_20 4.7687
R_x_PM_OAI21_X4%B1_r14 x_PM_OAI21_X4%B1_20 x_PM_OAI21_X4%B1_18 25.0012
R_x_PM_OAI21_X4%B1_r15 x_PM_OAI21_X4%B1_28 x_PM_OAI21_X4%B1_17 0.095
R_x_PM_OAI21_X4%B1_r16 x_PM_OAI21_X4%B1_18 x_PM_OAI21_X4%B1_17 2.48357
R_x_PM_OAI21_X4%B1_r17 N_B1_M3_g x_PM_OAI21_X4%B1_36 65.52
R_x_PM_OAI21_X4%B1_r18 N_B1_M8_g x_PM_OAI21_X4%B1_35 55.38
R_x_PM_OAI21_X4%B1_r19 x_PM_OAI21_X4%B1_30 x_PM_OAI21_X4%B1_5 1.95
R_x_PM_OAI21_X4%B1_r20 N_B1_M0_g x_PM_OAI21_X4%B1_5 70.2
R_x_PM_OAI21_X4%B1_r21 x_PM_OAI21_X4%B1_30 x_PM_OAI21_X4%B1_VSS 1.95
R_x_PM_OAI21_X4%B1_r22 N_B1_M5_g x_PM_OAI21_X4%B1_VSS 50.7
C_x_PM_OAI21_X4%B2_c0 VSS x_PM_OAI21_X4%B2_24 3.57298e-18
C_x_PM_OAI21_X4%B2_c1 VSS B2 8.31169e-17
C_x_PM_OAI21_X4%B2_c2 VSS x_PM_OAI21_X4%B2_19 4.38863e-18
C_x_PM_OAI21_X4%B2_c3 VSS N_B2_M2_g 4.09003e-17
C_x_PM_OAI21_X4%B2_c4 VSS N_B2_M7_g 6.1994e-17
C_x_PM_OAI21_X4%B2_c5 VSS x_PM_OAI21_X4%B2_9 8.05223e-18
C_x_PM_OAI21_X4%B2_c6 VSS N_B2_M1_g 3.93786e-17
C_x_PM_OAI21_X4%B2_c7 VSS N_B2_M6_g 6.17402e-17
R_x_PM_OAI21_X4%B2_r8 x_PM_OAI21_X4%B2_24 x_PM_OAI21_X4%B2_22 25.0012
R_x_PM_OAI21_X4%B2_r9 x_PM_OAI21_X4%B2_22 B2 0.249854
R_x_PM_OAI21_X4%B2_r10 x_PM_OAI21_X4%B2_19 x_PM_OAI21_X4%B2_15 4.56151
R_x_PM_OAI21_X4%B2_r11 N_B2_M2_g x_PM_OAI21_X4%B2_15 39
R_x_PM_OAI21_X4%B2_r12 x_PM_OAI21_X4%B2_19 x_PM_OAI21_X4%B2_11 4.56151
R_x_PM_OAI21_X4%B2_r13 N_B2_M7_g x_PM_OAI21_X4%B2_11 81.9
R_x_PM_OAI21_X4%B2_r14 x_PM_OAI21_X4%B2_24 x_PM_OAI21_X4%B2_10 0.043368
R_x_PM_OAI21_X4%B2_r15 x_PM_OAI21_X4%B2_19 x_PM_OAI21_X4%B2_9 0.043368
R_x_PM_OAI21_X4%B2_r16 x_PM_OAI21_X4%B2_10 x_PM_OAI21_X4%B2_9 14.56
R_x_PM_OAI21_X4%B2_r17 x_PM_OAI21_X4%B2_24 x_PM_OAI21_X4%B2_5 4.56151
R_x_PM_OAI21_X4%B2_r18 N_B2_M1_g x_PM_OAI21_X4%B2_5 39
R_x_PM_OAI21_X4%B2_r19 x_PM_OAI21_X4%B2_24 x_PM_OAI21_X4%B2_VSS 4.56151
R_x_PM_OAI21_X4%B2_r20 N_B2_M6_g x_PM_OAI21_X4%B2_VSS 81.9
C_x_PM_OAI21_X4%A_c0 VSS x_PM_OAI21_X4%A_23 3.80952e-17
C_x_PM_OAI21_X4%A_c1 VSS x_PM_OAI21_X4%A_18 3.57315e-18
C_x_PM_OAI21_X4%A_c2 VSS x_PM_OAI21_X4%A_16 3.62938e-17
C_x_PM_OAI21_X4%A_c3 VSS N_A_M10_g 4.62909e-17
C_x_PM_OAI21_X4%A_c4 VSS x_PM_OAI21_X4%A_9 1.6277e-17
C_x_PM_OAI21_X4%A_c5 VSS N_A_M4_g 6.13301e-17
C_x_PM_OAI21_X4%A_c6 VSS N_A_M9_g 4.24782e-17
R_x_PM_OAI21_X4%A_r7 x_PM_OAI21_X4%A_23 A 0.298571
R_x_PM_OAI21_X4%A_r8 x_PM_OAI21_X4%A_18 x_PM_OAI21_X4%A_16 25.0012
R_x_PM_OAI21_X4%A_r9 x_PM_OAI21_X4%A_23 x_PM_OAI21_X4%A_15 0.095
R_x_PM_OAI21_X4%A_r10 x_PM_OAI21_X4%A_16 x_PM_OAI21_X4%A_15 1.045
R_x_PM_OAI21_X4%A_r11 N_A_M10_g x_PM_OAI21_X4%A_11 53.82
R_x_PM_OAI21_X4%A_r12 x_PM_OAI21_X4%A_18 x_PM_OAI21_X4%A_10 0.043368
R_x_PM_OAI21_X4%A_r13 x_PM_OAI21_X4%A_11 x_PM_OAI21_X4%A_9 4.58872
R_x_PM_OAI21_X4%A_r14 x_PM_OAI21_X4%A_10 x_PM_OAI21_X4%A_9 14.56
R_x_PM_OAI21_X4%A_r15 x_PM_OAI21_X4%A_18 x_PM_OAI21_X4%A_5 4.56151
R_x_PM_OAI21_X4%A_r16 N_A_M4_g x_PM_OAI21_X4%A_5 55.38
R_x_PM_OAI21_X4%A_r17 x_PM_OAI21_X4%A_18 x_PM_OAI21_X4%A_VSS 4.56151
R_x_PM_OAI21_X4%A_r18 N_A_M9_g x_PM_OAI21_X4%A_VSS 53.82
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X1 VSS VDD B2 B1 ZN A C2 C1
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A:I C2:I C1:I
M_M5 noxref_11 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_ZN_M1_d N_B1_M1_g noxref_11 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M8 noxref_12 N_C2_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M9 N_ZN_M4_d N_C1_M4_g noxref_12 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_VSS_M5_d N_B2_M5_g N_3_M5_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 N_3_M6_d N_B1_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_8_M7_d N_A_M7_g N_3_M6_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_ZN_M8_d N_C2_M8_g N_8_M7_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M4 N_8_M9_d N_C1_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.170000U L=0.050000U
C_x_PM_OAI221_X1%VSS_c0 VSS x_PM_OAI221_X1%VSS_12 2.70598e-17
C_x_PM_OAI221_X1%VSS_c1 VSS VSS 1.44637e-16
C_x_PM_OAI221_X1%VSS_c2 VSS N_VSS_M5_d 4.14314e-17
R_x_PM_OAI221_X1%VSS_r3 x_PM_OAI221_X1%VSS_12 x_PM_OAI221_X1%VSS_8 0.0731438
R_x_PM_OAI221_X1%VSS_r4 VSS x_PM_OAI221_X1%VSS_8 0.614706
R_x_PM_OAI221_X1%VSS_r5 x_PM_OAI221_X1%VSS_12 x_PM_OAI221_X1%VSS_4 0.145286
R_x_PM_OAI221_X1%VSS_r6 N_VSS_M5_d x_PM_OAI221_X1%VSS_4 0.936429
C_x_PM_OAI221_X1%VDD_c0 VSS x_PM_OAI221_X1%VDD_17 5.21996e-17
C_x_PM_OAI221_X1%VDD_c1 VSS N_VDD_M2_d 2.58474e-17
C_x_PM_OAI221_X1%VDD_c2 VSS x_PM_OAI221_X1%VDD_8 1.08262e-17
C_x_PM_OAI221_X1%VDD_c3 VSS x_PM_OAI221_X1%VDD_7 5.32198e-17
C_x_PM_OAI221_X1%VDD_c4 VSS N_VDD_M0_s 1.18023e-17
R_x_PM_OAI221_X1%VDD_r5 x_PM_OAI221_X1%VDD_17 x_PM_OAI221_X1%VDD_11 0.145286
R_x_PM_OAI221_X1%VDD_r6 N_VDD_M2_d x_PM_OAI221_X1%VDD_11 0.393571
R_x_PM_OAI221_X1%VDD_r7 VDD x_PM_OAI221_X1%VDD_8 1.02824
R_x_PM_OAI221_X1%VDD_r8 x_PM_OAI221_X1%VDD_17 x_PM_OAI221_X1%VDD_7 0.0731438
R_x_PM_OAI221_X1%VDD_r9 VDD x_PM_OAI221_X1%VDD_7 0.0782353
R_x_PM_OAI221_X1%VDD_r10 x_PM_OAI221_X1%VDD_8 x_PM_OAI221_X1%VDD_3 0.264221
R_x_PM_OAI221_X1%VDD_r11 N_VDD_M0_s x_PM_OAI221_X1%VDD_3 0.393571
C_x_PM_OAI221_X1%3_c0 VSS x_PM_OAI221_X1%3_8 8.95166e-18
C_x_PM_OAI221_X1%3_c1 VSS x_PM_OAI221_X1%3_7 5.6848e-17
C_x_PM_OAI221_X1%3_c2 VSS N_3_M5_s 1.21406e-17
C_x_PM_OAI221_X1%3_c3 VSS N_3_M6_d 1.49453e-17
R_x_PM_OAI221_X1%3_r4 x_PM_OAI221_X1%3_9 x_PM_OAI221_X1%3_7 0.212317
R_x_PM_OAI221_X1%3_r5 x_PM_OAI221_X1%3_8 x_PM_OAI221_X1%3_7 1.62857
R_x_PM_OAI221_X1%3_r6 x_PM_OAI221_X1%3_8 x_PM_OAI221_X1%3_3 0.212317
R_x_PM_OAI221_X1%3_r7 N_3_M5_s x_PM_OAI221_X1%3_3 0.203571
R_x_PM_OAI221_X1%3_r8 N_3_M6_d x_PM_OAI221_X1%3_9 0.203571
C_x_PM_OAI221_X1%B2_c0 VSS x_PM_OAI221_X1%B2_14 7.29435e-18
C_x_PM_OAI221_X1%B2_c1 VSS x_PM_OAI221_X1%B2_12 2.70552e-17
C_x_PM_OAI221_X1%B2_c2 VSS N_B2_M0_g 6.14059e-17
C_x_PM_OAI221_X1%B2_c3 VSS N_B2_M5_g 4.57486e-17
R_x_PM_OAI221_X1%B2_r4 x_PM_OAI221_X1%B2_18 x_PM_OAI221_X1%B2_14 4.7687
R_x_PM_OAI221_X1%B2_r5 x_PM_OAI221_X1%B2_17 x_PM_OAI221_X1%B2_14 4.7687
R_x_PM_OAI221_X1%B2_r6 x_PM_OAI221_X1%B2_14 x_PM_OAI221_X1%B2_12 25.0012
R_x_PM_OAI221_X1%B2_r7 x_PM_OAI221_X1%B2_12 B2 0.2375
R_x_PM_OAI221_X1%B2_r8 N_B2_M0_g x_PM_OAI221_X1%B2_18 79.95
R_x_PM_OAI221_X1%B2_r9 N_B2_M5_g x_PM_OAI221_X1%B2_17 45.24
C_x_PM_OAI221_X1%B1_c0 VSS x_PM_OAI221_X1%B1_13 8.90924e-18
C_x_PM_OAI221_X1%B1_c1 VSS B1 4.05864e-17
C_x_PM_OAI221_X1%B1_c2 VSS N_B1_M1_g 3.13291e-17
C_x_PM_OAI221_X1%B1_c3 VSS N_B1_M6_g 8.12643e-17
R_x_PM_OAI221_X1%B1_r4 x_PM_OAI221_X1%B1_16 x_PM_OAI221_X1%B1_13 4.74714
R_x_PM_OAI221_X1%B1_r5 x_PM_OAI221_X1%B1_15 x_PM_OAI221_X1%B1_13 4.74714
R_x_PM_OAI221_X1%B1_r6 x_PM_OAI221_X1%B1_13 x_PM_OAI221_X1%B1_11 25.0012
R_x_PM_OAI221_X1%B1_r7 x_PM_OAI221_X1%B1_11 B1 0.131785
R_x_PM_OAI221_X1%B1_r8 N_B1_M1_g x_PM_OAI221_X1%B1_16 23.01
R_x_PM_OAI221_X1%B1_r9 N_B1_M6_g x_PM_OAI221_X1%B1_15 102.18
C_x_PM_OAI221_X1%ZN_c0 VSS x_PM_OAI221_X1%ZN_24 4.80538e-18
C_x_PM_OAI221_X1%ZN_c1 VSS N_ZN_M4_d 1.4517e-17
C_x_PM_OAI221_X1%ZN_c2 VSS x_PM_OAI221_X1%ZN_16 2.01692e-17
C_x_PM_OAI221_X1%ZN_c3 VSS N_ZN_M8_d 1.35778e-16
C_x_PM_OAI221_X1%ZN_c4 VSS x_PM_OAI221_X1%ZN_10 3.41191e-17
C_x_PM_OAI221_X1%ZN_c5 VSS x_PM_OAI221_X1%ZN_9 6.53979e-18
C_x_PM_OAI221_X1%ZN_c6 VSS x_PM_OAI221_X1%ZN_8 2.51824e-17
C_x_PM_OAI221_X1%ZN_c7 VSS N_ZN_M1_d 3.23227e-17
C_x_PM_OAI221_X1%ZN_c8 VSS x_PM_OAI221_X1%ZN_4 4.74473e-18
R_x_PM_OAI221_X1%ZN_r9 N_ZN_M4_d x_PM_OAI221_X1%ZN_18 0.339286
R_x_PM_OAI221_X1%ZN_r10 x_PM_OAI221_X1%ZN_24 x_PM_OAI221_X1%ZN_17 0.151873
R_x_PM_OAI221_X1%ZN_r11 x_PM_OAI221_X1%ZN_18 x_PM_OAI221_X1%ZN_16 0.212317
R_x_PM_OAI221_X1%ZN_r12 x_PM_OAI221_X1%ZN_17 x_PM_OAI221_X1%ZN_16 0.597143
R_x_PM_OAI221_X1%ZN_r13 x_PM_OAI221_X1%ZN_24 x_PM_OAI221_X1%ZN_12 0.0495914
R_x_PM_OAI221_X1%ZN_r14 N_ZN_M8_d x_PM_OAI221_X1%ZN_12 3.40643
R_x_PM_OAI221_X1%ZN_r15 ZN x_PM_OAI221_X1%ZN_11 0.185074
R_x_PM_OAI221_X1%ZN_r16 x_PM_OAI221_X1%ZN_24 x_PM_OAI221_X1%ZN_10 0.151873
R_x_PM_OAI221_X1%ZN_r17 x_PM_OAI221_X1%ZN_11 x_PM_OAI221_X1%ZN_10 1.40125
R_x_PM_OAI221_X1%ZN_r18 ZN x_PM_OAI221_X1%ZN_8 0.0284729
R_x_PM_OAI221_X1%ZN_r19 x_PM_OAI221_X1%ZN_9 x_PM_OAI221_X1%ZN_8 0.298571
R_x_PM_OAI221_X1%ZN_r20 x_PM_OAI221_X1%ZN_9 x_PM_OAI221_X1%ZN_4 0.202958
R_x_PM_OAI221_X1%ZN_r21 N_ZN_M1_d x_PM_OAI221_X1%ZN_4 0.111765
C_x_PM_OAI221_X1%A_c0 VSS A 4.29327e-17
C_x_PM_OAI221_X1%A_c1 VSS x_PM_OAI221_X1%A_11 1.00314e-17
C_x_PM_OAI221_X1%A_c2 VSS N_A_M2_g 8.25598e-17
C_x_PM_OAI221_X1%A_c3 VSS N_A_M7_g 3.07924e-17
R_x_PM_OAI221_X1%A_r4 x_PM_OAI221_X1%A_11 x_PM_OAI221_X1%A_16 3.38
R_x_PM_OAI221_X1%A_r5 x_PM_OAI221_X1%A_11 x_PM_OAI221_X1%A_9 25.0012
R_x_PM_OAI221_X1%A_r6 A x_PM_OAI221_X1%A_9 0.223929
R_x_PM_OAI221_X1%A_r7 x_PM_OAI221_X1%A_16 x_PM_OAI221_X1%A_5 1.95
R_x_PM_OAI221_X1%A_r8 N_A_M2_g x_PM_OAI221_X1%A_5 106.47
R_x_PM_OAI221_X1%A_r9 x_PM_OAI221_X1%A_16 x_PM_OAI221_X1%A_VSS 1.95
R_x_PM_OAI221_X1%A_r10 N_A_M7_g x_PM_OAI221_X1%A_VSS 23.4
C_x_PM_OAI221_X1%8_c0 VSS x_PM_OAI221_X1%8_8 1.81713e-17
C_x_PM_OAI221_X1%8_c1 VSS x_PM_OAI221_X1%8_7 9.26159e-17
C_x_PM_OAI221_X1%8_c2 VSS N_8_M7_d 1.98433e-17
C_x_PM_OAI221_X1%8_c3 VSS N_8_M9_d 1.07922e-17
R_x_PM_OAI221_X1%8_r4 x_PM_OAI221_X1%8_9 x_PM_OAI221_X1%8_7 0.212317
R_x_PM_OAI221_X1%8_r5 x_PM_OAI221_X1%8_8 x_PM_OAI221_X1%8_7 1.62857
R_x_PM_OAI221_X1%8_r6 x_PM_OAI221_X1%8_8 x_PM_OAI221_X1%8_3 0.212317
R_x_PM_OAI221_X1%8_r7 N_8_M7_d x_PM_OAI221_X1%8_3 0.203571
R_x_PM_OAI221_X1%8_r8 N_8_M9_d x_PM_OAI221_X1%8_9 0.203571
C_x_PM_OAI221_X1%C2_c0 VSS x_PM_OAI221_X1%C2_18 1.07107e-17
C_x_PM_OAI221_X1%C2_c1 VSS x_PM_OAI221_X1%C2_12 4.64685e-17
C_x_PM_OAI221_X1%C2_c2 VSS N_C2_M3_g 5.64049e-17
C_x_PM_OAI221_X1%C2_c3 VSS N_C2_M8_g 6.01158e-17
R_x_PM_OAI221_X1%C2_r4 x_PM_OAI221_X1%C2_18 x_PM_OAI221_X1%C2_14 3.38
R_x_PM_OAI221_X1%C2_r5 x_PM_OAI221_X1%C2_14 x_PM_OAI221_X1%C2_12 25.0012
R_x_PM_OAI221_X1%C2_r6 x_PM_OAI221_X1%C2_12 C2 0.115357
R_x_PM_OAI221_X1%C2_r7 x_PM_OAI221_X1%C2_18 x_PM_OAI221_X1%C2_5 1.95
R_x_PM_OAI221_X1%C2_r8 N_C2_M3_g x_PM_OAI221_X1%C2_5 58.11
R_x_PM_OAI221_X1%C2_r9 x_PM_OAI221_X1%C2_18 x_PM_OAI221_X1%C2_VSS 1.95
R_x_PM_OAI221_X1%C2_r10 N_C2_M8_g x_PM_OAI221_X1%C2_VSS 67.08
C_x_PM_OAI221_X1%C1_c0 VSS C1 4.25159e-17
C_x_PM_OAI221_X1%C1_c1 VSS x_PM_OAI221_X1%C1_11 9.16967e-18
C_x_PM_OAI221_X1%C1_c2 VSS N_C1_M4_g 5.56373e-17
C_x_PM_OAI221_X1%C1_c3 VSS N_C1_M9_g 5.61153e-17
R_x_PM_OAI221_X1%C1_r4 x_PM_OAI221_X1%C1_11 x_PM_OAI221_X1%C1_16 4.42
R_x_PM_OAI221_X1%C1_r5 x_PM_OAI221_X1%C1_11 x_PM_OAI221_X1%C1_9 25.0012
R_x_PM_OAI221_X1%C1_r6 C1 x_PM_OAI221_X1%C1_9 0.196786
R_x_PM_OAI221_X1%C1_r7 x_PM_OAI221_X1%C1_16 x_PM_OAI221_X1%C1_5 1.95
R_x_PM_OAI221_X1%C1_r8 N_C1_M4_g x_PM_OAI221_X1%C1_5 58.89
R_x_PM_OAI221_X1%C1_r9 x_PM_OAI221_X1%C1_16 x_PM_OAI221_X1%C1_VSS 1.95
R_x_PM_OAI221_X1%C1_r10 N_C1_M9_g x_PM_OAI221_X1%C1_VSS 66.3
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X2 VSS VDD B2 B1 ZN A C2 C1
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A:I C2:I C1:I
M_M5 noxref_11 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_ZN_M1_d N_B1_M1_g noxref_11 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_VDD_M2_d N_A_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M8 noxref_12 N_C2_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_ZN_M4_d N_C1_M4_g noxref_12 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_VSS_M5_d N_B2_M5_g N_3_M5_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_3_M6_d N_B1_M6_g N_VSS_M5_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_8_M7_d N_A_M7_g N_3_M6_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_ZN_M8_d N_C2_M8_g N_8_M7_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 N_8_M9_d N_C1_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI221_X2%VSS_c0 VSS x_PM_OAI221_X2%VSS_12 4.17497e-17
C_x_PM_OAI221_X2%VSS_c1 VSS VSS 1.40602e-16
C_x_PM_OAI221_X2%VSS_c2 VSS N_VSS_M5_d 3.00442e-17
R_x_PM_OAI221_X2%VSS_r3 x_PM_OAI221_X2%VSS_12 x_PM_OAI221_X2%VSS_8 0.0731438
R_x_PM_OAI221_X2%VSS_r4 VSS x_PM_OAI221_X2%VSS_8 0.614706
R_x_PM_OAI221_X2%VSS_r5 x_PM_OAI221_X2%VSS_12 x_PM_OAI221_X2%VSS_4 0.145286
R_x_PM_OAI221_X2%VSS_r6 N_VSS_M5_d x_PM_OAI221_X2%VSS_4 0.230714
C_x_PM_OAI221_X2%VDD_c0 VSS x_PM_OAI221_X2%VDD_16 5.50604e-17
C_x_PM_OAI221_X2%VDD_c1 VSS N_VDD_M2_d 2.13043e-17
C_x_PM_OAI221_X2%VDD_c2 VSS x_PM_OAI221_X2%VDD_7 4.81784e-17
C_x_PM_OAI221_X2%VDD_c3 VSS N_VDD_M0_s 2.05861e-17
C_x_PM_OAI221_X2%VDD_c4 VSS x_PM_OAI221_X2%VDD_3 1.07531e-17
R_x_PM_OAI221_X2%VDD_r5 x_PM_OAI221_X2%VDD_16 x_PM_OAI221_X2%VDD_9 0.145286
R_x_PM_OAI221_X2%VDD_r6 N_VDD_M2_d x_PM_OAI221_X2%VDD_9 0.230714
R_x_PM_OAI221_X2%VDD_r7 VDD x_PM_OAI221_X2%VDD_8 0.195294
R_x_PM_OAI221_X2%VDD_r8 x_PM_OAI221_X2%VDD_16 x_PM_OAI221_X2%VDD_7 0.0731438
R_x_PM_OAI221_X2%VDD_r9 x_PM_OAI221_X2%VDD_8 x_PM_OAI221_X2%VDD_7 1.10647
R_x_PM_OAI221_X2%VDD_r10 VDD x_PM_OAI221_X2%VDD_3 0.0689273
R_x_PM_OAI221_X2%VDD_r11 N_VDD_M0_s x_PM_OAI221_X2%VDD_3 0.230714
C_x_PM_OAI221_X2%3_c0 VSS x_PM_OAI221_X2%3_7 9.90749e-18
C_x_PM_OAI221_X2%3_c1 VSS N_3_M5_s 2.45075e-17
C_x_PM_OAI221_X2%3_c2 VSS N_3_M6_d 6.98982e-17
R_x_PM_OAI221_X2%3_r3 x_PM_OAI221_X2%3_7 x_PM_OAI221_X2%3_3 0.212317
R_x_PM_OAI221_X2%3_r4 N_3_M5_s x_PM_OAI221_X2%3_3 0.230714
R_x_PM_OAI221_X2%3_r5 N_3_M6_d x_PM_OAI221_X2%3_7 1.83214
C_x_PM_OAI221_X2%B2_c0 VSS x_PM_OAI221_X2%B2_14 6.51318e-18
C_x_PM_OAI221_X2%B2_c1 VSS x_PM_OAI221_X2%B2_12 4.0168e-17
C_x_PM_OAI221_X2%B2_c2 VSS N_B2_M0_g 7.84703e-17
C_x_PM_OAI221_X2%B2_c3 VSS N_B2_M5_g 4.73534e-17
R_x_PM_OAI221_X2%B2_r4 x_PM_OAI221_X2%B2_18 x_PM_OAI221_X2%B2_14 4.7687
R_x_PM_OAI221_X2%B2_r5 x_PM_OAI221_X2%B2_17 x_PM_OAI221_X2%B2_14 4.7687
R_x_PM_OAI221_X2%B2_r6 x_PM_OAI221_X2%B2_14 x_PM_OAI221_X2%B2_12 25.0012
R_x_PM_OAI221_X2%B2_r7 x_PM_OAI221_X2%B2_12 B2 0.2375
R_x_PM_OAI221_X2%B2_r8 N_B2_M0_g x_PM_OAI221_X2%B2_18 86.58
R_x_PM_OAI221_X2%B2_r9 N_B2_M5_g x_PM_OAI221_X2%B2_17 35.1
C_x_PM_OAI221_X2%B1_c0 VSS x_PM_OAI221_X2%B1_11 8.20941e-18
C_x_PM_OAI221_X2%B1_c1 VSS x_PM_OAI221_X2%B1_9 2.49392e-17
C_x_PM_OAI221_X2%B1_c2 VSS N_B1_M1_g 4.99159e-17
C_x_PM_OAI221_X2%B1_c3 VSS N_B1_M6_g 7.77324e-17
R_x_PM_OAI221_X2%B1_r4 x_PM_OAI221_X2%B1_16 x_PM_OAI221_X2%B1_11 4.7687
R_x_PM_OAI221_X2%B1_r5 x_PM_OAI221_X2%B1_15 x_PM_OAI221_X2%B1_11 4.7687
R_x_PM_OAI221_X2%B1_r6 x_PM_OAI221_X2%B1_11 x_PM_OAI221_X2%B1_9 25.0012
R_x_PM_OAI221_X2%B1_r7 B1 x_PM_OAI221_X2%B1_9 0.293539
R_x_PM_OAI221_X2%B1_r8 N_B1_M1_g x_PM_OAI221_X2%B1_16 39
R_x_PM_OAI221_X2%B1_r9 N_B1_M6_g x_PM_OAI221_X2%B1_15 82.68
C_x_PM_OAI221_X2%ZN_c0 VSS ZN 9.84987e-18
C_x_PM_OAI221_X2%ZN_c1 VSS x_PM_OAI221_X2%ZN_13 3.16978e-17
C_x_PM_OAI221_X2%ZN_c2 VSS N_ZN_M8_d 1.24881e-16
C_x_PM_OAI221_X2%ZN_c3 VSS x_PM_OAI221_X2%ZN_4 5.01453e-17
R_x_PM_OAI221_X2%ZN_r4 ZN x_PM_OAI221_X2%ZN_13 0.111116
R_x_PM_OAI221_X2%ZN_r5 x_PM_OAI221_X2%ZN_13 N_ZN_M4_d 0.337698
R_x_PM_OAI221_X2%ZN_r6 ZN x_PM_OAI221_X2%ZN_8 0.0910788
R_x_PM_OAI221_X2%ZN_r7 N_ZN_M8_d x_PM_OAI221_X2%ZN_8 3.18929
R_x_PM_OAI221_X2%ZN_r8 ZN x_PM_OAI221_X2%ZN_4 0.111116
R_x_PM_OAI221_X2%ZN_r9 N_ZN_M1_d x_PM_OAI221_X2%ZN_4 1.786
C_x_PM_OAI221_X2%A_c0 VSS x_PM_OAI221_X2%A_14 9.31482e-18
C_x_PM_OAI221_X2%A_c1 VSS x_PM_OAI221_X2%A_12 5.52855e-17
C_x_PM_OAI221_X2%A_c2 VSS N_A_M2_g 8.20989e-17
C_x_PM_OAI221_X2%A_c3 VSS N_A_M7_g 4.52526e-17
R_x_PM_OAI221_X2%A_r4 x_PM_OAI221_X2%A_18 x_PM_OAI221_X2%A_14 4.74714
R_x_PM_OAI221_X2%A_r5 x_PM_OAI221_X2%A_17 x_PM_OAI221_X2%A_14 4.74714
R_x_PM_OAI221_X2%A_r6 x_PM_OAI221_X2%A_14 x_PM_OAI221_X2%A_12 25.0012
R_x_PM_OAI221_X2%A_r7 x_PM_OAI221_X2%A_12 A 0.128529
R_x_PM_OAI221_X2%A_r8 N_A_M2_g x_PM_OAI221_X2%A_18 95.94
R_x_PM_OAI221_X2%A_r9 N_A_M7_g x_PM_OAI221_X2%A_17 35.1
C_x_PM_OAI221_X2%8_c0 VSS x_PM_OAI221_X2%8_3 9.69559e-17
C_x_PM_OAI221_X2%8_c1 VSS N_8_M9_d 2.37797e-17
R_x_PM_OAI221_X2%8_r2 x_PM_OAI221_X2%8_7 x_PM_OAI221_X2%8_3 0.212317
R_x_PM_OAI221_X2%8_r3 N_8_M7_d x_PM_OAI221_X2%8_3 1.83214
R_x_PM_OAI221_X2%8_r4 N_8_M9_d x_PM_OAI221_X2%8_7 0.746429
C_x_PM_OAI221_X2%C2_c0 VSS x_PM_OAI221_X2%C2_18 1.02917e-17
C_x_PM_OAI221_X2%C2_c1 VSS x_PM_OAI221_X2%C2_12 7.11009e-17
C_x_PM_OAI221_X2%C2_c2 VSS N_C2_M3_g 8.26592e-17
C_x_PM_OAI221_X2%C2_c3 VSS N_C2_M8_g 4.87618e-17
R_x_PM_OAI221_X2%C2_r4 x_PM_OAI221_X2%C2_18 x_PM_OAI221_X2%C2_14 3.38
R_x_PM_OAI221_X2%C2_r5 x_PM_OAI221_X2%C2_14 x_PM_OAI221_X2%C2_12 25.0012
R_x_PM_OAI221_X2%C2_r6 x_PM_OAI221_X2%C2_12 C2 0.106176
R_x_PM_OAI221_X2%C2_r7 x_PM_OAI221_X2%C2_18 x_PM_OAI221_X2%C2_5 1.95
R_x_PM_OAI221_X2%C2_r8 N_C2_M3_g x_PM_OAI221_X2%C2_5 86.58
R_x_PM_OAI221_X2%C2_r9 x_PM_OAI221_X2%C2_18 x_PM_OAI221_X2%C2_VSS 1.95
R_x_PM_OAI221_X2%C2_r10 N_C2_M8_g x_PM_OAI221_X2%C2_VSS 35.1
C_x_PM_OAI221_X2%C1_c0 VSS C1 4.31712e-17
C_x_PM_OAI221_X2%C1_c1 VSS x_PM_OAI221_X2%C1_11 9.25446e-18
C_x_PM_OAI221_X2%C1_c2 VSS N_C1_M4_g 5.62791e-17
C_x_PM_OAI221_X2%C1_c3 VSS N_C1_M9_g 7.26061e-17
R_x_PM_OAI221_X2%C1_r4 x_PM_OAI221_X2%C1_11 x_PM_OAI221_X2%C1_16 4.42
R_x_PM_OAI221_X2%C1_r5 x_PM_OAI221_X2%C1_11 x_PM_OAI221_X2%C1_9 25.0012
R_x_PM_OAI221_X2%C1_r6 C1 x_PM_OAI221_X2%C1_9 0.183214
R_x_PM_OAI221_X2%C1_r7 x_PM_OAI221_X2%C1_16 x_PM_OAI221_X2%C1_5 1.95
R_x_PM_OAI221_X2%C1_r8 N_C1_M4_g x_PM_OAI221_X2%C1_5 48.36
R_x_PM_OAI221_X2%C1_r9 x_PM_OAI221_X2%C1_16 x_PM_OAI221_X2%C1_VSS 1.95
R_x_PM_OAI221_X2%C1_r10 N_C1_M9_g x_PM_OAI221_X2%C1_VSS 73.32
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI221_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI221_X4 VSS VDD ZN B2 B1 ZN A C2 C1
*.PININFO VSS:B VDD:B ZN:O C1:I C2:I A:I B2:I B1:I
M_M10 11 N_C1_M0_g N_ZN_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_VDD_M1_d N_C2_M1_g 11 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M12 12 N_C2_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M13 N_ZN_M3_d N_C1_M3_g 12 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M14 N_VDD_M4_d N_A_M4_g N_ZN_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M15 13 N_B2_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M16 N_ZN_M6_d N_B1_M6_g 13 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M17 14 N_B1_M7_g N_ZN_M6_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M18 N_VDD_M8_d N_B2_M8_g 14 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_5_M9_d N_C1_M9_g N_ZN_M9_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_ZN_M10_d N_C2_M10_g N_5_M9_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_5_M11_d N_C2_M11_g N_ZN_M10_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_ZN_M12_d N_C1_M12_g N_5_M11_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 N_5_M13_d N_A_M13_g N_7_M13_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M5 N_7_M14_d N_A_M14_g N_5_M13_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M6 N_VSS_M15_d N_B2_M15_g N_7_M14_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M7 N_7_M16_d N_B1_M16_g N_VSS_M15_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M8 N_VSS_M17_d N_B1_M17_g N_7_M16_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M9 N_7_M18_d N_B2_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI221_X4%VSS_c0 VSS x_PM_OAI221_X4%VSS_20 3.53305e-17
C_x_PM_OAI221_X4%VSS_c1 VSS x_PM_OAI221_X4%VSS_19 2.64443e-18
C_x_PM_OAI221_X4%VSS_c2 VSS N_VSS_M17_d 1.97589e-17
C_x_PM_OAI221_X4%VSS_c3 VSS x_PM_OAI221_X4%VSS_11 3.35504e-17
C_x_PM_OAI221_X4%VSS_c4 VSS N_VSS_M15_d 1.89819e-17
C_x_PM_OAI221_X4%VSS_c5 VSS x_PM_OAI221_X4%VSS_3 3.38398e-16
R_x_PM_OAI221_X4%VSS_r6 x_PM_OAI221_X4%VSS_20 x_PM_OAI221_X4%VSS_13 0.145286
R_x_PM_OAI221_X4%VSS_r7 N_VSS_M17_d x_PM_OAI221_X4%VSS_13 0.230714
R_x_PM_OAI221_X4%VSS_r8 x_PM_OAI221_X4%VSS_19 x_PM_OAI221_X4%VSS_12 0.0731438
R_x_PM_OAI221_X4%VSS_r9 x_PM_OAI221_X4%VSS_20 x_PM_OAI221_X4%VSS_11 0.0731438
R_x_PM_OAI221_X4%VSS_r10 x_PM_OAI221_X4%VSS_12 x_PM_OAI221_X4%VSS_11 0.681765
R_x_PM_OAI221_X4%VSS_r11 x_PM_OAI221_X4%VSS_19 x_PM_OAI221_X4%VSS_7 0.145286
R_x_PM_OAI221_X4%VSS_r12 N_VSS_M15_d x_PM_OAI221_X4%VSS_7 0.230714
R_x_PM_OAI221_X4%VSS_r13 x_PM_OAI221_X4%VSS_19 x_PM_OAI221_X4%VSS_3 0.0731438
R_x_PM_OAI221_X4%VSS_r14 VSS x_PM_OAI221_X4%VSS_3 0.905294
C_x_PM_OAI221_X4%VDD_c0 VSS x_PM_OAI221_X4%VDD_28 2.03107e-17
C_x_PM_OAI221_X4%VDD_c1 VSS x_PM_OAI221_X4%VDD_27 2.70113e-18
C_x_PM_OAI221_X4%VDD_c2 VSS x_PM_OAI221_X4%VDD_26 2.70113e-18
C_x_PM_OAI221_X4%VDD_c3 VSS N_VDD_M8_d 1.96316e-17
C_x_PM_OAI221_X4%VDD_c4 VSS x_PM_OAI221_X4%VDD_18 5.74988e-17
C_x_PM_OAI221_X4%VDD_c5 VSS N_VDD_M4_d 3.51965e-17
C_x_PM_OAI221_X4%VDD_c6 VSS x_PM_OAI221_X4%VDD_12 5.80707e-17
C_x_PM_OAI221_X4%VDD_c7 VSS N_VDD_M1_d 4.0838e-17
C_x_PM_OAI221_X4%VDD_c8 VSS x_PM_OAI221_X4%VDD_4 4.86803e-17
R_x_PM_OAI221_X4%VDD_r9 x_PM_OAI221_X4%VDD_28 x_PM_OAI221_X4%VDD_20 0.145286
R_x_PM_OAI221_X4%VDD_r10 N_VDD_M8_d x_PM_OAI221_X4%VDD_20 0.230714
R_x_PM_OAI221_X4%VDD_r11 x_PM_OAI221_X4%VDD_27 x_PM_OAI221_X4%VDD_19 0.0731438
R_x_PM_OAI221_X4%VDD_r12 x_PM_OAI221_X4%VDD_28 x_PM_OAI221_X4%VDD_18 0.0731438
R_x_PM_OAI221_X4%VDD_r13 x_PM_OAI221_X4%VDD_19 x_PM_OAI221_X4%VDD_18 1.54235
R_x_PM_OAI221_X4%VDD_r14 x_PM_OAI221_X4%VDD_27 x_PM_OAI221_X4%VDD_14 0.145286
R_x_PM_OAI221_X4%VDD_r15 N_VDD_M4_d x_PM_OAI221_X4%VDD_14 0.230714
R_x_PM_OAI221_X4%VDD_r16 x_PM_OAI221_X4%VDD_26 x_PM_OAI221_X4%VDD_13 0.0731438
R_x_PM_OAI221_X4%VDD_r17 x_PM_OAI221_X4%VDD_27 x_PM_OAI221_X4%VDD_12 0.0731438
R_x_PM_OAI221_X4%VDD_r18 x_PM_OAI221_X4%VDD_13 x_PM_OAI221_X4%VDD_12 1.57588
R_x_PM_OAI221_X4%VDD_r19 x_PM_OAI221_X4%VDD_26 x_PM_OAI221_X4%VDD_8 0.145286
R_x_PM_OAI221_X4%VDD_r20 N_VDD_M1_d x_PM_OAI221_X4%VDD_8 0.230714
R_x_PM_OAI221_X4%VDD_r21 x_PM_OAI221_X4%VDD_26 x_PM_OAI221_X4%VDD_4 0.0731438
R_x_PM_OAI221_X4%VDD_r22 VDD x_PM_OAI221_X4%VDD_4 0.553235
C_x_PM_OAI221_X4%ZN_c0 VSS N_ZN_M12_d 1.27236e-16
C_x_PM_OAI221_X4%ZN_c1 VSS N_ZN_M6_d 1.91087e-16
C_x_PM_OAI221_X4%ZN_c2 VSS x_PM_OAI221_X4%ZN_15 5.96864e-18
C_x_PM_OAI221_X4%ZN_c3 VSS x_PM_OAI221_X4%ZN_14 4.34921e-17
C_x_PM_OAI221_X4%ZN_c4 VSS ZN 2.76273e-18
C_x_PM_OAI221_X4%ZN_c5 VSS N_ZN_M9_s 4.79441e-17
R_x_PM_OAI221_X4%ZN_r6 N_ZN_M12_d N_ZN_M10_d 2.06286
R_x_PM_OAI221_X4%ZN_r7 N_ZN_M10_d x_PM_OAI221_X4%ZN_23 1.83214
R_x_PM_OAI221_X4%ZN_r8 N_ZN_M6_d N_ZN_M3_d 4.20714
R_x_PM_OAI221_X4%ZN_r9 N_ZN_M3_d N_ZN_M0_s 4.12571
R_x_PM_OAI221_X4%ZN_r10 N_ZN_M0_s x_PM_OAI221_X4%ZN_15 0.257857
R_x_PM_OAI221_X4%ZN_r11 x_PM_OAI221_X4%ZN_15 x_PM_OAI221_X4%ZN_14 0.212317
R_x_PM_OAI221_X4%ZN_r12 x_PM_OAI221_X4%ZN_14 x_PM_OAI221_X4%ZN_13 2.74143
R_x_PM_OAI221_X4%ZN_r13 ZN x_PM_OAI221_X4%ZN_23 0.0604376
R_x_PM_OAI221_X4%ZN_r14 ZN x_PM_OAI221_X4%ZN_13 0.140052
R_x_PM_OAI221_X4%ZN_r15 ZN N_ZN_M9_s 0.5296
C_x_PM_OAI221_X4%C1_c0 VSS x_PM_OAI221_X4%C1_39 1.27758e-17
C_x_PM_OAI221_X4%C1_c1 VSS x_PM_OAI221_X4%C1_34 1.64161e-17
C_x_PM_OAI221_X4%C1_c2 VSS x_PM_OAI221_X4%C1_27 3.9577e-17
C_x_PM_OAI221_X4%C1_c3 VSS x_PM_OAI221_X4%C1_23 5.21144e-18
C_x_PM_OAI221_X4%C1_c4 VSS x_PM_OAI221_X4%C1_17 9.84247e-17
C_x_PM_OAI221_X4%C1_c5 VSS N_C1_M3_g 5.60317e-17
C_x_PM_OAI221_X4%C1_c6 VSS N_C1_M12_g 7.31365e-17
C_x_PM_OAI221_X4%C1_c7 VSS N_C1_M0_g 8.08152e-17
C_x_PM_OAI221_X4%C1_c8 VSS N_C1_M9_g 5.97887e-17
R_x_PM_OAI221_X4%C1_r9 x_PM_OAI221_X4%C1_39 x_PM_OAI221_X4%C1_29 5.46
R_x_PM_OAI221_X4%C1_r10 x_PM_OAI221_X4%C1_29 x_PM_OAI221_X4%C1_36 1.3
R_x_PM_OAI221_X4%C1_r11 x_PM_OAI221_X4%C1_29 x_PM_OAI221_X4%C1_27 25.0012
R_x_PM_OAI221_X4%C1_r12 x_PM_OAI221_X4%C1_27 C1 0.288519
R_x_PM_OAI221_X4%C1_r13 C1 x_PM_OAI221_X4%C1_23 0.095
R_x_PM_OAI221_X4%C1_r14 x_PM_OAI221_X4%C1_23 x_PM_OAI221_X4%C1_22 0.38
R_x_PM_OAI221_X4%C1_r15 x_PM_OAI221_X4%C1_34 x_PM_OAI221_X4%C1_20 1.3
R_x_PM_OAI221_X4%C1_r16 x_PM_OAI221_X4%C1_20 x_PM_OAI221_X4%C1_31 5.46
R_x_PM_OAI221_X4%C1_r17 x_PM_OAI221_X4%C1_20 x_PM_OAI221_X4%C1_18 25.0012
R_x_PM_OAI221_X4%C1_r18 x_PM_OAI221_X4%C1_22 x_PM_OAI221_X4%C1_17 0.212317
R_x_PM_OAI221_X4%C1_r19 x_PM_OAI221_X4%C1_18 x_PM_OAI221_X4%C1_17 2.13071
R_x_PM_OAI221_X4%C1_r20 x_PM_OAI221_X4%C1_39 x_PM_OAI221_X4%C1_13 1.95
R_x_PM_OAI221_X4%C1_r21 N_C1_M3_g x_PM_OAI221_X4%C1_13 47.58
R_x_PM_OAI221_X4%C1_r22 x_PM_OAI221_X4%C1_36 x_PM_OAI221_X4%C1_9 1.95
R_x_PM_OAI221_X4%C1_r23 N_C1_M12_g x_PM_OAI221_X4%C1_9 74.1
R_x_PM_OAI221_X4%C1_r24 x_PM_OAI221_X4%C1_34 x_PM_OAI221_X4%C1_5 1.95
R_x_PM_OAI221_X4%C1_r25 N_C1_M0_g x_PM_OAI221_X4%C1_5 74.88
R_x_PM_OAI221_X4%C1_r26 x_PM_OAI221_X4%C1_31 x_PM_OAI221_X4%C1_VSS 1.95
R_x_PM_OAI221_X4%C1_r27 N_C1_M9_g x_PM_OAI221_X4%C1_VSS 46.8
C_x_PM_OAI221_X4%5_c0 VSS N_5_M13_d 3.11953e-16
R_x_PM_OAI221_X4%5_r1 N_5_M11_d N_5_M9_d 2.03571
R_x_PM_OAI221_X4%5_r2 N_5_M13_d N_5_M11_d 2.93143
C_x_PM_OAI221_X4%C2_c0 VSS x_PM_OAI221_X4%C2_29 2.87558e-17
C_x_PM_OAI221_X4%C2_c1 VSS x_PM_OAI221_X4%C2_20 7.44151e-17
C_x_PM_OAI221_X4%C2_c2 VSS N_C2_M2_g 4.62721e-17
C_x_PM_OAI221_X4%C2_c3 VSS N_C2_M11_g 6.16594e-17
C_x_PM_OAI221_X4%C2_c4 VSS N_C2_M1_g 4.46805e-17
C_x_PM_OAI221_X4%C2_c5 VSS N_C2_M10_g 6.34617e-17
R_x_PM_OAI221_X4%C2_r6 x_PM_OAI221_X4%C2_29 x_PM_OAI221_X4%C2_28 6.76
R_x_PM_OAI221_X4%C2_r7 x_PM_OAI221_X4%C2_28 x_PM_OAI221_X4%C2_27 13
R_x_PM_OAI221_X4%C2_r8 x_PM_OAI221_X4%C2_27 x_PM_OAI221_X4%C2_22 5.46
R_x_PM_OAI221_X4%C2_r9 x_PM_OAI221_X4%C2_22 x_PM_OAI221_X4%C2_24 1.3
R_x_PM_OAI221_X4%C2_r10 x_PM_OAI221_X4%C2_22 x_PM_OAI221_X4%C2_20 25.0012
R_x_PM_OAI221_X4%C2_r11 x_PM_OAI221_X4%C2_20 C2 0.278214
R_x_PM_OAI221_X4%C2_r12 x_PM_OAI221_X4%C2_29 x_PM_OAI221_X4%C2_13 1.95
R_x_PM_OAI221_X4%C2_r13 N_C2_M2_g x_PM_OAI221_X4%C2_13 48.36
R_x_PM_OAI221_X4%C2_r14 x_PM_OAI221_X4%C2_28 x_PM_OAI221_X4%C2_9 1.95
R_x_PM_OAI221_X4%C2_r15 N_C2_M11_g x_PM_OAI221_X4%C2_9 73.32
R_x_PM_OAI221_X4%C2_r16 x_PM_OAI221_X4%C2_27 x_PM_OAI221_X4%C2_5 1.95
R_x_PM_OAI221_X4%C2_r17 N_C2_M1_g x_PM_OAI221_X4%C2_5 48.36
R_x_PM_OAI221_X4%C2_r18 x_PM_OAI221_X4%C2_24 x_PM_OAI221_X4%C2_VSS 1.95
R_x_PM_OAI221_X4%C2_r19 N_C2_M10_g x_PM_OAI221_X4%C2_VSS 73.32
C_x_PM_OAI221_X4%7_c0 VSS N_7_M18_d 2.7476e-16
R_x_PM_OAI221_X4%7_r1 N_7_M16_d N_7_M14_d 1.03143
R_x_PM_OAI221_X4%7_r2 N_7_M14_d N_7_M13_s 1.01786
R_x_PM_OAI221_X4%7_r3 N_7_M18_d N_7_M16_d 1.03143
C_x_PM_OAI221_X4%A_c0 VSS x_PM_OAI221_X4%A_24 2.07073e-17
C_x_PM_OAI221_X4%A_c1 VSS x_PM_OAI221_X4%A_13 5.10897e-17
C_x_PM_OAI221_X4%A_c2 VSS N_A_M14_g 3.9527e-17
C_x_PM_OAI221_X4%A_c3 VSS N_A_M4_g 7.40413e-17
C_x_PM_OAI221_X4%A_c4 VSS N_A_M13_g 4.10312e-17
R_x_PM_OAI221_X4%A_r5 x_PM_OAI221_X4%A_24 x_PM_OAI221_X4%A_23 8.32
R_x_PM_OAI221_X4%A_r6 x_PM_OAI221_X4%A_23 x_PM_OAI221_X4%A_15 1.3
R_x_PM_OAI221_X4%A_r7 x_PM_OAI221_X4%A_15 x_PM_OAI221_X4%A_20 10.14
R_x_PM_OAI221_X4%A_r8 x_PM_OAI221_X4%A_15 x_PM_OAI221_X4%A_13 25.0012
R_x_PM_OAI221_X4%A_r9 A x_PM_OAI221_X4%A_13 0.302593
R_x_PM_OAI221_X4%A_r10 x_PM_OAI221_X4%A_24 x_PM_OAI221_X4%A_9 1.95
R_x_PM_OAI221_X4%A_r11 N_A_M14_g x_PM_OAI221_X4%A_9 35.1
R_x_PM_OAI221_X4%A_r12 x_PM_OAI221_X4%A_23 x_PM_OAI221_X4%A_5 1.95
R_x_PM_OAI221_X4%A_r13 N_A_M4_g x_PM_OAI221_X4%A_5 74.88
R_x_PM_OAI221_X4%A_r14 x_PM_OAI221_X4%A_20 x_PM_OAI221_X4%A_VSS 1.95
R_x_PM_OAI221_X4%A_r15 N_A_M13_g x_PM_OAI221_X4%A_VSS 35.1
C_x_PM_OAI221_X4%B2_c0 VSS x_PM_OAI221_X4%B2_40 1.2996e-17
C_x_PM_OAI221_X4%B2_c1 VSS x_PM_OAI221_X4%B2_35 1.46455e-17
C_x_PM_OAI221_X4%B2_c2 VSS x_PM_OAI221_X4%B2_26 2.68002e-17
C_x_PM_OAI221_X4%B2_c3 VSS B2 1.3296e-17
C_x_PM_OAI221_X4%B2_c4 VSS x_PM_OAI221_X4%B2_17 7.57484e-17
C_x_PM_OAI221_X4%B2_c5 VSS N_B2_M18_g 6.36064e-17
C_x_PM_OAI221_X4%B2_c6 VSS N_B2_M8_g 5.66438e-17
C_x_PM_OAI221_X4%B2_c7 VSS N_B2_M15_g 6.02354e-17
C_x_PM_OAI221_X4%B2_c8 VSS N_B2_M5_g 6.9495e-17
R_x_PM_OAI221_X4%B2_r9 x_PM_OAI221_X4%B2_35 x_PM_OAI221_X4%B2_30 1.3
R_x_PM_OAI221_X4%B2_r10 x_PM_OAI221_X4%B2_30 x_PM_OAI221_X4%B2_32 7.02
R_x_PM_OAI221_X4%B2_r11 x_PM_OAI221_X4%B2_30 x_PM_OAI221_X4%B2_28 25.0012
R_x_PM_OAI221_X4%B2_r12 x_PM_OAI221_X4%B2_28 x_PM_OAI221_X4%B2_26 0.19
R_x_PM_OAI221_X4%B2_r13 x_PM_OAI221_X4%B2_40 x_PM_OAI221_X4%B2_24 6.5
R_x_PM_OAI221_X4%B2_r14 x_PM_OAI221_X4%B2_24 x_PM_OAI221_X4%B2_37 1.82
R_x_PM_OAI221_X4%B2_r15 x_PM_OAI221_X4%B2_24 x_PM_OAI221_X4%B2_22 25.0012
R_x_PM_OAI221_X4%B2_r16 x_PM_OAI221_X4%B2_22 B2 0.692143
R_x_PM_OAI221_X4%B2_r17 B2 x_PM_OAI221_X4%B2_19 0.0271429
R_x_PM_OAI221_X4%B2_r18 x_PM_OAI221_X4%B2_26 x_PM_OAI221_X4%B2_18 0.095
R_x_PM_OAI221_X4%B2_r19 x_PM_OAI221_X4%B2_19 x_PM_OAI221_X4%B2_17 0.212317
R_x_PM_OAI221_X4%B2_r20 x_PM_OAI221_X4%B2_18 x_PM_OAI221_X4%B2_17 2.28
R_x_PM_OAI221_X4%B2_r21 x_PM_OAI221_X4%B2_40 x_PM_OAI221_X4%B2_13 1.95
R_x_PM_OAI221_X4%B2_r22 N_B2_M18_g x_PM_OAI221_X4%B2_13 71.76
R_x_PM_OAI221_X4%B2_r23 x_PM_OAI221_X4%B2_37 x_PM_OAI221_X4%B2_9 1.95
R_x_PM_OAI221_X4%B2_r24 N_B2_M8_g x_PM_OAI221_X4%B2_9 49.92
R_x_PM_OAI221_X4%B2_r25 x_PM_OAI221_X4%B2_35 x_PM_OAI221_X4%B2_5 1.95
R_x_PM_OAI221_X4%B2_r26 N_B2_M15_g x_PM_OAI221_X4%B2_5 56.16
R_x_PM_OAI221_X4%B2_r27 x_PM_OAI221_X4%B2_32 x_PM_OAI221_X4%B2_VSS 1.95
R_x_PM_OAI221_X4%B2_r28 N_B2_M5_g x_PM_OAI221_X4%B2_VSS 65.52
C_x_PM_OAI221_X4%B1_c0 VSS x_PM_OAI221_X4%B1_31 3.94146e-18
C_x_PM_OAI221_X4%B1_c1 VSS B1 5.19765e-17
C_x_PM_OAI221_X4%B1_c2 VSS x_PM_OAI221_X4%B1_24 2.21819e-17
C_x_PM_OAI221_X4%B1_c3 VSS N_B1_M17_g 3.90977e-17
C_x_PM_OAI221_X4%B1_c4 VSS N_B1_M7_g 3.77844e-17
C_x_PM_OAI221_X4%B1_c5 VSS x_PM_OAI221_X4%B1_12 2.29932e-17
C_x_PM_OAI221_X4%B1_c6 VSS N_B1_M16_g 3.91046e-17
C_x_PM_OAI221_X4%B1_c7 VSS x_PM_OAI221_X4%B1_6 7.5113e-18
C_x_PM_OAI221_X4%B1_c8 VSS x_PM_OAI221_X4%B1_5 8.34009e-18
C_x_PM_OAI221_X4%B1_c9 VSS N_B1_M6_g 4.20133e-17
R_x_PM_OAI221_X4%B1_r10 x_PM_OAI221_X4%B1_31 x_PM_OAI221_X4%B1_29 25.0012
R_x_PM_OAI221_X4%B1_r11 x_PM_OAI221_X4%B1_29 B1 0.101786
R_x_PM_OAI221_X4%B1_r12 x_PM_OAI221_X4%B1_24 x_PM_OAI221_X4%B1_23 11.4
R_x_PM_OAI221_X4%B1_r13 x_PM_OAI221_X4%B1_23 x_PM_OAI221_X4%B1_21 11.4
R_x_PM_OAI221_X4%B1_r14 x_PM_OAI221_X4%B1_24 x_PM_OAI221_X4%B1_17 1.95
R_x_PM_OAI221_X4%B1_r15 N_B1_M17_g x_PM_OAI221_X4%B1_17 35.1
R_x_PM_OAI221_X4%B1_r16 x_PM_OAI221_X4%B1_31 x_PM_OAI221_X4%B1_13 3.71426
R_x_PM_OAI221_X4%B1_r17 N_B1_M7_g x_PM_OAI221_X4%B1_13 42.12
R_x_PM_OAI221_X4%B1_r18 x_PM_OAI221_X4%B1_31 x_PM_OAI221_X4%B1_12 3.71426
R_x_PM_OAI221_X4%B1_r19 x_PM_OAI221_X4%B1_23 x_PM_OAI221_X4%B1_11 1.95
R_x_PM_OAI221_X4%B1_r20 x_PM_OAI221_X4%B1_12 x_PM_OAI221_X4%B1_11 21.45
R_x_PM_OAI221_X4%B1_r21 x_PM_OAI221_X4%B1_21 x_PM_OAI221_X4%B1_7 1.95
R_x_PM_OAI221_X4%B1_r22 N_B1_M16_g x_PM_OAI221_X4%B1_7 35.1
R_x_PM_OAI221_X4%B1_r23 x_PM_OAI221_X4%B1_31 x_PM_OAI221_X4%B1_5 0.532375
R_x_PM_OAI221_X4%B1_r24 x_PM_OAI221_X4%B1_6 x_PM_OAI221_X4%B1_5 11.44
R_x_PM_OAI221_X4%B1_r25 x_PM_OAI221_X4%B1_6 x_PM_OAI221_X4%B1_VSS 4.58872
R_x_PM_OAI221_X4%B1_r26 N_B1_M6_g x_PM_OAI221_X4%B1_VSS 42.12
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X1 VSS VDD B2 C2 C1 ZN B1 A1 A2
*.PININFO VSS:B VDD:B B2:I C2:I C1:I ZN:O B1:I A1:I A2:I
M_M6 N_VDD_M0_d N_B2_M0_g N_4_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 noxref_13 N_C2_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M8 N_ZN_M2_d N_C1_M2_g noxref_13 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M9 N_4_M3_d N_B1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M10 noxref_14 N_A1_M4_g N_ZN_M4_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M11 N_VDD_M5_d N_A2_M5_g noxref_14 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_6_M6_d N_B2_M6_g N_5_M6_s VSS NMOS_VTL W=0.170000U L=0.050000U
M_M1 N_VSS_M7_d N_C2_M7_g N_6_M6_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M2 N_6_M8_d N_C1_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M3 N_5_M9_d N_B1_M9_g N_6_M8_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M4 N_ZN_M10_d N_A1_M10_g N_5_M9_d VSS NMOS_VTL W=0.170000U L=0.050000U
M_M5 N_5_M11_d N_A2_M11_g N_ZN_M10_d VSS NMOS_VTL W=0.170000U L=0.050000U
C_x_PM_OAI222_X1%VSS_c0 VSS x_PM_OAI222_X1%VSS_12 5.02677e-17
C_x_PM_OAI222_X1%VSS_c1 VSS VSS 1.57277e-16
C_x_PM_OAI222_X1%VSS_c2 VSS N_VSS_M7_d 4.11709e-17
R_x_PM_OAI222_X1%VSS_r3 x_PM_OAI222_X1%VSS_12 x_PM_OAI222_X1%VSS_8 0.0731438
R_x_PM_OAI222_X1%VSS_r4 VSS x_PM_OAI222_X1%VSS_8 0.38
R_x_PM_OAI222_X1%VSS_r5 x_PM_OAI222_X1%VSS_12 x_PM_OAI222_X1%VSS_4 0.145286
R_x_PM_OAI222_X1%VSS_r6 N_VSS_M7_d x_PM_OAI222_X1%VSS_4 0.936429
C_x_PM_OAI222_X1%VDD_c0 VSS x_PM_OAI222_X1%VDD_17 2.93189e-18
C_x_PM_OAI222_X1%VDD_c1 VSS N_VDD_M5_d 3.52519e-17
C_x_PM_OAI222_X1%VDD_c2 VSS x_PM_OAI222_X1%VDD_11 1.50522e-16
C_x_PM_OAI222_X1%VDD_c3 VSS N_VDD_M0_d 3.69581e-17
C_x_PM_OAI222_X1%VDD_c4 VSS x_PM_OAI222_X1%VDD_3 3.05434e-17
R_x_PM_OAI222_X1%VDD_r5 N_VDD_M5_d x_PM_OAI222_X1%VDD_13 2.185
R_x_PM_OAI222_X1%VDD_r6 x_PM_OAI222_X1%VDD_17 x_PM_OAI222_X1%VDD_12 0.0731438
R_x_PM_OAI222_X1%VDD_r7 x_PM_OAI222_X1%VDD_13 x_PM_OAI222_X1%VDD_11 0.264221
R_x_PM_OAI222_X1%VDD_r8 x_PM_OAI222_X1%VDD_12 x_PM_OAI222_X1%VDD_11 2.23529
R_x_PM_OAI222_X1%VDD_r9 x_PM_OAI222_X1%VDD_17 x_PM_OAI222_X1%VDD_7 0.145286
R_x_PM_OAI222_X1%VDD_r10 N_VDD_M0_d x_PM_OAI222_X1%VDD_7 0.800714
R_x_PM_OAI222_X1%VDD_r11 x_PM_OAI222_X1%VDD_17 x_PM_OAI222_X1%VDD_3 0.0731438
R_x_PM_OAI222_X1%VDD_r12 VDD x_PM_OAI222_X1%VDD_3 0.346471
C_x_PM_OAI222_X1%B2_c0 VSS x_PM_OAI222_X1%B2_14 7.70435e-18
C_x_PM_OAI222_X1%B2_c1 VSS x_PM_OAI222_X1%B2_12 4.85005e-17
C_x_PM_OAI222_X1%B2_c2 VSS N_B2_M6_g 6.05422e-17
C_x_PM_OAI222_X1%B2_c3 VSS N_B2_M0_g 4.70735e-17
R_x_PM_OAI222_X1%B2_r4 x_PM_OAI222_X1%B2_18 x_PM_OAI222_X1%B2_14 4.7687
R_x_PM_OAI222_X1%B2_r5 x_PM_OAI222_X1%B2_17 x_PM_OAI222_X1%B2_14 4.7687
R_x_PM_OAI222_X1%B2_r6 x_PM_OAI222_X1%B2_14 x_PM_OAI222_X1%B2_12 25.0012
R_x_PM_OAI222_X1%B2_r7 x_PM_OAI222_X1%B2_12 B2 0.454643
R_x_PM_OAI222_X1%B2_r8 N_B2_M6_g x_PM_OAI222_X1%B2_17 66.3
R_x_PM_OAI222_X1%B2_r9 N_B2_M0_g x_PM_OAI222_X1%B2_18 47.19
C_x_PM_OAI222_X1%4_c0 VSS x_PM_OAI222_X1%4_10 5.44024e-17
C_x_PM_OAI222_X1%4_c1 VSS x_PM_OAI222_X1%4_5 1.81195e-17
C_x_PM_OAI222_X1%4_c2 VSS x_PM_OAI222_X1%4_3 1.0228e-16
R_x_PM_OAI222_X1%4_r3 N_4_M0_s x_PM_OAI222_X1%4_5 0.257857
R_x_PM_OAI222_X1%4_r4 x_PM_OAI222_X1%4_5 x_PM_OAI222_X1%4_4 0.095
R_x_PM_OAI222_X1%4_r5 x_PM_OAI222_X1%4_10 x_PM_OAI222_X1%4_3 0.095
R_x_PM_OAI222_X1%4_r6 x_PM_OAI222_X1%4_4 x_PM_OAI222_X1%4_3 3.69143
R_x_PM_OAI222_X1%4_r7 N_4_M3_d x_PM_OAI222_X1%4_10 0.257857
C_x_PM_OAI222_X1%5_c0 VSS x_PM_OAI222_X1%5_22 9.34911e-18
C_x_PM_OAI222_X1%5_c1 VSS x_PM_OAI222_X1%5_17 2.68823e-17
C_x_PM_OAI222_X1%5_c2 VSS x_PM_OAI222_X1%5_16 1.01275e-16
C_x_PM_OAI222_X1%5_c3 VSS x_PM_OAI222_X1%5_15 2.94878e-17
C_x_PM_OAI222_X1%5_c4 VSS N_5_M9_d 4.51382e-18
C_x_PM_OAI222_X1%5_c5 VSS x_PM_OAI222_X1%5_9 1.0827e-17
C_x_PM_OAI222_X1%5_c6 VSS x_PM_OAI222_X1%5_8 1.59664e-16
C_x_PM_OAI222_X1%5_c7 VSS N_5_M6_s 2.83888e-17
C_x_PM_OAI222_X1%5_c8 VSS N_5_M11_d 2.01046e-17
R_x_PM_OAI222_X1%5_r9 x_PM_OAI222_X1%5_18 x_PM_OAI222_X1%5_16 0.212317
R_x_PM_OAI222_X1%5_r10 x_PM_OAI222_X1%5_17 x_PM_OAI222_X1%5_16 1.68286
R_x_PM_OAI222_X1%5_r11 x_PM_OAI222_X1%5_15 x_PM_OAI222_X1%5_22 1.08571
R_x_PM_OAI222_X1%5_r12 x_PM_OAI222_X1%5_22 x_PM_OAI222_X1%5_11 0.217071
R_x_PM_OAI222_X1%5_r13 N_5_M9_d x_PM_OAI222_X1%5_11 0.08
R_x_PM_OAI222_X1%5_r14 x_PM_OAI222_X1%5_17 x_PM_OAI222_X1%5_10 0.218718
R_x_PM_OAI222_X1%5_r15 N_5_M9_d x_PM_OAI222_X1%5_10 0.15
R_x_PM_OAI222_X1%5_r16 x_PM_OAI222_X1%5_15 x_PM_OAI222_X1%5_8 0.212317
R_x_PM_OAI222_X1%5_r17 x_PM_OAI222_X1%5_9 x_PM_OAI222_X1%5_8 3.55571
R_x_PM_OAI222_X1%5_r18 x_PM_OAI222_X1%5_9 x_PM_OAI222_X1%5_4 0.212317
R_x_PM_OAI222_X1%5_r19 N_5_M6_s x_PM_OAI222_X1%5_4 0.936429
R_x_PM_OAI222_X1%5_r20 N_5_M11_d x_PM_OAI222_X1%5_18 0.203571
C_x_PM_OAI222_X1%6_c0 VSS x_PM_OAI222_X1%6_8 2.26032e-17
C_x_PM_OAI222_X1%6_c1 VSS x_PM_OAI222_X1%6_7 1.0203e-16
C_x_PM_OAI222_X1%6_c2 VSS N_6_M6_d 1.80835e-17
C_x_PM_OAI222_X1%6_c3 VSS N_6_M8_d 1.95874e-17
R_x_PM_OAI222_X1%6_r4 x_PM_OAI222_X1%6_9 x_PM_OAI222_X1%6_7 0.212317
R_x_PM_OAI222_X1%6_r5 x_PM_OAI222_X1%6_8 x_PM_OAI222_X1%6_7 1.62857
R_x_PM_OAI222_X1%6_r6 x_PM_OAI222_X1%6_8 x_PM_OAI222_X1%6_3 0.212317
R_x_PM_OAI222_X1%6_r7 N_6_M6_d x_PM_OAI222_X1%6_3 0.203571
R_x_PM_OAI222_X1%6_r8 N_6_M8_d x_PM_OAI222_X1%6_9 0.203571
C_x_PM_OAI222_X1%C2_c0 VSS C2 3.8514e-17
C_x_PM_OAI222_X1%C2_c1 VSS x_PM_OAI222_X1%C2_11 9.0059e-18
C_x_PM_OAI222_X1%C2_c2 VSS N_C2_M7_g 6.29881e-17
C_x_PM_OAI222_X1%C2_c3 VSS N_C2_M1_g 4.80705e-17
R_x_PM_OAI222_X1%C2_r4 x_PM_OAI222_X1%C2_18 x_PM_OAI222_X1%C2_11 4.7687
R_x_PM_OAI222_X1%C2_r5 x_PM_OAI222_X1%C2_17 x_PM_OAI222_X1%C2_11 4.7687
R_x_PM_OAI222_X1%C2_r6 x_PM_OAI222_X1%C2_11 x_PM_OAI222_X1%C2_9 25.0012
R_x_PM_OAI222_X1%C2_r7 C2 x_PM_OAI222_X1%C2_9 0.0610714
R_x_PM_OAI222_X1%C2_r8 N_C2_M7_g x_PM_OAI222_X1%C2_17 66.3
R_x_PM_OAI222_X1%C2_r9 N_C2_M1_g x_PM_OAI222_X1%C2_18 47.19
C_x_PM_OAI222_X1%C1_c0 VSS x_PM_OAI222_X1%C1_14 8.19646e-18
C_x_PM_OAI222_X1%C1_c1 VSS C1 6.31641e-17
C_x_PM_OAI222_X1%C1_c2 VSS N_C1_M8_g 6.62356e-17
C_x_PM_OAI222_X1%C1_c3 VSS N_C1_M2_g 4.57642e-17
R_x_PM_OAI222_X1%C1_r4 x_PM_OAI222_X1%C1_18 x_PM_OAI222_X1%C1_14 4.7687
R_x_PM_OAI222_X1%C1_r5 x_PM_OAI222_X1%C1_17 x_PM_OAI222_X1%C1_14 4.7687
R_x_PM_OAI222_X1%C1_r6 x_PM_OAI222_X1%C1_14 x_PM_OAI222_X1%C1_12 25.0012
R_x_PM_OAI222_X1%C1_r7 x_PM_OAI222_X1%C1_12 C1 0.0882143
R_x_PM_OAI222_X1%C1_r8 N_C1_M8_g x_PM_OAI222_X1%C1_17 71.76
R_x_PM_OAI222_X1%C1_r9 N_C1_M2_g x_PM_OAI222_X1%C1_18 41.73
C_x_PM_OAI222_X1%ZN_c0 VSS x_PM_OAI222_X1%ZN_26 5.11424e-17
C_x_PM_OAI222_X1%ZN_c1 VSS x_PM_OAI222_X1%ZN_21 3.86451e-17
C_x_PM_OAI222_X1%ZN_c2 VSS N_ZN_M2_d 3.81423e-17
C_x_PM_OAI222_X1%ZN_c3 VSS x_PM_OAI222_X1%ZN_11 7.31091e-17
C_x_PM_OAI222_X1%ZN_c4 VSS ZN 4.789e-17
C_x_PM_OAI222_X1%ZN_c5 VSS x_PM_OAI222_X1%ZN_4 8.60103e-17
R_x_PM_OAI222_X1%ZN_r6 x_PM_OAI222_X1%ZN_26 N_ZN_M10_d 0.133704
R_x_PM_OAI222_X1%ZN_r7 x_PM_OAI222_X1%ZN_21 x_PM_OAI222_X1%ZN_20 0.732857
R_x_PM_OAI222_X1%ZN_r8 x_PM_OAI222_X1%ZN_20 N_ZN_M4_s 0.0135714
R_x_PM_OAI222_X1%ZN_r9 x_PM_OAI222_X1%ZN_15 N_ZN_M2_d 0.257857
R_x_PM_OAI222_X1%ZN_r10 x_PM_OAI222_X1%ZN_21 x_PM_OAI222_X1%ZN_11 0.095
R_x_PM_OAI222_X1%ZN_r11 x_PM_OAI222_X1%ZN_26 x_PM_OAI222_X1%ZN_10 0.095
R_x_PM_OAI222_X1%ZN_r12 x_PM_OAI222_X1%ZN_11 x_PM_OAI222_X1%ZN_10 1.87286
R_x_PM_OAI222_X1%ZN_r13 ZN x_PM_OAI222_X1%ZN_7 1.46571
R_x_PM_OAI222_X1%ZN_r14 x_PM_OAI222_X1%ZN_20 x_PM_OAI222_X1%ZN_6 0.095
R_x_PM_OAI222_X1%ZN_r15 ZN x_PM_OAI222_X1%ZN_6 0.407143
R_x_PM_OAI222_X1%ZN_r16 x_PM_OAI222_X1%ZN_15 x_PM_OAI222_X1%ZN_5 0.095
R_x_PM_OAI222_X1%ZN_r17 x_PM_OAI222_X1%ZN_7 x_PM_OAI222_X1%ZN_4 0.212317
R_x_PM_OAI222_X1%ZN_r18 x_PM_OAI222_X1%ZN_5 x_PM_OAI222_X1%ZN_4 1.33
C_x_PM_OAI222_X1%B1_c0 VSS B1 4.27491e-17
C_x_PM_OAI222_X1%B1_c1 VSS x_PM_OAI222_X1%B1_11 8.36801e-18
C_x_PM_OAI222_X1%B1_c2 VSS N_B1_M9_g 5.89384e-17
C_x_PM_OAI222_X1%B1_c3 VSS N_B1_M3_g 5.5233e-17
R_x_PM_OAI222_X1%B1_r4 x_PM_OAI222_X1%B1_18 x_PM_OAI222_X1%B1_11 4.7687
R_x_PM_OAI222_X1%B1_r5 x_PM_OAI222_X1%B1_17 x_PM_OAI222_X1%B1_11 4.7687
R_x_PM_OAI222_X1%B1_r6 x_PM_OAI222_X1%B1_11 x_PM_OAI222_X1%B1_9 25.0012
R_x_PM_OAI222_X1%B1_r7 B1 x_PM_OAI222_X1%B1_9 0.0610714
R_x_PM_OAI222_X1%B1_r8 N_B1_M9_g x_PM_OAI222_X1%B1_17 67.08
R_x_PM_OAI222_X1%B1_r9 N_B1_M3_g x_PM_OAI222_X1%B1_18 46.41
C_x_PM_OAI222_X1%A1_c0 VSS x_PM_OAI222_X1%A1_19 1.92347e-17
C_x_PM_OAI222_X1%A1_c1 VSS x_PM_OAI222_X1%A1_9 4.69955e-17
C_x_PM_OAI222_X1%A1_c2 VSS N_A1_M4_g 4.22803e-17
C_x_PM_OAI222_X1%A1_c3 VSS N_A1_M10_g 4.47316e-17
R_x_PM_OAI222_X1%A1_r4 x_PM_OAI222_X1%A1_19 x_PM_OAI222_X1%A1_11 9.1
R_x_PM_OAI222_X1%A1_r5 x_PM_OAI222_X1%A1_11 x_PM_OAI222_X1%A1_16 1.3
R_x_PM_OAI222_X1%A1_r6 x_PM_OAI222_X1%A1_11 x_PM_OAI222_X1%A1_9 25.0012
R_x_PM_OAI222_X1%A1_r7 A1 x_PM_OAI222_X1%A1_9 0.0135714
R_x_PM_OAI222_X1%A1_r8 x_PM_OAI222_X1%A1_19 x_PM_OAI222_X1%A1_5 1.95
R_x_PM_OAI222_X1%A1_r9 N_A1_M4_g x_PM_OAI222_X1%A1_5 29.25
R_x_PM_OAI222_X1%A1_r10 x_PM_OAI222_X1%A1_16 x_PM_OAI222_X1%A1_VSS 1.95
R_x_PM_OAI222_X1%A1_r11 N_A1_M10_g x_PM_OAI222_X1%A1_VSS 44.46
C_x_PM_OAI222_X1%A2_c0 VSS A2 5.06461e-17
C_x_PM_OAI222_X1%A2_c1 VSS x_PM_OAI222_X1%A2_11 1.66273e-17
C_x_PM_OAI222_X1%A2_c2 VSS N_A2_M5_g 4.396e-17
C_x_PM_OAI222_X1%A2_c3 VSS N_A2_M11_g 3.61543e-17
R_x_PM_OAI222_X1%A2_r4 x_PM_OAI222_X1%A2_18 x_PM_OAI222_X1%A2_11 1.34483
R_x_PM_OAI222_X1%A2_r5 x_PM_OAI222_X1%A2_11 x_PM_OAI222_X1%A2_16 9.41379
R_x_PM_OAI222_X1%A2_r6 x_PM_OAI222_X1%A2_11 x_PM_OAI222_X1%A2_9 25.0012
R_x_PM_OAI222_X1%A2_r7 A2 x_PM_OAI222_X1%A2_9 0.294828
R_x_PM_OAI222_X1%A2_r8 x_PM_OAI222_X1%A2_18 x_PM_OAI222_X1%A2_5 2.55517
R_x_PM_OAI222_X1%A2_r9 N_A2_M5_g x_PM_OAI222_X1%A2_5 49.53
R_x_PM_OAI222_X1%A2_r10 x_PM_OAI222_X1%A2_16 x_PM_OAI222_X1%A2_VSS 2.55517
R_x_PM_OAI222_X1%A2_r11 N_A2_M11_g x_PM_OAI222_X1%A2_VSS 21.06
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X2 VSS VDD B2 C2 C1 ZN B1 A1 A2
*.PININFO VSS:B VDD:B B2:I C2:I C1:I ZN:O B1:I A1:I A2:I
M_M6 N_VDD_M0_d N_B2_M0_g N_5_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 noxref_13 N_C2_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M8 N_ZN_M2_d N_C1_M2_g noxref_13 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_5_M3_d N_B1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 noxref_14 N_A1_M4_g N_ZN_M4_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_VDD_M5_d N_A2_M5_g noxref_14 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_6_M6_d N_B2_M6_g N_4_M6_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_VSS_M7_d N_C2_M7_g N_6_M6_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_6_M8_d N_C1_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_4_M9_d N_B1_M9_g N_6_M8_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 N_ZN_M10_d N_A1_M10_g N_4_M9_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M5 N_4_M11_d N_A2_M11_g N_ZN_M10_d VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI222_X2%VSS_c0 VSS N_VSS_M7_d 5.94565e-17
C_x_PM_OAI222_X2%VSS_c1 VSS x_PM_OAI222_X2%VSS_4 1.62464e-16
R_x_PM_OAI222_X2%VSS_r2 x_PM_OAI222_X2%VSS_4 N_VSS_M7_d 0.140674
R_x_PM_OAI222_X2%VSS_r3 VSS x_PM_OAI222_X2%VSS_4 0.38
C_x_PM_OAI222_X2%VDD_c0 VSS x_PM_OAI222_X2%VDD_17 2.70113e-18
C_x_PM_OAI222_X2%VDD_c1 VSS N_VDD_M5_d 2.59335e-17
C_x_PM_OAI222_X2%VDD_c2 VSS x_PM_OAI222_X2%VDD_11 1.23765e-16
C_x_PM_OAI222_X2%VDD_c3 VSS N_VDD_M0_d 4.82979e-17
C_x_PM_OAI222_X2%VDD_c4 VSS x_PM_OAI222_X2%VDD_3 3.28865e-17
R_x_PM_OAI222_X2%VDD_r5 N_VDD_M5_d x_PM_OAI222_X2%VDD_13 0.230714
R_x_PM_OAI222_X2%VDD_r6 x_PM_OAI222_X2%VDD_17 x_PM_OAI222_X2%VDD_12 0.0731438
R_x_PM_OAI222_X2%VDD_r7 x_PM_OAI222_X2%VDD_13 x_PM_OAI222_X2%VDD_11 0.264221
R_x_PM_OAI222_X2%VDD_r8 x_PM_OAI222_X2%VDD_12 x_PM_OAI222_X2%VDD_11 2.32471
R_x_PM_OAI222_X2%VDD_r9 x_PM_OAI222_X2%VDD_17 x_PM_OAI222_X2%VDD_7 0.145286
R_x_PM_OAI222_X2%VDD_r10 N_VDD_M0_d x_PM_OAI222_X2%VDD_7 0.230714
R_x_PM_OAI222_X2%VDD_r11 x_PM_OAI222_X2%VDD_17 x_PM_OAI222_X2%VDD_3 0.0731438
R_x_PM_OAI222_X2%VDD_r12 VDD x_PM_OAI222_X2%VDD_3 0.301765
C_x_PM_OAI222_X2%B2_c0 VSS x_PM_OAI222_X2%B2_14 7.39346e-18
C_x_PM_OAI222_X2%B2_c1 VSS x_PM_OAI222_X2%B2_12 2.99752e-17
C_x_PM_OAI222_X2%B2_c2 VSS N_B2_M6_g 5.32806e-17
C_x_PM_OAI222_X2%B2_c3 VSS N_B2_M0_g 7.22113e-17
R_x_PM_OAI222_X2%B2_r4 x_PM_OAI222_X2%B2_18 x_PM_OAI222_X2%B2_14 4.7687
R_x_PM_OAI222_X2%B2_r5 x_PM_OAI222_X2%B2_17 x_PM_OAI222_X2%B2_14 4.7687
R_x_PM_OAI222_X2%B2_r6 x_PM_OAI222_X2%B2_14 x_PM_OAI222_X2%B2_12 25.0012
R_x_PM_OAI222_X2%B2_r7 x_PM_OAI222_X2%B2_12 B2 0.359643
R_x_PM_OAI222_X2%B2_r8 N_B2_M6_g x_PM_OAI222_X2%B2_17 51.48
R_x_PM_OAI222_X2%B2_r9 N_B2_M0_g x_PM_OAI222_X2%B2_18 70.2
C_x_PM_OAI222_X2%4_c0 VSS N_4_M11_d 2.62427e-16
R_x_PM_OAI222_X2%4_r1 N_4_M9_d N_4_M6_s 4.12571
R_x_PM_OAI222_X2%4_r2 N_4_M11_d N_4_M9_d 2.03571
C_x_PM_OAI222_X2%5_c0 VSS x_PM_OAI222_X2%5_7 5.85323e-18
C_x_PM_OAI222_X2%5_c1 VSS N_5_M0_s 3.0068e-17
C_x_PM_OAI222_X2%5_c2 VSS N_5_M3_d 1.14491e-16
R_x_PM_OAI222_X2%5_r3 x_PM_OAI222_X2%5_7 x_PM_OAI222_X2%5_3 0.212317
R_x_PM_OAI222_X2%5_r4 N_5_M0_s x_PM_OAI222_X2%5_3 0.746429
R_x_PM_OAI222_X2%5_r5 N_5_M3_d x_PM_OAI222_X2%5_7 3.895
C_x_PM_OAI222_X2%6_c0 VSS N_6_M8_d 1.2479e-16
R_x_PM_OAI222_X2%6_r1 N_6_M8_d N_6_M6_d 2.03571
C_x_PM_OAI222_X2%C2_c0 VSS C2 2.97627e-17
C_x_PM_OAI222_X2%C2_c1 VSS x_PM_OAI222_X2%C2_11 8.8889e-18
C_x_PM_OAI222_X2%C2_c2 VSS N_C2_M7_g 6.09995e-17
C_x_PM_OAI222_X2%C2_c3 VSS N_C2_M1_g 7.15106e-17
R_x_PM_OAI222_X2%C2_r4 x_PM_OAI222_X2%C2_18 x_PM_OAI222_X2%C2_11 4.7687
R_x_PM_OAI222_X2%C2_r5 x_PM_OAI222_X2%C2_17 x_PM_OAI222_X2%C2_11 4.7687
R_x_PM_OAI222_X2%C2_r6 x_PM_OAI222_X2%C2_11 x_PM_OAI222_X2%C2_9 25.0012
R_x_PM_OAI222_X2%C2_r7 C2 x_PM_OAI222_X2%C2_9 0.156071
R_x_PM_OAI222_X2%C2_r8 N_C2_M7_g x_PM_OAI222_X2%C2_17 51.48
R_x_PM_OAI222_X2%C2_r9 N_C2_M1_g x_PM_OAI222_X2%C2_18 70.2
C_x_PM_OAI222_X2%C1_c0 VSS C1 2.81602e-17
C_x_PM_OAI222_X2%C1_c1 VSS x_PM_OAI222_X2%C1_11 8.7575e-18
C_x_PM_OAI222_X2%C1_c2 VSS N_C1_M8_g 7.4865e-17
C_x_PM_OAI222_X2%C1_c3 VSS N_C1_M2_g 5.90752e-17
R_x_PM_OAI222_X2%C1_r4 x_PM_OAI222_X2%C1_18 x_PM_OAI222_X2%C1_11 4.7687
R_x_PM_OAI222_X2%C1_r5 x_PM_OAI222_X2%C1_17 x_PM_OAI222_X2%C1_11 4.7687
R_x_PM_OAI222_X2%C1_r6 x_PM_OAI222_X2%C1_11 x_PM_OAI222_X2%C1_9 25.0012
R_x_PM_OAI222_X2%C1_r7 C1 x_PM_OAI222_X2%C1_9 0.156071
R_x_PM_OAI222_X2%C1_r8 N_C1_M8_g x_PM_OAI222_X2%C1_17 73.32
R_x_PM_OAI222_X2%C1_r9 N_C1_M2_g x_PM_OAI222_X2%C1_18 48.36
C_x_PM_OAI222_X2%ZN_c0 VSS x_PM_OAI222_X2%ZN_18 1.05943e-16
C_x_PM_OAI222_X2%ZN_c1 VSS ZN 4.02813e-17
C_x_PM_OAI222_X2%ZN_c2 VSS x_PM_OAI222_X2%ZN_10 5.84384e-17
C_x_PM_OAI222_X2%ZN_c3 VSS x_PM_OAI222_X2%ZN_4 8.23308e-17
R_x_PM_OAI222_X2%ZN_r4 x_PM_OAI222_X2%ZN_19 ZN 0.2432
R_x_PM_OAI222_X2%ZN_r5 x_PM_OAI222_X2%ZN_18 ZN 0.28578
R_x_PM_OAI222_X2%ZN_r6 x_PM_OAI222_X2%ZN_18 x_PM_OAI222_X2%ZN_14 2.98571
R_x_PM_OAI222_X2%ZN_r7 x_PM_OAI222_X2%ZN_14 x_PM_OAI222_X2%ZN_10 0.212317
R_x_PM_OAI222_X2%ZN_r8 N_ZN_M10_d x_PM_OAI222_X2%ZN_10 0.257857
R_x_PM_OAI222_X2%ZN_r9 N_ZN_M4_s N_ZN_M2_d 1.9
R_x_PM_OAI222_X2%ZN_r10 x_PM_OAI222_X2%ZN_19 x_PM_OAI222_X2%ZN_4 0.095
R_x_PM_OAI222_X2%ZN_r11 N_ZN_M4_s x_PM_OAI222_X2%ZN_4 0.556429
C_x_PM_OAI222_X2%B1_c0 VSS B1 3.10152e-17
C_x_PM_OAI222_X2%B1_c1 VSS x_PM_OAI222_X2%B1_11 8.82989e-18
C_x_PM_OAI222_X2%B1_c2 VSS N_B1_M9_g 5.7947e-17
C_x_PM_OAI222_X2%B1_c3 VSS N_B1_M3_g 7.56838e-17
R_x_PM_OAI222_X2%B1_r4 x_PM_OAI222_X2%B1_18 x_PM_OAI222_X2%B1_11 4.7687
R_x_PM_OAI222_X2%B1_r5 x_PM_OAI222_X2%B1_17 x_PM_OAI222_X2%B1_11 4.7687
R_x_PM_OAI222_X2%B1_r6 x_PM_OAI222_X2%B1_11 x_PM_OAI222_X2%B1_9 25.0012
R_x_PM_OAI222_X2%B1_r7 B1 x_PM_OAI222_X2%B1_9 0.156071
R_x_PM_OAI222_X2%B1_r8 N_B1_M9_g x_PM_OAI222_X2%B1_17 51.48
R_x_PM_OAI222_X2%B1_r9 N_B1_M3_g x_PM_OAI222_X2%B1_18 70.2
C_x_PM_OAI222_X2%A1_c0 VSS A1 5.87885e-17
C_x_PM_OAI222_X2%A1_c1 VSS N_A1_M4_g 7.75066e-17
C_x_PM_OAI222_X2%A1_c2 VSS x_PM_OAI222_X2%A1_5 1.56527e-17
C_x_PM_OAI222_X2%A1_c3 VSS N_A1_M10_g 6.21546e-17
C_x_PM_OAI222_X2%A1_c4 VSS x_PM_OAI222_X2%A1_VSS 5.57862e-18
R_x_PM_OAI222_X2%A1_r5 x_PM_OAI222_X2%A1_16 x_PM_OAI222_X2%A1_14 25.0012
R_x_PM_OAI222_X2%A1_r6 x_PM_OAI222_X2%A1_14 A1 0.1995
R_x_PM_OAI222_X2%A1_r7 N_A1_M4_g x_PM_OAI222_X2%A1_7 61.62
R_x_PM_OAI222_X2%A1_r8 x_PM_OAI222_X2%A1_16 x_PM_OAI222_X2%A1_6 0.917744
R_x_PM_OAI222_X2%A1_r9 x_PM_OAI222_X2%A1_7 x_PM_OAI222_X2%A1_5 4.58872
R_x_PM_OAI222_X2%A1_r10 x_PM_OAI222_X2%A1_6 x_PM_OAI222_X2%A1_5 8.84
R_x_PM_OAI222_X2%A1_r11 x_PM_OAI222_X2%A1_16 x_PM_OAI222_X2%A1_VSS 3.67098
R_x_PM_OAI222_X2%A1_r12 N_A1_M10_g x_PM_OAI222_X2%A1_VSS 60.06
C_x_PM_OAI222_X2%A2_c0 VSS A2 5.44292e-17
C_x_PM_OAI222_X2%A2_c1 VSS N_A2_M5_g 7.7292e-17
C_x_PM_OAI222_X2%A2_c2 VSS x_PM_OAI222_X2%A2_7 3.53203e-18
C_x_PM_OAI222_X2%A2_c3 VSS x_PM_OAI222_X2%A2_6 8.80197e-18
C_x_PM_OAI222_X2%A2_c4 VSS x_PM_OAI222_X2%A2_5 8.15706e-18
C_x_PM_OAI222_X2%A2_c5 VSS N_A2_M11_g 4.84671e-17
R_x_PM_OAI222_X2%A2_r6 x_PM_OAI222_X2%A2_13 x_PM_OAI222_X2%A2_11 25.0012
R_x_PM_OAI222_X2%A2_r7 A2 x_PM_OAI222_X2%A2_11 0.251471
R_x_PM_OAI222_X2%A2_r8 x_PM_OAI222_X2%A2_13 x_PM_OAI222_X2%A2_7 3.67098
R_x_PM_OAI222_X2%A2_r9 N_A2_M5_g x_PM_OAI222_X2%A2_7 86.58
R_x_PM_OAI222_X2%A2_r10 x_PM_OAI222_X2%A2_13 x_PM_OAI222_X2%A2_5 0.917744
R_x_PM_OAI222_X2%A2_r11 x_PM_OAI222_X2%A2_6 x_PM_OAI222_X2%A2_5 8.84
R_x_PM_OAI222_X2%A2_r12 x_PM_OAI222_X2%A2_6 x_PM_OAI222_X2%A2_VSS 4.58872
R_x_PM_OAI222_X2%A2_r13 N_A2_M11_g x_PM_OAI222_X2%A2_VSS 35.1
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI222_X4.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI222_X4 VSS VDD B2 C2 C1 ZN B1 A1 A2
*.PININFO VSS:B VDD:B C2:I C1:I ZN:O B2:I B1:I A1:I A2:I
M_M12 12 N_C2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M13 N_ZN_M1_d N_C1_M1_g 12 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M14 13 N_C1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M15 N_VDD_M3_d N_C2_M3_g 13 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M16 14 N_B2_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M17 N_ZN_M5_d N_B1_M5_g 14 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M18 15 N_B1_M6_g N_ZN_M5_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M19 N_VDD_M7_d N_B2_M7_g 15 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M20 16 N_A1_M8_g N_ZN_M8_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M21 N_VDD_M9_d N_A2_M9_g 16 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M22 17 N_A2_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M23 N_ZN_M11_d N_A1_M11_g 17 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_VSS_M12_d N_C2_M12_g N_3_M12_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M1 N_3_M13_d N_C1_M13_g N_VSS_M12_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M2 N_VSS_M14_d N_C1_M14_g N_3_M13_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M3 N_3_M15_d N_C2_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M4 N_8_M16_d N_B2_M16_g N_3_M15_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M5 N_3_M17_d N_B1_M17_g N_8_M16_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M6 N_8_M18_d N_B1_M18_g N_3_M17_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M7 N_3_M19_d N_B2_M19_g N_8_M18_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M8 N_8_M20_d N_A1_M20_g N_ZN_M20_s VSS NMOS_VTL W=0.340000U L=0.050000U
M_M9 N_ZN_M21_d N_A2_M21_g N_8_M20_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M10 N_8_M22_d N_A2_M22_g N_ZN_M21_d VSS NMOS_VTL W=0.340000U L=0.050000U
M_M11 N_ZN_M23_d N_A1_M23_g N_8_M22_d VSS NMOS_VTL W=0.340000U L=0.050000U
C_x_PM_OAI222_X4%VSS_c0 VSS x_PM_OAI222_X4%VSS_20 2.64443e-18
C_x_PM_OAI222_X4%VSS_c1 VSS x_PM_OAI222_X4%VSS_19 4.14978e-17
C_x_PM_OAI222_X4%VSS_c2 VSS VSS 4.40055e-16
C_x_PM_OAI222_X4%VSS_c3 VSS N_VSS_M14_d 1.89835e-17
C_x_PM_OAI222_X4%VSS_c4 VSS x_PM_OAI222_X4%VSS_9 3.39029e-17
C_x_PM_OAI222_X4%VSS_c5 VSS N_VSS_M12_d 2.10348e-17
R_x_PM_OAI222_X4%VSS_r6 x_PM_OAI222_X4%VSS_20 x_PM_OAI222_X4%VSS_15 0.0731438
R_x_PM_OAI222_X4%VSS_r7 VSS x_PM_OAI222_X4%VSS_15 1.45294
R_x_PM_OAI222_X4%VSS_r8 x_PM_OAI222_X4%VSS_20 x_PM_OAI222_X4%VSS_11 0.145286
R_x_PM_OAI222_X4%VSS_r9 N_VSS_M14_d x_PM_OAI222_X4%VSS_11 0.230714
R_x_PM_OAI222_X4%VSS_r10 x_PM_OAI222_X4%VSS_19 x_PM_OAI222_X4%VSS_10 0.0731438
R_x_PM_OAI222_X4%VSS_r11 x_PM_OAI222_X4%VSS_20 x_PM_OAI222_X4%VSS_9 0.0731438
R_x_PM_OAI222_X4%VSS_r12 x_PM_OAI222_X4%VSS_10 x_PM_OAI222_X4%VSS_9 0.692941
R_x_PM_OAI222_X4%VSS_r13 x_PM_OAI222_X4%VSS_19 x_PM_OAI222_X4%VSS_5 0.145286
R_x_PM_OAI222_X4%VSS_r14 N_VSS_M12_d x_PM_OAI222_X4%VSS_5 0.230714
C_x_PM_OAI222_X4%VDD_c0 VSS x_PM_OAI222_X4%VDD_32 5.62277e-17
C_x_PM_OAI222_X4%VDD_c1 VSS x_PM_OAI222_X4%VDD_31 2.69652e-18
C_x_PM_OAI222_X4%VDD_c2 VSS x_PM_OAI222_X4%VDD_30 2.64443e-18
C_x_PM_OAI222_X4%VDD_c3 VSS N_VDD_M9_d 2.14289e-17
C_x_PM_OAI222_X4%VDD_c4 VSS x_PM_OAI222_X4%VDD_21 5.21981e-17
C_x_PM_OAI222_X4%VDD_c5 VSS N_VDD_M7_d 1.81529e-17
C_x_PM_OAI222_X4%VDD_c6 VSS x_PM_OAI222_X4%VDD_15 7.54361e-17
C_x_PM_OAI222_X4%VDD_c7 VSS N_VDD_M3_d 1.96252e-17
C_x_PM_OAI222_X4%VDD_c8 VSS x_PM_OAI222_X4%VDD_9 6.78722e-17
C_x_PM_OAI222_X4%VDD_c9 VSS N_VDD_M0_s 2.10952e-17
C_x_PM_OAI222_X4%VDD_c10 VSS x_PM_OAI222_X4%VDD_5 1.08375e-17
R_x_PM_OAI222_X4%VDD_r11 x_PM_OAI222_X4%VDD_32 x_PM_OAI222_X4%VDD_23 0.145286
R_x_PM_OAI222_X4%VDD_r12 N_VDD_M9_d x_PM_OAI222_X4%VDD_23 0.230714
R_x_PM_OAI222_X4%VDD_r13 x_PM_OAI222_X4%VDD_31 x_PM_OAI222_X4%VDD_22 0.0731438
R_x_PM_OAI222_X4%VDD_r14 x_PM_OAI222_X4%VDD_32 x_PM_OAI222_X4%VDD_21 0.0731438
R_x_PM_OAI222_X4%VDD_r15 x_PM_OAI222_X4%VDD_22 x_PM_OAI222_X4%VDD_21 1.10647
R_x_PM_OAI222_X4%VDD_r16 x_PM_OAI222_X4%VDD_31 x_PM_OAI222_X4%VDD_17 0.145286
R_x_PM_OAI222_X4%VDD_r17 N_VDD_M7_d x_PM_OAI222_X4%VDD_17 0.230714
R_x_PM_OAI222_X4%VDD_r18 x_PM_OAI222_X4%VDD_30 x_PM_OAI222_X4%VDD_16 0.0731438
R_x_PM_OAI222_X4%VDD_r19 x_PM_OAI222_X4%VDD_31 x_PM_OAI222_X4%VDD_15 0.0731438
R_x_PM_OAI222_X4%VDD_r20 x_PM_OAI222_X4%VDD_16 x_PM_OAI222_X4%VDD_15 1.54235
R_x_PM_OAI222_X4%VDD_r21 x_PM_OAI222_X4%VDD_30 x_PM_OAI222_X4%VDD_11 0.145286
R_x_PM_OAI222_X4%VDD_r22 N_VDD_M3_d x_PM_OAI222_X4%VDD_11 0.230714
R_x_PM_OAI222_X4%VDD_r23 VDD x_PM_OAI222_X4%VDD_10 0.195294
R_x_PM_OAI222_X4%VDD_r24 x_PM_OAI222_X4%VDD_30 x_PM_OAI222_X4%VDD_9 0.0731438
R_x_PM_OAI222_X4%VDD_r25 x_PM_OAI222_X4%VDD_10 x_PM_OAI222_X4%VDD_9 1.53118
R_x_PM_OAI222_X4%VDD_r26 VDD x_PM_OAI222_X4%VDD_5 0.0689273
R_x_PM_OAI222_X4%VDD_r27 N_VDD_M0_s x_PM_OAI222_X4%VDD_5 0.230714
C_x_PM_OAI222_X4%3_c0 VSS x_PM_OAI222_X4%3_10 4.30466e-18
C_x_PM_OAI222_X4%3_c1 VSS N_3_M12_s 2.77246e-17
C_x_PM_OAI222_X4%3_c2 VSS N_3_M19_d 3.3952e-16
R_x_PM_OAI222_X4%3_r3 N_3_M17_d N_3_M15_d 2.06286
R_x_PM_OAI222_X4%3_r4 N_3_M15_d N_3_M13_d 2.06286
R_x_PM_OAI222_X4%3_r5 N_3_M13_d x_PM_OAI222_X4%3_10 1.83214
R_x_PM_OAI222_X4%3_r6 x_PM_OAI222_X4%3_10 x_PM_OAI222_X4%3_6 0.212317
R_x_PM_OAI222_X4%3_r7 N_3_M12_s x_PM_OAI222_X4%3_6 0.366429
R_x_PM_OAI222_X4%3_r8 N_3_M19_d N_3_M17_d 2.06286
C_x_PM_OAI222_X4%C2_c0 VSS x_PM_OAI222_X4%C2_29 2.28924e-17
C_x_PM_OAI222_X4%C2_c1 VSS x_PM_OAI222_X4%C2_27 8.22062e-18
C_x_PM_OAI222_X4%C2_c2 VSS x_PM_OAI222_X4%C2_25 3.40201e-17
C_x_PM_OAI222_X4%C2_c3 VSS x_PM_OAI222_X4%C2_23 1.60171e-17
C_x_PM_OAI222_X4%C2_c4 VSS x_PM_OAI222_X4%C2_22 6.56647e-17
C_x_PM_OAI222_X4%C2_c5 VSS x_PM_OAI222_X4%C2_20 7.02793e-18
C_x_PM_OAI222_X4%C2_c6 VSS x_PM_OAI222_X4%C2_18 8.38049e-18
C_x_PM_OAI222_X4%C2_c7 VSS N_C2_M3_g 8.15383e-17
C_x_PM_OAI222_X4%C2_c8 VSS N_C2_M15_g 4.87906e-17
C_x_PM_OAI222_X4%C2_c9 VSS N_C2_M0_g 7.75979e-17
C_x_PM_OAI222_X4%C2_c10 VSS N_C2_M12_g 4.77674e-17
R_x_PM_OAI222_X4%C2_r11 x_PM_OAI222_X4%C2_33 C2 0.19
R_x_PM_OAI222_X4%C2_r12 C2 x_PM_OAI222_X4%C2_29 0.19
R_x_PM_OAI222_X4%C2_r13 x_PM_OAI222_X4%C2_40 x_PM_OAI222_X4%C2_27 4.7687
R_x_PM_OAI222_X4%C2_r14 x_PM_OAI222_X4%C2_39 x_PM_OAI222_X4%C2_27 4.7687
R_x_PM_OAI222_X4%C2_r15 x_PM_OAI222_X4%C2_27 x_PM_OAI222_X4%C2_25 25.0012
R_x_PM_OAI222_X4%C2_r16 x_PM_OAI222_X4%C2_33 x_PM_OAI222_X4%C2_24 0.095
R_x_PM_OAI222_X4%C2_r17 x_PM_OAI222_X4%C2_25 x_PM_OAI222_X4%C2_24 1.31643
R_x_PM_OAI222_X4%C2_r18 x_PM_OAI222_X4%C2_29 x_PM_OAI222_X4%C2_22 0.095
R_x_PM_OAI222_X4%C2_r19 x_PM_OAI222_X4%C2_23 x_PM_OAI222_X4%C2_22 1.38429
R_x_PM_OAI222_X4%C2_r20 x_PM_OAI222_X4%C2_37 x_PM_OAI222_X4%C2_20 4.74714
R_x_PM_OAI222_X4%C2_r21 x_PM_OAI222_X4%C2_36 x_PM_OAI222_X4%C2_20 4.74714
R_x_PM_OAI222_X4%C2_r22 x_PM_OAI222_X4%C2_20 x_PM_OAI222_X4%C2_18 25.0012
R_x_PM_OAI222_X4%C2_r23 x_PM_OAI222_X4%C2_23 x_PM_OAI222_X4%C2_17 0.212317
R_x_PM_OAI222_X4%C2_r24 x_PM_OAI222_X4%C2_18 x_PM_OAI222_X4%C2_17 0.176429
R_x_PM_OAI222_X4%C2_r25 N_C2_M3_g x_PM_OAI222_X4%C2_40 86.58
R_x_PM_OAI222_X4%C2_r26 N_C2_M15_g x_PM_OAI222_X4%C2_39 35.1
R_x_PM_OAI222_X4%C2_r27 N_C2_M0_g x_PM_OAI222_X4%C2_37 86.58
R_x_PM_OAI222_X4%C2_r28 N_C2_M12_g x_PM_OAI222_X4%C2_36 35.1
C_x_PM_OAI222_X4%C1_c0 VSS C1 2.83392e-17
C_x_PM_OAI222_X4%C1_c1 VSS x_PM_OAI222_X4%C1_23 3.51727e-18
C_x_PM_OAI222_X4%C1_c2 VSS x_PM_OAI222_X4%C1_21 7.46874e-18
C_x_PM_OAI222_X4%C1_c3 VSS x_PM_OAI222_X4%C1_19 4.24185e-18
C_x_PM_OAI222_X4%C1_c4 VSS N_C1_M2_g 5.09206e-17
C_x_PM_OAI222_X4%C1_c5 VSS N_C1_M14_g 5.1156e-17
C_x_PM_OAI222_X4%C1_c6 VSS x_PM_OAI222_X4%C1_9 7.42183e-18
C_x_PM_OAI222_X4%C1_c7 VSS N_C1_M1_g 4.68423e-17
C_x_PM_OAI222_X4%C1_c8 VSS N_C1_M13_g 5.09634e-17
R_x_PM_OAI222_X4%C1_r9 x_PM_OAI222_X4%C1_28 C1 0.19
R_x_PM_OAI222_X4%C1_r10 x_PM_OAI222_X4%C1_23 x_PM_OAI222_X4%C1_21 25.0012
R_x_PM_OAI222_X4%C1_r11 x_PM_OAI222_X4%C1_28 x_PM_OAI222_X4%C1_20 0.095
R_x_PM_OAI222_X4%C1_r12 x_PM_OAI222_X4%C1_21 x_PM_OAI222_X4%C1_20 0.285
R_x_PM_OAI222_X4%C1_r13 x_PM_OAI222_X4%C1_19 x_PM_OAI222_X4%C1_15 4.56151
R_x_PM_OAI222_X4%C1_r14 N_C1_M2_g x_PM_OAI222_X4%C1_15 64.74
R_x_PM_OAI222_X4%C1_r15 x_PM_OAI222_X4%C1_19 x_PM_OAI222_X4%C1_11 4.56151
R_x_PM_OAI222_X4%C1_r16 N_C1_M14_g x_PM_OAI222_X4%C1_11 56.94
R_x_PM_OAI222_X4%C1_r17 x_PM_OAI222_X4%C1_23 x_PM_OAI222_X4%C1_10 0.043368
R_x_PM_OAI222_X4%C1_r18 x_PM_OAI222_X4%C1_19 x_PM_OAI222_X4%C1_9 0.043368
R_x_PM_OAI222_X4%C1_r19 x_PM_OAI222_X4%C1_10 x_PM_OAI222_X4%C1_9 14.56
R_x_PM_OAI222_X4%C1_r20 x_PM_OAI222_X4%C1_23 x_PM_OAI222_X4%C1_5 4.56151
R_x_PM_OAI222_X4%C1_r21 N_C1_M1_g x_PM_OAI222_X4%C1_5 64.74
R_x_PM_OAI222_X4%C1_r22 x_PM_OAI222_X4%C1_23 x_PM_OAI222_X4%C1_VSS 4.56151
R_x_PM_OAI222_X4%C1_r23 N_C1_M13_g x_PM_OAI222_X4%C1_VSS 56.94
C_x_PM_OAI222_X4%ZN_c0 VSS N_ZN_M23_d 3.99247e-17
C_x_PM_OAI222_X4%ZN_c1 VSS N_ZN_M8_s 1.1546e-16
C_x_PM_OAI222_X4%ZN_c2 VSS N_ZN_M20_s 4.41464e-17
C_x_PM_OAI222_X4%ZN_c3 VSS x_PM_OAI222_X4%ZN_26 9.67305e-17
C_x_PM_OAI222_X4%ZN_c4 VSS x_PM_OAI222_X4%ZN_18 8.77139e-17
C_x_PM_OAI222_X4%ZN_c5 VSS x_PM_OAI222_X4%ZN_17 7.3475e-17
C_x_PM_OAI222_X4%ZN_c6 VSS x_PM_OAI222_X4%ZN_13 1.16645e-17
C_x_PM_OAI222_X4%ZN_c7 VSS x_PM_OAI222_X4%ZN_12 6.10677e-17
R_x_PM_OAI222_X4%ZN_r8 N_ZN_M11_d N_ZN_M8_s 3.90066
R_x_PM_OAI222_X4%ZN_r9 N_ZN_M8_s x_PM_OAI222_X4%ZN_32 0.0125828
R_x_PM_OAI222_X4%ZN_r10 x_PM_OAI222_X4%ZN_30 N_ZN_M20_s 0.158333
R_x_PM_OAI222_X4%ZN_r11 x_PM_OAI222_X4%ZN_26 N_ZN_M5_d 0.128865
R_x_PM_OAI222_X4%ZN_r12 x_PM_OAI222_X4%ZN_30 x_PM_OAI222_X4%ZN_19 0.095
R_x_PM_OAI222_X4%ZN_r13 N_ZN_M21_d x_PM_OAI222_X4%ZN_19 1.85929
R_x_PM_OAI222_X4%ZN_r14 N_ZN_M23_d x_PM_OAI222_X4%ZN_18 0.198162
R_x_PM_OAI222_X4%ZN_r15 N_ZN_M21_d x_PM_OAI222_X4%ZN_18 1.85929
R_x_PM_OAI222_X4%ZN_r16 x_PM_OAI222_X4%ZN_32 x_PM_OAI222_X4%ZN_17 0.176159
R_x_PM_OAI222_X4%ZN_r17 x_PM_OAI222_X4%ZN_16 x_PM_OAI222_X4%ZN_30 0.167557
R_x_PM_OAI222_X4%ZN_r18 x_PM_OAI222_X4%ZN_17 x_PM_OAI222_X4%ZN_16 3.01286
R_x_PM_OAI222_X4%ZN_r19 N_ZN_M5_d x_PM_OAI222_X4%ZN_13 0.156071
R_x_PM_OAI222_X4%ZN_r20 ZN x_PM_OAI222_X4%ZN_13 0.936429
R_x_PM_OAI222_X4%ZN_r21 x_PM_OAI222_X4%ZN_32 x_PM_OAI222_X4%ZN_12 0.175133
R_x_PM_OAI222_X4%ZN_r22 ZN x_PM_OAI222_X4%ZN_12 0.298571
R_x_PM_OAI222_X4%ZN_r23 N_ZN_M1_d x_PM_OAI222_X4%ZN_26 4.03071
C_x_PM_OAI222_X4%B2_c0 VSS x_PM_OAI222_X4%B2_26 7.14517e-18
C_x_PM_OAI222_X4%B2_c1 VSS x_PM_OAI222_X4%B2_22 4.2636e-17
C_x_PM_OAI222_X4%B2_c2 VSS x_PM_OAI222_X4%B2_20 9.10625e-18
C_x_PM_OAI222_X4%B2_c3 VSS x_PM_OAI222_X4%B2_17 5.85674e-17
C_x_PM_OAI222_X4%B2_c4 VSS N_B2_M7_g 7.52849e-17
C_x_PM_OAI222_X4%B2_c5 VSS N_B2_M19_g 6.09358e-17
C_x_PM_OAI222_X4%B2_c6 VSS N_B2_M4_g 7.5211e-17
C_x_PM_OAI222_X4%B2_c7 VSS N_B2_M16_g 5.59327e-17
R_x_PM_OAI222_X4%B2_r8 x_PM_OAI222_X4%B2_36 x_PM_OAI222_X4%B2_26 4.7687
R_x_PM_OAI222_X4%B2_r9 x_PM_OAI222_X4%B2_35 x_PM_OAI222_X4%B2_26 4.7687
R_x_PM_OAI222_X4%B2_r10 x_PM_OAI222_X4%B2_26 x_PM_OAI222_X4%B2_24 25.0012
R_x_PM_OAI222_X4%B2_r11 B2 x_PM_OAI222_X4%B2_24 0.00558824
R_x_PM_OAI222_X4%B2_r12 x_PM_OAI222_X4%B2_24 x_PM_OAI222_X4%B2_22 0.0726471
R_x_PM_OAI222_X4%B2_r13 x_PM_OAI222_X4%B2_20 x_PM_OAI222_X4%B2_30 2.34
R_x_PM_OAI222_X4%B2_r14 x_PM_OAI222_X4%B2_20 x_PM_OAI222_X4%B2_18 25.0012
R_x_PM_OAI222_X4%B2_r15 x_PM_OAI222_X4%B2_22 x_PM_OAI222_X4%B2_17 0.095
R_x_PM_OAI222_X4%B2_r16 x_PM_OAI222_X4%B2_18 x_PM_OAI222_X4%B2_17 2.86357
R_x_PM_OAI222_X4%B2_r17 N_B2_M7_g x_PM_OAI222_X4%B2_36 70.2
R_x_PM_OAI222_X4%B2_r18 N_B2_M19_g x_PM_OAI222_X4%B2_35 51.48
R_x_PM_OAI222_X4%B2_r19 x_PM_OAI222_X4%B2_30 x_PM_OAI222_X4%B2_5 1.95
R_x_PM_OAI222_X4%B2_r20 N_B2_M4_g x_PM_OAI222_X4%B2_5 74.88
R_x_PM_OAI222_X4%B2_r21 x_PM_OAI222_X4%B2_30 x_PM_OAI222_X4%B2_VSS 1.95
R_x_PM_OAI222_X4%B2_r22 N_B2_M16_g x_PM_OAI222_X4%B2_VSS 46.8
C_x_PM_OAI222_X4%8_c0 VSS N_8_M22_d 4.62452e-16
R_x_PM_OAI222_X4%8_r1 N_8_M20_d N_8_M18_d 3.06714
R_x_PM_OAI222_X4%8_r2 N_8_M18_d N_8_M16_d 2.03571
R_x_PM_OAI222_X4%8_r3 N_8_M22_d N_8_M20_d 2.06286
C_x_PM_OAI222_X4%B1_c0 VSS x_PM_OAI222_X4%B1_24 3.46619e-18
C_x_PM_OAI222_X4%B1_c1 VSS B1 4.8823e-17
C_x_PM_OAI222_X4%B1_c2 VSS x_PM_OAI222_X4%B1_19 4.33804e-18
C_x_PM_OAI222_X4%B1_c3 VSS N_B1_M6_g 4.21489e-17
C_x_PM_OAI222_X4%B1_c4 VSS N_B1_M18_g 6.48564e-17
C_x_PM_OAI222_X4%B1_c5 VSS x_PM_OAI222_X4%B1_9 7.96111e-18
C_x_PM_OAI222_X4%B1_c6 VSS N_B1_M5_g 4.01787e-17
C_x_PM_OAI222_X4%B1_c7 VSS N_B1_M17_g 6.50021e-17
R_x_PM_OAI222_X4%B1_r8 x_PM_OAI222_X4%B1_24 x_PM_OAI222_X4%B1_22 25.0012
R_x_PM_OAI222_X4%B1_r9 x_PM_OAI222_X4%B1_22 B1 0.191864
R_x_PM_OAI222_X4%B1_r10 x_PM_OAI222_X4%B1_19 x_PM_OAI222_X4%B1_15 4.56151
R_x_PM_OAI222_X4%B1_r11 N_B1_M6_g x_PM_OAI222_X4%B1_15 39
R_x_PM_OAI222_X4%B1_r12 x_PM_OAI222_X4%B1_19 x_PM_OAI222_X4%B1_11 4.56151
R_x_PM_OAI222_X4%B1_r13 N_B1_M18_g x_PM_OAI222_X4%B1_11 82.68
R_x_PM_OAI222_X4%B1_r14 x_PM_OAI222_X4%B1_24 x_PM_OAI222_X4%B1_10 0.043368
R_x_PM_OAI222_X4%B1_r15 x_PM_OAI222_X4%B1_19 x_PM_OAI222_X4%B1_9 0.043368
R_x_PM_OAI222_X4%B1_r16 x_PM_OAI222_X4%B1_10 x_PM_OAI222_X4%B1_9 14.56
R_x_PM_OAI222_X4%B1_r17 x_PM_OAI222_X4%B1_24 x_PM_OAI222_X4%B1_5 4.56151
R_x_PM_OAI222_X4%B1_r18 N_B1_M5_g x_PM_OAI222_X4%B1_5 39
R_x_PM_OAI222_X4%B1_r19 x_PM_OAI222_X4%B1_24 x_PM_OAI222_X4%B1_VSS 4.56151
R_x_PM_OAI222_X4%B1_r20 N_B1_M17_g x_PM_OAI222_X4%B1_VSS 82.68
C_x_PM_OAI222_X4%A1_c0 VSS x_PM_OAI222_X4%A1_26 7.47324e-18
C_x_PM_OAI222_X4%A1_c1 VSS x_PM_OAI222_X4%A1_22 4.74638e-17
C_x_PM_OAI222_X4%A1_c2 VSS x_PM_OAI222_X4%A1_20 1.52714e-17
C_x_PM_OAI222_X4%A1_c3 VSS x_PM_OAI222_X4%A1_17 8.07331e-17
C_x_PM_OAI222_X4%A1_c4 VSS N_A1_M11_g 5.82778e-17
C_x_PM_OAI222_X4%A1_c5 VSS N_A1_M23_g 6.53055e-17
C_x_PM_OAI222_X4%A1_c6 VSS N_A1_M8_g 7.38989e-17
C_x_PM_OAI222_X4%A1_c7 VSS N_A1_M20_g 6.56909e-17
R_x_PM_OAI222_X4%A1_r8 x_PM_OAI222_X4%A1_33 x_PM_OAI222_X4%A1_26 4.7687
R_x_PM_OAI222_X4%A1_r9 x_PM_OAI222_X4%A1_32 x_PM_OAI222_X4%A1_26 4.7687
R_x_PM_OAI222_X4%A1_r10 x_PM_OAI222_X4%A1_26 x_PM_OAI222_X4%A1_25 25.0012
R_x_PM_OAI222_X4%A1_r11 x_PM_OAI222_X4%A1_25 x_PM_OAI222_X4%A1_22 0.0485041
R_x_PM_OAI222_X4%A1_r12 A1 x_PM_OAI222_X4%A1_22 0.228
R_x_PM_OAI222_X4%A1_r13 x_PM_OAI222_X4%A1_20 x_PM_OAI222_X4%A1_27 5.46
R_x_PM_OAI222_X4%A1_r14 x_PM_OAI222_X4%A1_20 x_PM_OAI222_X4%A1_18 25.0012
R_x_PM_OAI222_X4%A1_r15 x_PM_OAI222_X4%A1_25 x_PM_OAI222_X4%A1_17 0.186554
R_x_PM_OAI222_X4%A1_r16 x_PM_OAI222_X4%A1_18 x_PM_OAI222_X4%A1_17 2.23929
R_x_PM_OAI222_X4%A1_r17 N_A1_M11_g x_PM_OAI222_X4%A1_33 60.06
R_x_PM_OAI222_X4%A1_r18 N_A1_M23_g x_PM_OAI222_X4%A1_32 61.62
R_x_PM_OAI222_X4%A1_r19 x_PM_OAI222_X4%A1_27 x_PM_OAI222_X4%A1_5 1.95
R_x_PM_OAI222_X4%A1_r20 N_A1_M8_g x_PM_OAI222_X4%A1_5 65.52
R_x_PM_OAI222_X4%A1_r21 x_PM_OAI222_X4%A1_27 x_PM_OAI222_X4%A1_VSS 1.95
R_x_PM_OAI222_X4%A1_r22 N_A1_M20_g x_PM_OAI222_X4%A1_VSS 56.16
C_x_PM_OAI222_X4%A2_c0 VSS x_PM_OAI222_X4%A2_22 3.56431e-18
C_x_PM_OAI222_X4%A2_c1 VSS x_PM_OAI222_X4%A2_20 7.06612e-17
C_x_PM_OAI222_X4%A2_c2 VSS x_PM_OAI222_X4%A2_19 4.64834e-18
C_x_PM_OAI222_X4%A2_c3 VSS N_A2_M10_g 4.09158e-17
C_x_PM_OAI222_X4%A2_c4 VSS N_A2_M22_g 6.5879e-17
C_x_PM_OAI222_X4%A2_c5 VSS x_PM_OAI222_X4%A2_9 8.03374e-18
C_x_PM_OAI222_X4%A2_c6 VSS N_A2_M9_g 4.03461e-17
C_x_PM_OAI222_X4%A2_c7 VSS N_A2_M21_g 6.57205e-17
R_x_PM_OAI222_X4%A2_r8 x_PM_OAI222_X4%A2_22 x_PM_OAI222_X4%A2_20 25.0012
R_x_PM_OAI222_X4%A2_r9 A2 x_PM_OAI222_X4%A2_20 0.263445
R_x_PM_OAI222_X4%A2_r10 x_PM_OAI222_X4%A2_19 x_PM_OAI222_X4%A2_15 4.56151
R_x_PM_OAI222_X4%A2_r11 N_A2_M10_g x_PM_OAI222_X4%A2_15 39
R_x_PM_OAI222_X4%A2_r12 x_PM_OAI222_X4%A2_19 x_PM_OAI222_X4%A2_11 4.56151
R_x_PM_OAI222_X4%A2_r13 N_A2_M22_g x_PM_OAI222_X4%A2_11 82.68
R_x_PM_OAI222_X4%A2_r14 x_PM_OAI222_X4%A2_22 x_PM_OAI222_X4%A2_10 0.043368
R_x_PM_OAI222_X4%A2_r15 x_PM_OAI222_X4%A2_19 x_PM_OAI222_X4%A2_9 0.043368
R_x_PM_OAI222_X4%A2_r16 x_PM_OAI222_X4%A2_10 x_PM_OAI222_X4%A2_9 14.56
R_x_PM_OAI222_X4%A2_r17 x_PM_OAI222_X4%A2_22 x_PM_OAI222_X4%A2_5 4.56151
R_x_PM_OAI222_X4%A2_r18 N_A2_M9_g x_PM_OAI222_X4%A2_5 39
R_x_PM_OAI222_X4%A2_r19 x_PM_OAI222_X4%A2_22 x_PM_OAI222_X4%A2_VSS 4.56151
R_x_PM_OAI222_X4%A2_r20 N_A2_M21_g x_PM_OAI222_X4%A2_VSS 82.68
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X1 VSS VDD B2 B1 A1 ZN A2
*.PININFO VSS:B VDD:B B2:I B1:I A1:I ZN:O A2:I
M_M4 noxref_9 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M1_d N_B1_M1_g noxref_9 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 noxref_10 N_A1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_VDD_M3_d N_A2_M3_g noxref_10 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_VSS_M4_d N_B2_M4_g N_3_M4_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_3_M5_d N_B1_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M6_d N_A1_M6_g N_3_M5_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_3_M7_d N_A2_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_OAI22_X1%VSS_c0 VSS x_PM_OAI22_X1%VSS_12 2.63903e-17
C_x_PM_OAI22_X1%VSS_c1 VSS VSS 1.28738e-16
C_x_PM_OAI22_X1%VSS_c2 VSS N_VSS_M4_d 5.142e-17
R_x_PM_OAI22_X1%VSS_r3 x_PM_OAI22_X1%VSS_12 x_PM_OAI22_X1%VSS_8 0.0731438
R_x_PM_OAI22_X1%VSS_r4 VSS x_PM_OAI22_X1%VSS_8 0.402353
R_x_PM_OAI22_X1%VSS_r5 x_PM_OAI22_X1%VSS_12 x_PM_OAI22_X1%VSS_4 0.145286
R_x_PM_OAI22_X1%VSS_r6 N_VSS_M4_d x_PM_OAI22_X1%VSS_4 1.15357
C_x_PM_OAI22_X1%VDD_c0 VSS N_VDD_M3_d 9.5224e-18
C_x_PM_OAI22_X1%VDD_c1 VSS x_PM_OAI22_X1%VDD_8 1.06295e-17
C_x_PM_OAI22_X1%VDD_c2 VSS x_PM_OAI22_X1%VDD_7 8.43875e-17
C_x_PM_OAI22_X1%VDD_c3 VSS N_VDD_M0_s 9.96017e-18
R_x_PM_OAI22_X1%VDD_r4 N_VDD_M3_d x_PM_OAI22_X1%VDD_11 0.230714
R_x_PM_OAI22_X1%VDD_r5 VDD x_PM_OAI22_X1%VDD_8 0.815882
R_x_PM_OAI22_X1%VDD_r6 x_PM_OAI22_X1%VDD_11 x_PM_OAI22_X1%VDD_7 0.264221
R_x_PM_OAI22_X1%VDD_r7 VDD x_PM_OAI22_X1%VDD_7 0.715294
R_x_PM_OAI22_X1%VDD_r8 x_PM_OAI22_X1%VDD_8 x_PM_OAI22_X1%VDD_3 0.264221
R_x_PM_OAI22_X1%VDD_r9 N_VDD_M0_s x_PM_OAI22_X1%VDD_3 0.230714
C_x_PM_OAI22_X1%3_c0 VSS x_PM_OAI22_X1%3_15 2.40362e-17
C_x_PM_OAI22_X1%3_c1 VSS x_PM_OAI22_X1%3_14 1.13675e-16
C_x_PM_OAI22_X1%3_c2 VSS N_3_M5_d 2.67711e-17
C_x_PM_OAI22_X1%3_c3 VSS x_PM_OAI22_X1%3_9 5.66086e-18
C_x_PM_OAI22_X1%3_c4 VSS x_PM_OAI22_X1%3_8 5.62924e-17
C_x_PM_OAI22_X1%3_c5 VSS N_3_M4_s 1.71652e-17
C_x_PM_OAI22_X1%3_c6 VSS N_3_M7_d 2.10437e-17
R_x_PM_OAI22_X1%3_r7 x_PM_OAI22_X1%3_16 x_PM_OAI22_X1%3_14 0.212317
R_x_PM_OAI22_X1%3_r8 x_PM_OAI22_X1%3_15 x_PM_OAI22_X1%3_14 1.65571
R_x_PM_OAI22_X1%3_r9 N_3_M5_d x_PM_OAI22_X1%3_11 0.719286
R_x_PM_OAI22_X1%3_r10 x_PM_OAI22_X1%3_15 x_PM_OAI22_X1%3_10 0.212317
R_x_PM_OAI22_X1%3_r11 N_3_M5_d x_PM_OAI22_X1%3_10 0.420714
R_x_PM_OAI22_X1%3_r12 x_PM_OAI22_X1%3_11 x_PM_OAI22_X1%3_8 0.212317
R_x_PM_OAI22_X1%3_r13 x_PM_OAI22_X1%3_9 x_PM_OAI22_X1%3_8 1.68286
R_x_PM_OAI22_X1%3_r14 x_PM_OAI22_X1%3_9 x_PM_OAI22_X1%3_4 0.212317
R_x_PM_OAI22_X1%3_r15 N_3_M4_s x_PM_OAI22_X1%3_4 0.420714
R_x_PM_OAI22_X1%3_r16 N_3_M7_d x_PM_OAI22_X1%3_16 0.420714
C_x_PM_OAI22_X1%B2_c0 VSS x_PM_OAI22_X1%B2_14 7.83094e-18
C_x_PM_OAI22_X1%B2_c1 VSS x_PM_OAI22_X1%B2_12 3.76503e-17
C_x_PM_OAI22_X1%B2_c2 VSS N_B2_M0_g 5.30426e-17
C_x_PM_OAI22_X1%B2_c3 VSS N_B2_M4_g 5.4696e-17
R_x_PM_OAI22_X1%B2_r4 x_PM_OAI22_X1%B2_18 x_PM_OAI22_X1%B2_14 4.74714
R_x_PM_OAI22_X1%B2_r5 x_PM_OAI22_X1%B2_17 x_PM_OAI22_X1%B2_14 4.74714
R_x_PM_OAI22_X1%B2_r6 x_PM_OAI22_X1%B2_14 x_PM_OAI22_X1%B2_12 25.0012
R_x_PM_OAI22_X1%B2_r7 x_PM_OAI22_X1%B2_12 B2 0.156071
R_x_PM_OAI22_X1%B2_r8 N_B2_M0_g x_PM_OAI22_X1%B2_18 62.79
R_x_PM_OAI22_X1%B2_r9 N_B2_M4_g x_PM_OAI22_X1%B2_17 63.96
C_x_PM_OAI22_X1%B1_c0 VSS x_PM_OAI22_X1%B1_18 1.11149e-17
C_x_PM_OAI22_X1%B1_c1 VSS x_PM_OAI22_X1%B1_12 3.7474e-17
C_x_PM_OAI22_X1%B1_c2 VSS N_B1_M1_g 5.57748e-17
C_x_PM_OAI22_X1%B1_c3 VSS N_B1_M5_g 5.68233e-17
R_x_PM_OAI22_X1%B1_r4 x_PM_OAI22_X1%B1_18 x_PM_OAI22_X1%B1_14 4.42
R_x_PM_OAI22_X1%B1_r5 x_PM_OAI22_X1%B1_14 x_PM_OAI22_X1%B1_12 25.0012
R_x_PM_OAI22_X1%B1_r6 x_PM_OAI22_X1%B1_12 B1 0.0882143
R_x_PM_OAI22_X1%B1_r7 x_PM_OAI22_X1%B1_18 x_PM_OAI22_X1%B1_5 1.95
R_x_PM_OAI22_X1%B1_r8 N_B1_M1_g x_PM_OAI22_X1%B1_5 62.79
R_x_PM_OAI22_X1%B1_r9 x_PM_OAI22_X1%B1_18 x_PM_OAI22_X1%B1_VSS 1.95
R_x_PM_OAI22_X1%B1_r10 N_B1_M5_g x_PM_OAI22_X1%B1_VSS 63.96
C_x_PM_OAI22_X1%A1_c0 VSS x_PM_OAI22_X1%A1_14 8.6861e-18
C_x_PM_OAI22_X1%A1_c1 VSS x_PM_OAI22_X1%A1_12 3.94755e-17
C_x_PM_OAI22_X1%A1_c2 VSS N_A1_M2_g 7.37776e-17
C_x_PM_OAI22_X1%A1_c3 VSS N_A1_M6_g 3.95818e-17
R_x_PM_OAI22_X1%A1_r4 x_PM_OAI22_X1%A1_18 x_PM_OAI22_X1%A1_14 4.74714
R_x_PM_OAI22_X1%A1_r5 x_PM_OAI22_X1%A1_17 x_PM_OAI22_X1%A1_14 4.74714
R_x_PM_OAI22_X1%A1_r6 x_PM_OAI22_X1%A1_14 x_PM_OAI22_X1%A1_12 25.0012
R_x_PM_OAI22_X1%A1_r7 x_PM_OAI22_X1%A1_12 A1 0.312143
R_x_PM_OAI22_X1%A1_r8 N_A1_M2_g x_PM_OAI22_X1%A1_18 85.41
R_x_PM_OAI22_X1%A1_r9 N_A1_M6_g x_PM_OAI22_X1%A1_17 41.34
C_x_PM_OAI22_X1%ZN_c0 VSS x_PM_OAI22_X1%ZN_16 6.13779e-17
C_x_PM_OAI22_X1%ZN_c1 VSS x_PM_OAI22_X1%ZN_12 4.57458e-17
C_x_PM_OAI22_X1%ZN_c2 VSS x_PM_OAI22_X1%ZN_10 1.38128e-17
C_x_PM_OAI22_X1%ZN_c3 VSS x_PM_OAI22_X1%ZN_9 4.22284e-17
C_x_PM_OAI22_X1%ZN_c4 VSS ZN 5.77216e-17
R_x_PM_OAI22_X1%ZN_r5 x_PM_OAI22_X1%ZN_16 N_ZN_M6_d 0.147778
R_x_PM_OAI22_X1%ZN_r6 x_PM_OAI22_X1%ZN_16 x_PM_OAI22_X1%ZN_11 0.095
R_x_PM_OAI22_X1%ZN_r7 x_PM_OAI22_X1%ZN_12 x_PM_OAI22_X1%ZN_11 2.19857
R_x_PM_OAI22_X1%ZN_r8 x_PM_OAI22_X1%ZN_12 x_PM_OAI22_X1%ZN_9 0.212317
R_x_PM_OAI22_X1%ZN_r9 x_PM_OAI22_X1%ZN_10 x_PM_OAI22_X1%ZN_9 0.841429
R_x_PM_OAI22_X1%ZN_r10 N_ZN_M1_d ZN 1.08412
R_x_PM_OAI22_X1%ZN_r11 x_PM_OAI22_X1%ZN_10 x_PM_OAI22_X1%ZN_3 0.214913
R_x_PM_OAI22_X1%ZN_r12 ZN x_PM_OAI22_X1%ZN_3 0.0670588
C_x_PM_OAI22_X1%A2_c0 VSS x_PM_OAI22_X1%A2_14 7.31895e-18
C_x_PM_OAI22_X1%A2_c1 VSS x_PM_OAI22_X1%A2_12 4.56429e-17
C_x_PM_OAI22_X1%A2_c2 VSS N_A2_M3_g 3.076e-17
C_x_PM_OAI22_X1%A2_c3 VSS N_A2_M7_g 9.34294e-17
R_x_PM_OAI22_X1%A2_r4 x_PM_OAI22_X1%A2_18 x_PM_OAI22_X1%A2_14 4.7687
R_x_PM_OAI22_X1%A2_r5 x_PM_OAI22_X1%A2_17 x_PM_OAI22_X1%A2_14 4.7687
R_x_PM_OAI22_X1%A2_r6 x_PM_OAI22_X1%A2_14 x_PM_OAI22_X1%A2_12 25.0012
R_x_PM_OAI22_X1%A2_r7 x_PM_OAI22_X1%A2_12 A2 0.207813
R_x_PM_OAI22_X1%A2_r8 N_A2_M3_g x_PM_OAI22_X1%A2_18 23.01
R_x_PM_OAI22_X1%A2_r9 N_A2_M7_g x_PM_OAI22_X1%A2_17 103.74
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X2 VSS VDD B2 B1 A1 ZN A2
*.PININFO VSS:B VDD:B B2:I B1:I A1:I ZN:O A2:I
M_M4 noxref_9 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M5 N_ZN_M1_d N_B1_M1_g noxref_9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 noxref_10 N_A1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_VDD_M3_d N_A2_M3_g noxref_10 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_VSS_M4_d N_B2_M4_g N_3_M4_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_3_M5_d N_B1_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_ZN_M6_d N_A1_M6_g N_3_M5_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_3_M7_d N_A2_M7_g N_ZN_M6_d VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_OAI22_X2%VSS_c0 VSS x_PM_OAI22_X2%VSS_12 3.12526e-17
C_x_PM_OAI22_X2%VSS_c1 VSS VSS 1.34346e-16
C_x_PM_OAI22_X2%VSS_c2 VSS N_VSS_M4_d 3.6604e-17
R_x_PM_OAI22_X2%VSS_r3 x_PM_OAI22_X2%VSS_12 x_PM_OAI22_X2%VSS_8 0.0731438
R_x_PM_OAI22_X2%VSS_r4 VSS x_PM_OAI22_X2%VSS_8 0.346471
R_x_PM_OAI22_X2%VSS_r5 x_PM_OAI22_X2%VSS_12 x_PM_OAI22_X2%VSS_4 0.145286
R_x_PM_OAI22_X2%VSS_r6 N_VSS_M4_d x_PM_OAI22_X2%VSS_4 0.447857
C_x_PM_OAI22_X2%VDD_c0 VSS VDD 1.23916e-17
C_x_PM_OAI22_X2%VDD_c1 VSS N_VDD_M3_d 2.00368e-17
C_x_PM_OAI22_X2%VDD_c2 VSS x_PM_OAI22_X2%VDD_7 6.95099e-17
C_x_PM_OAI22_X2%VDD_c3 VSS N_VDD_M0_s 2.03132e-17
R_x_PM_OAI22_X2%VDD_r4 x_PM_OAI22_X2%VDD_16 VDD 0.225185
R_x_PM_OAI22_X2%VDD_r5 x_PM_OAI22_X2%VDD_15 VDD 0.101823
R_x_PM_OAI22_X2%VDD_r6 N_VDD_M3_d x_PM_OAI22_X2%VDD_9 0.230714
R_x_PM_OAI22_X2%VDD_r7 x_PM_OAI22_X2%VDD_16 x_PM_OAI22_X2%VDD_8 0.095
R_x_PM_OAI22_X2%VDD_r8 x_PM_OAI22_X2%VDD_9 x_PM_OAI22_X2%VDD_7 0.264221
R_x_PM_OAI22_X2%VDD_r9 x_PM_OAI22_X2%VDD_8 x_PM_OAI22_X2%VDD_7 1.53118
R_x_PM_OAI22_X2%VDD_r10 N_VDD_M0_s x_PM_OAI22_X2%VDD_15 0.230714
C_x_PM_OAI22_X2%3_c0 VSS x_PM_OAI22_X2%3_13 2.4566e-17
C_x_PM_OAI22_X2%3_c1 VSS x_PM_OAI22_X2%3_10 7.90335e-17
C_x_PM_OAI22_X2%3_c2 VSS x_PM_OAI22_X2%3_9 8.19685e-18
C_x_PM_OAI22_X2%3_c3 VSS x_PM_OAI22_X2%3_8 2.3416e-17
C_x_PM_OAI22_X2%3_c4 VSS x_PM_OAI22_X2%3_4 6.50525e-17
R_x_PM_OAI22_X2%3_r5 N_3_M5_d x_PM_OAI22_X2%3_11 0.197151
R_x_PM_OAI22_X2%3_r6 x_PM_OAI22_X2%3_13 x_PM_OAI22_X2%3_10 0.095
R_x_PM_OAI22_X2%3_r7 x_PM_OAI22_X2%3_11 x_PM_OAI22_X2%3_10 1.68286
R_x_PM_OAI22_X2%3_r8 N_3_M5_d x_PM_OAI22_X2%3_8 0.0151655
R_x_PM_OAI22_X2%3_r9 x_PM_OAI22_X2%3_9 x_PM_OAI22_X2%3_8 0.434286
R_x_PM_OAI22_X2%3_r10 x_PM_OAI22_X2%3_9 x_PM_OAI22_X2%3_4 0.212317
R_x_PM_OAI22_X2%3_r11 N_3_M4_s x_PM_OAI22_X2%3_4 1.83214
R_x_PM_OAI22_X2%3_r12 N_3_M7_d x_PM_OAI22_X2%3_13 0.176429
C_x_PM_OAI22_X2%B2_c0 VSS x_PM_OAI22_X2%B2_18 9.41059e-18
C_x_PM_OAI22_X2%B2_c1 VSS x_PM_OAI22_X2%B2_12 3.90482e-17
C_x_PM_OAI22_X2%B2_c2 VSS N_B2_M0_g 6.82858e-17
C_x_PM_OAI22_X2%B2_c3 VSS N_B2_M4_g 5.01621e-17
R_x_PM_OAI22_X2%B2_r4 x_PM_OAI22_X2%B2_18 x_PM_OAI22_X2%B2_14 4.42
R_x_PM_OAI22_X2%B2_r5 x_PM_OAI22_X2%B2_14 x_PM_OAI22_X2%B2_12 25.0012
R_x_PM_OAI22_X2%B2_r6 x_PM_OAI22_X2%B2_12 B2 0.156071
R_x_PM_OAI22_X2%B2_r7 x_PM_OAI22_X2%B2_18 x_PM_OAI22_X2%B2_5 1.95
R_x_PM_OAI22_X2%B2_r8 N_B2_M0_g x_PM_OAI22_X2%B2_5 70.2
R_x_PM_OAI22_X2%B2_r9 x_PM_OAI22_X2%B2_18 x_PM_OAI22_X2%B2_VSS 1.95
R_x_PM_OAI22_X2%B2_r10 N_B2_M4_g x_PM_OAI22_X2%B2_VSS 51.48
C_x_PM_OAI22_X2%B1_c0 VSS x_PM_OAI22_X2%B1_18 1.1798e-17
C_x_PM_OAI22_X2%B1_c1 VSS x_PM_OAI22_X2%B1_12 6.185e-17
C_x_PM_OAI22_X2%B1_c2 VSS N_B1_M1_g 6.94194e-17
C_x_PM_OAI22_X2%B1_c3 VSS N_B1_M5_g 5.53947e-17
R_x_PM_OAI22_X2%B1_r4 x_PM_OAI22_X2%B1_18 x_PM_OAI22_X2%B1_14 4.42
R_x_PM_OAI22_X2%B1_r5 x_PM_OAI22_X2%B1_14 x_PM_OAI22_X2%B1_12 25.0012
R_x_PM_OAI22_X2%B1_r6 x_PM_OAI22_X2%B1_12 B1 0.156071
R_x_PM_OAI22_X2%B1_r7 x_PM_OAI22_X2%B1_18 x_PM_OAI22_X2%B1_5 1.95
R_x_PM_OAI22_X2%B1_r8 N_B1_M1_g x_PM_OAI22_X2%B1_5 70.2
R_x_PM_OAI22_X2%B1_r9 x_PM_OAI22_X2%B1_18 x_PM_OAI22_X2%B1_VSS 1.95
R_x_PM_OAI22_X2%B1_r10 N_B1_M5_g x_PM_OAI22_X2%B1_VSS 51.48
C_x_PM_OAI22_X2%A1_c0 VSS x_PM_OAI22_X2%A1_18 1.18879e-17
C_x_PM_OAI22_X2%A1_c1 VSS x_PM_OAI22_X2%A1_12 8.00865e-17
C_x_PM_OAI22_X2%A1_c2 VSS N_A1_M2_g 7.37834e-17
C_x_PM_OAI22_X2%A1_c3 VSS N_A1_M6_g 5.54977e-17
R_x_PM_OAI22_X2%A1_r4 x_PM_OAI22_X2%A1_18 x_PM_OAI22_X2%A1_14 4.42
R_x_PM_OAI22_X2%A1_r5 x_PM_OAI22_X2%A1_14 x_PM_OAI22_X2%A1_12 25.0012
R_x_PM_OAI22_X2%A1_r6 x_PM_OAI22_X2%A1_12 A1 0.156071
R_x_PM_OAI22_X2%A1_r7 x_PM_OAI22_X2%A1_18 x_PM_OAI22_X2%A1_5 1.95
R_x_PM_OAI22_X2%A1_r8 N_A1_M2_g x_PM_OAI22_X2%A1_5 70.2
R_x_PM_OAI22_X2%A1_r9 x_PM_OAI22_X2%A1_18 x_PM_OAI22_X2%A1_VSS 1.95
R_x_PM_OAI22_X2%A1_r10 N_A1_M6_g x_PM_OAI22_X2%A1_VSS 51.48
C_x_PM_OAI22_X2%ZN_c0 VSS N_ZN_M6_d 1.08414e-16
C_x_PM_OAI22_X2%ZN_c1 VSS x_PM_OAI22_X2%ZN_8 2.2027e-17
C_x_PM_OAI22_X2%ZN_c2 VSS x_PM_OAI22_X2%ZN_7 2.33668e-17
C_x_PM_OAI22_X2%ZN_c3 VSS N_ZN_M1_d 4.33973e-17
R_x_PM_OAI22_X2%ZN_r4 ZN N_ZN_M6_d 1.50643
R_x_PM_OAI22_X2%ZN_r5 ZN x_PM_OAI22_X2%ZN_9 0.732857
R_x_PM_OAI22_X2%ZN_r6 x_PM_OAI22_X2%ZN_9 x_PM_OAI22_X2%ZN_7 0.212317
R_x_PM_OAI22_X2%ZN_r7 x_PM_OAI22_X2%ZN_8 x_PM_OAI22_X2%ZN_7 0.597143
R_x_PM_OAI22_X2%ZN_r8 x_PM_OAI22_X2%ZN_8 x_PM_OAI22_X2%ZN_3 0.212317
R_x_PM_OAI22_X2%ZN_r9 N_ZN_M1_d x_PM_OAI22_X2%ZN_3 1.425
C_x_PM_OAI22_X2%A2_c0 VSS A2 3.97402e-17
C_x_PM_OAI22_X2%A2_c1 VSS x_PM_OAI22_X2%A2_11 8.27461e-18
C_x_PM_OAI22_X2%A2_c2 VSS N_A2_M3_g 8.06223e-17
C_x_PM_OAI22_X2%A2_c3 VSS N_A2_M7_g 4.02286e-17
R_x_PM_OAI22_X2%A2_r4 x_PM_OAI22_X2%A2_11 x_PM_OAI22_X2%A2_16 3.38
R_x_PM_OAI22_X2%A2_r5 x_PM_OAI22_X2%A2_11 x_PM_OAI22_X2%A2_9 25.0012
R_x_PM_OAI22_X2%A2_r6 A2 x_PM_OAI22_X2%A2_9 0.156071
R_x_PM_OAI22_X2%A2_r7 x_PM_OAI22_X2%A2_16 x_PM_OAI22_X2%A2_5 1.95
R_x_PM_OAI22_X2%A2_r8 N_A2_M3_g x_PM_OAI22_X2%A2_5 92.04
R_x_PM_OAI22_X2%A2_r9 x_PM_OAI22_X2%A2_16 x_PM_OAI22_X2%A2_VSS 1.95
R_x_PM_OAI22_X2%A2_r10 N_A2_M7_g x_PM_OAI22_X2%A2_VSS 29.64
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI22_X4.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI22_X4 VSS VDD B2 B1 A1 ZN A2
*.PININFO VSS:B VDD:B B2:I B1:I ZN:O A2:I A1:I
M_M8 9 N_B2_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_ZN_M1_d N_B1_M1_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 10 N_B1_M2_g N_ZN_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_VDD_M3_d N_B2_M3_g 10 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M12 11 N_A2_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M13 N_ZN_M5_d N_A1_M5_g 11 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M14 12 N_A1_M6_g N_ZN_M5_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M15 N_VDD_M7_d N_A2_M7_g 12 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_VSS_M8_d N_B2_M8_g N_3_M8_s VSS NMOS_VTL W=0.260000U L=0.050000U
M_M1 N_3_M9_d N_B1_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_VSS_M10_d N_B1_M10_g N_3_M9_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_3_M11_d N_B2_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_ZN_M12_d N_A2_M12_g N_3_M11_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_3_M13_d N_A1_M13_g N_ZN_M12_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 N_ZN_M14_d N_A1_M14_g N_3_M13_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 N_3_M15_d N_A2_M15_g N_ZN_M14_d VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_OAI22_X4%VSS_c0 VSS x_PM_OAI22_X4%VSS_16 4.22025e-17
C_x_PM_OAI22_X4%VSS_c1 VSS x_PM_OAI22_X4%VSS_11 6.25109e-17
C_x_PM_OAI22_X4%VSS_c2 VSS VSS 2.18366e-16
C_x_PM_OAI22_X4%VSS_c3 VSS x_PM_OAI22_X4%VSS_5 2.15678e-17
R_x_PM_OAI22_X4%VSS_r4 N_VSS_M10_d x_PM_OAI22_X4%VSS_16 0.485556
R_x_PM_OAI22_X4%VSS_r5 N_VSS_M8_d x_PM_OAI22_X4%VSS_11 0.485556
R_x_PM_OAI22_X4%VSS_r6 x_PM_OAI22_X4%VSS_16 x_PM_OAI22_X4%VSS_7 0.095
R_x_PM_OAI22_X4%VSS_r7 VSS x_PM_OAI22_X4%VSS_7 0.301765
R_x_PM_OAI22_X4%VSS_r8 x_PM_OAI22_X4%VSS_11 x_PM_OAI22_X4%VSS_6 0.095
R_x_PM_OAI22_X4%VSS_r9 x_PM_OAI22_X4%VSS_16 x_PM_OAI22_X4%VSS_5 0.095
R_x_PM_OAI22_X4%VSS_r10 x_PM_OAI22_X4%VSS_6 x_PM_OAI22_X4%VSS_5 0.547647
C_x_PM_OAI22_X4%VDD_c0 VSS x_PM_OAI22_X4%VDD_22 5.79763e-18
C_x_PM_OAI22_X4%VDD_c1 VSS N_VDD_M7_d 1.9162e-17
C_x_PM_OAI22_X4%VDD_c2 VSS x_PM_OAI22_X4%VDD_16 7.24689e-17
C_x_PM_OAI22_X4%VDD_c3 VSS N_VDD_M3_d 3.3902e-17
C_x_PM_OAI22_X4%VDD_c4 VSS x_PM_OAI22_X4%VDD_9 1.11758e-17
C_x_PM_OAI22_X4%VDD_c5 VSS x_PM_OAI22_X4%VDD_8 5.63312e-17
C_x_PM_OAI22_X4%VDD_c6 VSS N_VDD_M0_s 1.96764e-17
R_x_PM_OAI22_X4%VDD_r7 N_VDD_M7_d x_PM_OAI22_X4%VDD_18 0.230714
R_x_PM_OAI22_X4%VDD_r8 x_PM_OAI22_X4%VDD_22 x_PM_OAI22_X4%VDD_17 0.132285
R_x_PM_OAI22_X4%VDD_r9 x_PM_OAI22_X4%VDD_18 x_PM_OAI22_X4%VDD_16 0.264221
R_x_PM_OAI22_X4%VDD_r10 x_PM_OAI22_X4%VDD_17 x_PM_OAI22_X4%VDD_16 1.46412
R_x_PM_OAI22_X4%VDD_r11 VDD N_VDD_M3_d 0.00703704
R_x_PM_OAI22_X4%VDD_r12 x_PM_OAI22_X4%VDD_22 x_PM_OAI22_X4%VDD_10 0.0680382
R_x_PM_OAI22_X4%VDD_r13 VDD x_PM_OAI22_X4%VDD_10 0.112593
R_x_PM_OAI22_X4%VDD_r14 x_PM_OAI22_X4%VDD_22 x_PM_OAI22_X4%VDD_8 0.132285
R_x_PM_OAI22_X4%VDD_r15 x_PM_OAI22_X4%VDD_9 x_PM_OAI22_X4%VDD_8 1.46412
R_x_PM_OAI22_X4%VDD_r16 x_PM_OAI22_X4%VDD_9 x_PM_OAI22_X4%VDD_4 0.264221
R_x_PM_OAI22_X4%VDD_r17 N_VDD_M0_s x_PM_OAI22_X4%VDD_4 0.230714
C_x_PM_OAI22_X4%3_c0 VSS N_3_M8_s 1.37553e-17
C_x_PM_OAI22_X4%3_c1 VSS x_PM_OAI22_X4%3_12 2.20913e-16
C_x_PM_OAI22_X4%3_c2 VSS x_PM_OAI22_X4%3_11 5.55914e-18
C_x_PM_OAI22_X4%3_c3 VSS x_PM_OAI22_X4%3_10 2.91439e-17
C_x_PM_OAI22_X4%3_c4 VSS x_PM_OAI22_X4%3_6 1.14772e-16
C_x_PM_OAI22_X4%3_c5 VSS N_3_M15_d 2.16431e-17
R_x_PM_OAI22_X4%3_r6 x_PM_OAI22_X4%3_23 N_3_M8_s 0.176429
R_x_PM_OAI22_X4%3_r7 N_3_M11_d x_PM_OAI22_X4%3_13 0.197151
R_x_PM_OAI22_X4%3_r8 N_3_M13_d x_PM_OAI22_X4%3_13 1.88643
R_x_PM_OAI22_X4%3_r9 x_PM_OAI22_X4%3_16 x_PM_OAI22_X4%3_12 0.212317
R_x_PM_OAI22_X4%3_r10 N_3_M13_d x_PM_OAI22_X4%3_12 1.85929
R_x_PM_OAI22_X4%3_r11 N_3_M11_d x_PM_OAI22_X4%3_10 0.0151655
R_x_PM_OAI22_X4%3_r12 x_PM_OAI22_X4%3_11 x_PM_OAI22_X4%3_10 0.38
R_x_PM_OAI22_X4%3_r13 x_PM_OAI22_X4%3_23 x_PM_OAI22_X4%3_7 0.095
R_x_PM_OAI22_X4%3_r14 N_3_M9_d x_PM_OAI22_X4%3_7 1.83214
R_x_PM_OAI22_X4%3_r15 x_PM_OAI22_X4%3_11 x_PM_OAI22_X4%3_6 0.212317
R_x_PM_OAI22_X4%3_r16 N_3_M9_d x_PM_OAI22_X4%3_6 1.85929
R_x_PM_OAI22_X4%3_r17 N_3_M15_d x_PM_OAI22_X4%3_16 0.746429
C_x_PM_OAI22_X4%B2_c0 VSS x_PM_OAI22_X4%B2_35 9.47499e-18
C_x_PM_OAI22_X4%B2_c1 VSS x_PM_OAI22_X4%B2_22 4.78628e-17
C_x_PM_OAI22_X4%B2_c2 VSS x_PM_OAI22_X4%B2_20 6.8505e-18
C_x_PM_OAI22_X4%B2_c3 VSS x_PM_OAI22_X4%B2_17 6.50188e-17
C_x_PM_OAI22_X4%B2_c4 VSS N_B2_M3_g 7.11926e-17
C_x_PM_OAI22_X4%B2_c5 VSS N_B2_M11_g 5.38993e-17
C_x_PM_OAI22_X4%B2_c6 VSS N_B2_M0_g 7.17483e-17
C_x_PM_OAI22_X4%B2_c7 VSS N_B2_M8_g 4.85973e-17
R_x_PM_OAI22_X4%B2_r8 x_PM_OAI22_X4%B2_35 x_PM_OAI22_X4%B2_26 2.34
R_x_PM_OAI22_X4%B2_r9 x_PM_OAI22_X4%B2_26 x_PM_OAI22_X4%B2_24 25.0012
R_x_PM_OAI22_X4%B2_r10 B2 x_PM_OAI22_X4%B2_24 0.0076
R_x_PM_OAI22_X4%B2_r11 x_PM_OAI22_X4%B2_24 x_PM_OAI22_X4%B2_22 0.0988
R_x_PM_OAI22_X4%B2_r12 x_PM_OAI22_X4%B2_32 x_PM_OAI22_X4%B2_20 4.7687
R_x_PM_OAI22_X4%B2_r13 x_PM_OAI22_X4%B2_31 x_PM_OAI22_X4%B2_20 4.7687
R_x_PM_OAI22_X4%B2_r14 x_PM_OAI22_X4%B2_20 x_PM_OAI22_X4%B2_18 25.0012
R_x_PM_OAI22_X4%B2_r15 x_PM_OAI22_X4%B2_22 x_PM_OAI22_X4%B2_17 0.095
R_x_PM_OAI22_X4%B2_r16 x_PM_OAI22_X4%B2_18 x_PM_OAI22_X4%B2_17 2.40214
R_x_PM_OAI22_X4%B2_r17 x_PM_OAI22_X4%B2_35 x_PM_OAI22_X4%B2_13 1.95
R_x_PM_OAI22_X4%B2_r18 N_B2_M3_g x_PM_OAI22_X4%B2_13 70.2
R_x_PM_OAI22_X4%B2_r19 x_PM_OAI22_X4%B2_35 x_PM_OAI22_X4%B2_9 1.95
R_x_PM_OAI22_X4%B2_r20 N_B2_M11_g x_PM_OAI22_X4%B2_9 50.7
R_x_PM_OAI22_X4%B2_r21 N_B2_M0_g x_PM_OAI22_X4%B2_32 75.66
R_x_PM_OAI22_X4%B2_r22 N_B2_M8_g x_PM_OAI22_X4%B2_31 45.24
C_x_PM_OAI22_X4%B1_c0 VSS x_PM_OAI22_X4%B1_25 3.46619e-18
C_x_PM_OAI22_X4%B1_c1 VSS x_PM_OAI22_X4%B1_23 4.374e-17
C_x_PM_OAI22_X4%B1_c2 VSS x_PM_OAI22_X4%B1_19 4.42088e-18
C_x_PM_OAI22_X4%B1_c3 VSS N_B1_M2_g 4.45864e-17
C_x_PM_OAI22_X4%B1_c4 VSS N_B1_M10_g 5.45266e-17
C_x_PM_OAI22_X4%B1_c5 VSS x_PM_OAI22_X4%B1_9 8.35381e-18
C_x_PM_OAI22_X4%B1_c6 VSS N_B1_M1_g 4.06778e-17
C_x_PM_OAI22_X4%B1_c7 VSS N_B1_M9_g 5.28192e-17
R_x_PM_OAI22_X4%B1_r8 x_PM_OAI22_X4%B1_25 x_PM_OAI22_X4%B1_23 25.0012
R_x_PM_OAI22_X4%B1_r9 x_PM_OAI22_X4%B1_23 B1 0.251071
R_x_PM_OAI22_X4%B1_r10 x_PM_OAI22_X4%B1_19 x_PM_OAI22_X4%B1_15 4.56151
R_x_PM_OAI22_X4%B1_r11 N_B1_M2_g x_PM_OAI22_X4%B1_15 48.36
R_x_PM_OAI22_X4%B1_r12 x_PM_OAI22_X4%B1_19 x_PM_OAI22_X4%B1_11 4.56151
R_x_PM_OAI22_X4%B1_r13 N_B1_M10_g x_PM_OAI22_X4%B1_11 72.54
R_x_PM_OAI22_X4%B1_r14 x_PM_OAI22_X4%B1_25 x_PM_OAI22_X4%B1_10 0.043368
R_x_PM_OAI22_X4%B1_r15 x_PM_OAI22_X4%B1_19 x_PM_OAI22_X4%B1_9 0.043368
R_x_PM_OAI22_X4%B1_r16 x_PM_OAI22_X4%B1_10 x_PM_OAI22_X4%B1_9 14.56
R_x_PM_OAI22_X4%B1_r17 x_PM_OAI22_X4%B1_25 x_PM_OAI22_X4%B1_5 4.56151
R_x_PM_OAI22_X4%B1_r18 N_B1_M1_g x_PM_OAI22_X4%B1_5 48.36
R_x_PM_OAI22_X4%B1_r19 x_PM_OAI22_X4%B1_25 x_PM_OAI22_X4%B1_VSS 4.56151
R_x_PM_OAI22_X4%B1_r20 N_B1_M9_g x_PM_OAI22_X4%B1_VSS 72.54
C_x_PM_OAI22_X4%ZN_c0 VSS x_PM_OAI22_X4%ZN_30 8.24612e-18
C_x_PM_OAI22_X4%ZN_c1 VSS N_ZN_M5_d 3.62454e-17
C_x_PM_OAI22_X4%ZN_c2 VSS x_PM_OAI22_X4%ZN_23 8.05409e-18
C_x_PM_OAI22_X4%ZN_c3 VSS N_ZN_M14_d 8.45486e-17
C_x_PM_OAI22_X4%ZN_c4 VSS x_PM_OAI22_X4%ZN_19 6.4339e-17
C_x_PM_OAI22_X4%ZN_c5 VSS x_PM_OAI22_X4%ZN_18 6.14423e-18
C_x_PM_OAI22_X4%ZN_c6 VSS x_PM_OAI22_X4%ZN_15 2.23538e-17
C_x_PM_OAI22_X4%ZN_c7 VSS ZN 7.09861e-17
C_x_PM_OAI22_X4%ZN_c8 VSS x_PM_OAI22_X4%ZN_10 9.49569e-18
C_x_PM_OAI22_X4%ZN_c9 VSS x_PM_OAI22_X4%ZN_9 3.0442e-17
C_x_PM_OAI22_X4%ZN_c10 VSS N_ZN_M1_d 2.48969e-17
R_x_PM_OAI22_X4%ZN_r11 N_ZN_M12_d x_PM_OAI22_X4%ZN_28 0.124153
R_x_PM_OAI22_X4%ZN_r12 x_PM_OAI22_X4%ZN_28 x_PM_OAI22_X4%ZN_27 0.63456
R_x_PM_OAI22_X4%ZN_r13 N_ZN_M5_d x_PM_OAI22_X4%ZN_23 0.800714
R_x_PM_OAI22_X4%ZN_r14 x_PM_OAI22_X4%ZN_28 x_PM_OAI22_X4%ZN_19 0.0488939
R_x_PM_OAI22_X4%ZN_r15 N_ZN_M14_d x_PM_OAI22_X4%ZN_19 2.04929
R_x_PM_OAI22_X4%ZN_r16 x_PM_OAI22_X4%ZN_23 x_PM_OAI22_X4%ZN_18 0.212317
R_x_PM_OAI22_X4%ZN_r17 x_PM_OAI22_X4%ZN_18 x_PM_OAI22_X4%ZN_17 0.352857
R_x_PM_OAI22_X4%ZN_r18 x_PM_OAI22_X4%ZN_30 x_PM_OAI22_X4%ZN_16 0.160909
R_x_PM_OAI22_X4%ZN_r19 x_PM_OAI22_X4%ZN_17 x_PM_OAI22_X4%ZN_15 0.212317
R_x_PM_OAI22_X4%ZN_r20 x_PM_OAI22_X4%ZN_16 x_PM_OAI22_X4%ZN_15 0.597143
R_x_PM_OAI22_X4%ZN_r21 x_PM_OAI22_X4%ZN_30 x_PM_OAI22_X4%ZN_12 0.0418175
R_x_PM_OAI22_X4%ZN_r22 ZN x_PM_OAI22_X4%ZN_12 0.76
R_x_PM_OAI22_X4%ZN_r23 x_PM_OAI22_X4%ZN_27 x_PM_OAI22_X4%ZN_11 0.128751
R_x_PM_OAI22_X4%ZN_r24 ZN x_PM_OAI22_X4%ZN_11 1.49286
R_x_PM_OAI22_X4%ZN_r25 x_PM_OAI22_X4%ZN_30 x_PM_OAI22_X4%ZN_9 0.160909
R_x_PM_OAI22_X4%ZN_r26 x_PM_OAI22_X4%ZN_10 x_PM_OAI22_X4%ZN_9 1.73714
R_x_PM_OAI22_X4%ZN_r27 x_PM_OAI22_X4%ZN_10 x_PM_OAI22_X4%ZN_5 0.212317
R_x_PM_OAI22_X4%ZN_r28 N_ZN_M1_d x_PM_OAI22_X4%ZN_5 0.746429
C_x_PM_OAI22_X4%A2_c0 VSS x_PM_OAI22_X4%A2_26 1.29527e-17
C_x_PM_OAI22_X4%A2_c1 VSS x_PM_OAI22_X4%A2_22 6.04109e-17
C_x_PM_OAI22_X4%A2_c2 VSS x_PM_OAI22_X4%A2_20 6.86365e-18
C_x_PM_OAI22_X4%A2_c3 VSS x_PM_OAI22_X4%A2_18 4.89378e-17
C_x_PM_OAI22_X4%A2_c4 VSS N_A2_M7_g 7.11675e-17
C_x_PM_OAI22_X4%A2_c5 VSS N_A2_M15_g 5.17903e-17
C_x_PM_OAI22_X4%A2_c6 VSS N_A2_M4_g 7.21017e-17
C_x_PM_OAI22_X4%A2_c7 VSS N_A2_M12_g 5.66379e-17
R_x_PM_OAI22_X4%A2_r8 x_PM_OAI22_X4%A2_26 x_PM_OAI22_X4%A2_30 5.46
R_x_PM_OAI22_X4%A2_r9 x_PM_OAI22_X4%A2_26 x_PM_OAI22_X4%A2_24 25.0012
R_x_PM_OAI22_X4%A2_r10 A2 x_PM_OAI22_X4%A2_24 0.0076
R_x_PM_OAI22_X4%A2_r11 x_PM_OAI22_X4%A2_24 x_PM_OAI22_X4%A2_22 0.0988
R_x_PM_OAI22_X4%A2_r12 x_PM_OAI22_X4%A2_36 x_PM_OAI22_X4%A2_20 4.7687
R_x_PM_OAI22_X4%A2_r13 x_PM_OAI22_X4%A2_35 x_PM_OAI22_X4%A2_20 4.7687
R_x_PM_OAI22_X4%A2_r14 x_PM_OAI22_X4%A2_20 x_PM_OAI22_X4%A2_18 25.0012
R_x_PM_OAI22_X4%A2_r15 x_PM_OAI22_X4%A2_22 x_PM_OAI22_X4%A2_17 0.095
R_x_PM_OAI22_X4%A2_r16 x_PM_OAI22_X4%A2_18 x_PM_OAI22_X4%A2_17 2.23929
R_x_PM_OAI22_X4%A2_r17 N_A2_M7_g x_PM_OAI22_X4%A2_36 75.66
R_x_PM_OAI22_X4%A2_r18 N_A2_M15_g x_PM_OAI22_X4%A2_35 45.24
R_x_PM_OAI22_X4%A2_r19 x_PM_OAI22_X4%A2_30 x_PM_OAI22_X4%A2_5 1.95
R_x_PM_OAI22_X4%A2_r20 N_A2_M4_g x_PM_OAI22_X4%A2_5 70.2
R_x_PM_OAI22_X4%A2_r21 x_PM_OAI22_X4%A2_30 x_PM_OAI22_X4%A2_VSS 1.95
R_x_PM_OAI22_X4%A2_r22 N_A2_M12_g x_PM_OAI22_X4%A2_VSS 50.7
C_x_PM_OAI22_X4%A1_c0 VSS x_PM_OAI22_X4%A1_22 4.23234e-18
C_x_PM_OAI22_X4%A1_c1 VSS x_PM_OAI22_X4%A1_20 4.23004e-17
C_x_PM_OAI22_X4%A1_c2 VSS x_PM_OAI22_X4%A1_19 4.31589e-18
C_x_PM_OAI22_X4%A1_c3 VSS N_A1_M6_g 3.62809e-17
C_x_PM_OAI22_X4%A1_c4 VSS N_A1_M14_g 6.16007e-17
C_x_PM_OAI22_X4%A1_c5 VSS x_PM_OAI22_X4%A1_9 5.44928e-18
C_x_PM_OAI22_X4%A1_c6 VSS N_A1_M5_g 4.12042e-17
C_x_PM_OAI22_X4%A1_c7 VSS N_A1_M13_g 6.23715e-17
R_x_PM_OAI22_X4%A1_r8 x_PM_OAI22_X4%A1_22 x_PM_OAI22_X4%A1_20 25.0012
R_x_PM_OAI22_X4%A1_r9 A1 x_PM_OAI22_X4%A1_20 0.232222
R_x_PM_OAI22_X4%A1_r10 x_PM_OAI22_X4%A1_22 x_PM_OAI22_X4%A1_15 4.56151
R_x_PM_OAI22_X4%A1_r11 N_A1_M6_g x_PM_OAI22_X4%A1_15 39
R_x_PM_OAI22_X4%A1_r12 x_PM_OAI22_X4%A1_22 x_PM_OAI22_X4%A1_11 4.56151
R_x_PM_OAI22_X4%A1_r13 N_A1_M14_g x_PM_OAI22_X4%A1_11 81.9
R_x_PM_OAI22_X4%A1_r14 x_PM_OAI22_X4%A1_19 x_PM_OAI22_X4%A1_10 0.043368
R_x_PM_OAI22_X4%A1_r15 x_PM_OAI22_X4%A1_22 x_PM_OAI22_X4%A1_9 0.043368
R_x_PM_OAI22_X4%A1_r16 x_PM_OAI22_X4%A1_10 x_PM_OAI22_X4%A1_9 14.56
R_x_PM_OAI22_X4%A1_r17 x_PM_OAI22_X4%A1_19 x_PM_OAI22_X4%A1_5 4.56151
R_x_PM_OAI22_X4%A1_r18 N_A1_M5_g x_PM_OAI22_X4%A1_5 39
R_x_PM_OAI22_X4%A1_r19 x_PM_OAI22_X4%A1_19 x_PM_OAI22_X4%A1_VSS 4.56151
R_x_PM_OAI22_X4%A1_r20 N_A1_M13_g x_PM_OAI22_X4%A1_VSS 81.9
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OAI33_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OAI33_X1 VSS VDD B3 B2 B1 ZN A1 A2 A3
*.PININFO VSS:B VDD:B B3:I B2:I B1:I ZN:O A1:I A2:I A3:I
M_M6 noxref_11 N_B3_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 noxref_12 N_B2_M1_g noxref_11 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M8 N_ZN_M2_d N_B1_M2_g noxref_12 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M9 noxref_13 N_A1_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.260000U L=0.050000U
M_M10 noxref_14 N_A2_M4_g noxref_13 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M11 N_VDD_M5_d N_A3_M5_g noxref_14 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M0 N_4_M6_d N_B3_M6_g N_VSS_M6_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M7_d N_B2_M7_g N_4_M6_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_4_M8_d N_B1_M8_g N_VSS_M7_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_ZN_M9_d N_A1_M9_g N_4_M8_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_4_M10_d N_A2_M10_g N_ZN_M9_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M5 N_ZN_M11_d N_A3_M11_g N_4_M10_d VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_OAI33_X1%VSS_c0 VSS x_PM_OAI33_X1%VSS_17 2.954e-18
C_x_PM_OAI33_X1%VSS_c1 VSS VSS 1.42911e-16
C_x_PM_OAI33_X1%VSS_c2 VSS N_VSS_M7_d 4.71396e-17
C_x_PM_OAI33_X1%VSS_c3 VSS x_PM_OAI33_X1%VSS_8 1.20086e-17
C_x_PM_OAI33_X1%VSS_c4 VSS x_PM_OAI33_X1%VSS_7 2.01948e-17
C_x_PM_OAI33_X1%VSS_c5 VSS N_VSS_M6_s 2.27911e-17
R_x_PM_OAI33_X1%VSS_r6 x_PM_OAI33_X1%VSS_17 x_PM_OAI33_X1%VSS_13 0.0731438
R_x_PM_OAI33_X1%VSS_r7 VSS x_PM_OAI33_X1%VSS_13 0.368824
R_x_PM_OAI33_X1%VSS_r8 x_PM_OAI33_X1%VSS_17 x_PM_OAI33_X1%VSS_9 0.145286
R_x_PM_OAI33_X1%VSS_r9 N_VSS_M7_d x_PM_OAI33_X1%VSS_9 1.15357
R_x_PM_OAI33_X1%VSS_r10 x_PM_OAI33_X1%VSS_17 x_PM_OAI33_X1%VSS_7 0.0731438
R_x_PM_OAI33_X1%VSS_r11 x_PM_OAI33_X1%VSS_8 x_PM_OAI33_X1%VSS_7 0.681765
R_x_PM_OAI33_X1%VSS_r12 x_PM_OAI33_X1%VSS_8 x_PM_OAI33_X1%VSS_3 0.264221
R_x_PM_OAI33_X1%VSS_r13 N_VSS_M6_s x_PM_OAI33_X1%VSS_3 1.15357
C_x_PM_OAI33_X1%VDD_c0 VSS VDD 1.18251e-17
C_x_PM_OAI33_X1%VDD_c1 VSS N_VDD_M5_d 3.07849e-17
C_x_PM_OAI33_X1%VDD_c2 VSS x_PM_OAI33_X1%VDD_7 1.06147e-16
C_x_PM_OAI33_X1%VDD_c3 VSS N_VDD_M0_s 2.1487e-17
R_x_PM_OAI33_X1%VDD_r4 x_PM_OAI33_X1%VDD_16 VDD 0.2432
R_x_PM_OAI33_X1%VDD_r5 x_PM_OAI33_X1%VDD_15 VDD 0.0881799
R_x_PM_OAI33_X1%VDD_r6 N_VDD_M5_d x_PM_OAI33_X1%VDD_9 0.230714
R_x_PM_OAI33_X1%VDD_r7 x_PM_OAI33_X1%VDD_16 x_PM_OAI33_X1%VDD_8 0.095
R_x_PM_OAI33_X1%VDD_r8 x_PM_OAI33_X1%VDD_9 x_PM_OAI33_X1%VDD_7 0.264221
R_x_PM_OAI33_X1%VDD_r9 x_PM_OAI33_X1%VDD_8 x_PM_OAI33_X1%VDD_7 2.38059
R_x_PM_OAI33_X1%VDD_r10 N_VDD_M0_s x_PM_OAI33_X1%VDD_15 0.230714
C_x_PM_OAI33_X1%B3_c0 VSS x_PM_OAI33_X1%B3_18 7.574e-18
C_x_PM_OAI33_X1%B3_c1 VSS x_PM_OAI33_X1%B3_12 1.36881e-17
C_x_PM_OAI33_X1%B3_c2 VSS N_B3_M0_g 6.84477e-17
C_x_PM_OAI33_X1%B3_c3 VSS N_B3_M6_g 3.8655e-17
R_x_PM_OAI33_X1%B3_r4 x_PM_OAI33_X1%B3_18 x_PM_OAI33_X1%B3_14 3.38
R_x_PM_OAI33_X1%B3_r5 x_PM_OAI33_X1%B3_14 x_PM_OAI33_X1%B3_12 25.0012
R_x_PM_OAI33_X1%B3_r6 x_PM_OAI33_X1%B3_12 B3 0.156071
R_x_PM_OAI33_X1%B3_r7 x_PM_OAI33_X1%B3_18 x_PM_OAI33_X1%B3_5 1.95
R_x_PM_OAI33_X1%B3_r8 N_B3_M0_g x_PM_OAI33_X1%B3_5 80.34
R_x_PM_OAI33_X1%B3_r9 x_PM_OAI33_X1%B3_18 x_PM_OAI33_X1%B3_VSS 1.95
R_x_PM_OAI33_X1%B3_r10 N_B3_M6_g x_PM_OAI33_X1%B3_VSS 41.34
C_x_PM_OAI33_X1%4_c0 VSS x_PM_OAI33_X1%4_15 2.402e-17
C_x_PM_OAI33_X1%4_c1 VSS x_PM_OAI33_X1%4_14 1.06127e-16
C_x_PM_OAI33_X1%4_c2 VSS N_4_M8_d 2.81383e-17
C_x_PM_OAI33_X1%4_c3 VSS x_PM_OAI33_X1%4_9 8.56297e-18
C_x_PM_OAI33_X1%4_c4 VSS x_PM_OAI33_X1%4_8 6.03957e-17
C_x_PM_OAI33_X1%4_c5 VSS N_4_M6_d 2.35363e-17
C_x_PM_OAI33_X1%4_c6 VSS N_4_M10_d 2.31552e-17
R_x_PM_OAI33_X1%4_r7 x_PM_OAI33_X1%4_16 x_PM_OAI33_X1%4_14 0.212317
R_x_PM_OAI33_X1%4_r8 x_PM_OAI33_X1%4_15 x_PM_OAI33_X1%4_14 1.62857
R_x_PM_OAI33_X1%4_r9 N_4_M8_d x_PM_OAI33_X1%4_11 0.719286
R_x_PM_OAI33_X1%4_r10 x_PM_OAI33_X1%4_15 x_PM_OAI33_X1%4_10 0.212317
R_x_PM_OAI33_X1%4_r11 N_4_M8_d x_PM_OAI33_X1%4_10 0.420714
R_x_PM_OAI33_X1%4_r12 x_PM_OAI33_X1%4_11 x_PM_OAI33_X1%4_8 0.212317
R_x_PM_OAI33_X1%4_r13 x_PM_OAI33_X1%4_9 x_PM_OAI33_X1%4_8 1.68286
R_x_PM_OAI33_X1%4_r14 x_PM_OAI33_X1%4_9 x_PM_OAI33_X1%4_4 0.212317
R_x_PM_OAI33_X1%4_r15 N_4_M6_d x_PM_OAI33_X1%4_4 0.420714
R_x_PM_OAI33_X1%4_r16 N_4_M10_d x_PM_OAI33_X1%4_16 0.420714
C_x_PM_OAI33_X1%B2_c0 VSS x_PM_OAI33_X1%B2_13 8.37768e-18
C_x_PM_OAI33_X1%B2_c1 VSS B2 4.91397e-17
C_x_PM_OAI33_X1%B2_c2 VSS N_B2_M1_g 4.77711e-17
C_x_PM_OAI33_X1%B2_c3 VSS N_B2_M7_g 6.17763e-17
R_x_PM_OAI33_X1%B2_r4 x_PM_OAI33_X1%B2_16 x_PM_OAI33_X1%B2_13 4.7687
R_x_PM_OAI33_X1%B2_r5 x_PM_OAI33_X1%B2_15 x_PM_OAI33_X1%B2_13 4.7687
R_x_PM_OAI33_X1%B2_r6 x_PM_OAI33_X1%B2_13 x_PM_OAI33_X1%B2_11 25.0012
R_x_PM_OAI33_X1%B2_r7 x_PM_OAI33_X1%B2_11 B2 0.240878
R_x_PM_OAI33_X1%B2_r8 N_B2_M1_g x_PM_OAI33_X1%B2_16 46.02
R_x_PM_OAI33_X1%B2_r9 N_B2_M7_g x_PM_OAI33_X1%B2_15 75.66
C_x_PM_OAI33_X1%B1_c0 VSS x_PM_OAI33_X1%B1_20 1.04144e-17
C_x_PM_OAI33_X1%B1_c1 VSS B1 4.21647e-17
C_x_PM_OAI33_X1%B1_c2 VSS x_PM_OAI33_X1%B1_10 7.8326e-17
C_x_PM_OAI33_X1%B1_c3 VSS N_B1_M2_g 5.63189e-17
C_x_PM_OAI33_X1%B1_c4 VSS N_B1_M8_g 5.40318e-17
R_x_PM_OAI33_X1%B1_r5 x_PM_OAI33_X1%B1_16 B1 0.28578
R_x_PM_OAI33_X1%B1_r6 x_PM_OAI33_X1%B1_20 x_PM_OAI33_X1%B1_12 3.38
R_x_PM_OAI33_X1%B1_r7 x_PM_OAI33_X1%B1_12 x_PM_OAI33_X1%B1_10 25.0012
R_x_PM_OAI33_X1%B1_r8 x_PM_OAI33_X1%B1_10 x_PM_OAI33_X1%B1_16 1.28929
R_x_PM_OAI33_X1%B1_r9 x_PM_OAI33_X1%B1_20 x_PM_OAI33_X1%B1_5 1.95
R_x_PM_OAI33_X1%B1_r10 N_B1_M2_g x_PM_OAI33_X1%B1_5 62.4
R_x_PM_OAI33_X1%B1_r11 x_PM_OAI33_X1%B1_20 x_PM_OAI33_X1%B1_VSS 1.95
R_x_PM_OAI33_X1%B1_r12 N_B1_M8_g x_PM_OAI33_X1%B1_VSS 59.28
C_x_PM_OAI33_X1%ZN_c0 VSS x_PM_OAI33_X1%ZN_22 1.64935e-17
C_x_PM_OAI33_X1%ZN_c1 VSS N_ZN_M11_d 2.41781e-17
C_x_PM_OAI33_X1%ZN_c2 VSS x_PM_OAI33_X1%ZN_16 3.67726e-17
C_x_PM_OAI33_X1%ZN_c3 VSS N_ZN_M9_d 5.22566e-17
C_x_PM_OAI33_X1%ZN_c4 VSS x_PM_OAI33_X1%ZN_11 2.23265e-17
C_x_PM_OAI33_X1%ZN_c5 VSS x_PM_OAI33_X1%ZN_10 1.60366e-17
C_x_PM_OAI33_X1%ZN_c6 VSS ZN 1.26164e-16
R_x_PM_OAI33_X1%ZN_r7 N_ZN_M11_d x_PM_OAI33_X1%ZN_18 1.15357
R_x_PM_OAI33_X1%ZN_r8 x_PM_OAI33_X1%ZN_22 x_PM_OAI33_X1%ZN_17 0.160909
R_x_PM_OAI33_X1%ZN_r9 x_PM_OAI33_X1%ZN_18 x_PM_OAI33_X1%ZN_16 0.212317
R_x_PM_OAI33_X1%ZN_r10 x_PM_OAI33_X1%ZN_17 x_PM_OAI33_X1%ZN_16 1.68286
R_x_PM_OAI33_X1%ZN_r11 x_PM_OAI33_X1%ZN_22 x_PM_OAI33_X1%ZN_12 0.0418175
R_x_PM_OAI33_X1%ZN_r12 N_ZN_M9_d x_PM_OAI33_X1%ZN_12 1.15357
R_x_PM_OAI33_X1%ZN_r13 x_PM_OAI33_X1%ZN_22 x_PM_OAI33_X1%ZN_10 0.160909
R_x_PM_OAI33_X1%ZN_r14 x_PM_OAI33_X1%ZN_11 x_PM_OAI33_X1%ZN_10 0.597143
R_x_PM_OAI33_X1%ZN_r15 N_ZN_M2_d ZN 1.72357
R_x_PM_OAI33_X1%ZN_r16 x_PM_OAI33_X1%ZN_11 x_PM_OAI33_X1%ZN_4 0.212317
R_x_PM_OAI33_X1%ZN_r17 ZN x_PM_OAI33_X1%ZN_4 0.732857
C_x_PM_OAI33_X1%A1_c0 VSS A1 6.20773e-17
C_x_PM_OAI33_X1%A1_c1 VSS x_PM_OAI33_X1%A1_11 1.17062e-17
C_x_PM_OAI33_X1%A1_c2 VSS N_A1_M3_g 5.57686e-17
C_x_PM_OAI33_X1%A1_c3 VSS N_A1_M9_g 5.80292e-17
R_x_PM_OAI33_X1%A1_r4 x_PM_OAI33_X1%A1_11 x_PM_OAI33_X1%A1_16 4.42
R_x_PM_OAI33_X1%A1_r5 x_PM_OAI33_X1%A1_11 x_PM_OAI33_X1%A1_9 25.0012
R_x_PM_OAI33_X1%A1_r6 A1 x_PM_OAI33_X1%A1_9 0.156071
R_x_PM_OAI33_X1%A1_r7 x_PM_OAI33_X1%A1_16 x_PM_OAI33_X1%A1_5 1.95
R_x_PM_OAI33_X1%A1_r8 N_A1_M3_g x_PM_OAI33_X1%A1_5 57.72
R_x_PM_OAI33_X1%A1_r9 x_PM_OAI33_X1%A1_16 x_PM_OAI33_X1%A1_VSS 1.95
R_x_PM_OAI33_X1%A1_r10 N_A1_M9_g x_PM_OAI33_X1%A1_VSS 63.96
C_x_PM_OAI33_X1%A2_c0 VSS A2 4.07948e-17
C_x_PM_OAI33_X1%A2_c1 VSS x_PM_OAI33_X1%A2_11 1.12464e-17
C_x_PM_OAI33_X1%A2_c2 VSS N_A2_M4_g 4.24595e-17
C_x_PM_OAI33_X1%A2_c3 VSS N_A2_M10_g 7.01278e-17
R_x_PM_OAI33_X1%A2_r4 x_PM_OAI33_X1%A2_11 x_PM_OAI33_X1%A2_16 4.42
R_x_PM_OAI33_X1%A2_r5 x_PM_OAI33_X1%A2_11 x_PM_OAI33_X1%A2_9 25.0012
R_x_PM_OAI33_X1%A2_r6 A2 x_PM_OAI33_X1%A2_9 0.156071
R_x_PM_OAI33_X1%A2_r7 x_PM_OAI33_X1%A2_16 x_PM_OAI33_X1%A2_5 1.95
R_x_PM_OAI33_X1%A2_r8 N_A2_M4_g x_PM_OAI33_X1%A2_5 36.66
R_x_PM_OAI33_X1%A2_r9 x_PM_OAI33_X1%A2_16 x_PM_OAI33_X1%A2_VSS 1.95
R_x_PM_OAI33_X1%A2_r10 N_A2_M10_g x_PM_OAI33_X1%A2_VSS 85.02
C_x_PM_OAI33_X1%A3_c0 VSS A3 4.56087e-17
C_x_PM_OAI33_X1%A3_c1 VSS x_PM_OAI33_X1%A3_11 9.6325e-18
C_x_PM_OAI33_X1%A3_c2 VSS N_A3_M5_g 4.4814e-17
C_x_PM_OAI33_X1%A3_c3 VSS N_A3_M11_g 7.05454e-17
R_x_PM_OAI33_X1%A3_r4 x_PM_OAI33_X1%A3_11 x_PM_OAI33_X1%A3_16 4.42
R_x_PM_OAI33_X1%A3_r5 x_PM_OAI33_X1%A3_11 x_PM_OAI33_X1%A3_9 25.0012
R_x_PM_OAI33_X1%A3_r6 A3 x_PM_OAI33_X1%A3_9 0.156071
R_x_PM_OAI33_X1%A3_r7 x_PM_OAI33_X1%A3_16 x_PM_OAI33_X1%A3_5 1.95
R_x_PM_OAI33_X1%A3_r8 N_A3_M5_g x_PM_OAI33_X1%A3_5 36.66
R_x_PM_OAI33_X1%A3_r9 x_PM_OAI33_X1%A3_16 x_PM_OAI33_X1%A3_VSS 1.95
R_x_PM_OAI33_X1%A3_r10 N_A3_M11_g x_PM_OAI33_X1%A3_VSS 85.02
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X1 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 7 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g 7 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_3_M3_d N_A1_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g N_3_M3_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_OR2_X1%VSS_c0 VSS x_PM_OR2_X1%VSS_17 4.09426e-17
C_x_PM_OR2_X1%VSS_c1 VSS N_VSS_M4_d 3.99217e-17
C_x_PM_OR2_X1%VSS_c2 VSS x_PM_OR2_X1%VSS_8 1.08425e-17
C_x_PM_OR2_X1%VSS_c3 VSS x_PM_OR2_X1%VSS_7 3.20626e-17
C_x_PM_OR2_X1%VSS_c4 VSS N_VSS_M3_s 3.37407e-17
R_x_PM_OR2_X1%VSS_r5 x_PM_OR2_X1%VSS_17 x_PM_OR2_X1%VSS_11 0.145286
R_x_PM_OR2_X1%VSS_r6 N_VSS_M4_d x_PM_OR2_X1%VSS_11 0.637857
R_x_PM_OR2_X1%VSS_r7 VSS x_PM_OR2_X1%VSS_8 0.603529
R_x_PM_OR2_X1%VSS_r8 x_PM_OR2_X1%VSS_17 x_PM_OR2_X1%VSS_7 0.0731438
R_x_PM_OR2_X1%VSS_r9 VSS x_PM_OR2_X1%VSS_7 0.0782353
R_x_PM_OR2_X1%VSS_r10 x_PM_OR2_X1%VSS_8 x_PM_OR2_X1%VSS_3 0.264221
R_x_PM_OR2_X1%VSS_r11 N_VSS_M3_s x_PM_OR2_X1%VSS_3 0.637857
C_x_PM_OR2_X1%VDD_c0 VSS x_PM_OR2_X1%VDD_12 3.43525e-17
C_x_PM_OR2_X1%VDD_c1 VSS N_VDD_M1_d 3.10797e-17
C_x_PM_OR2_X1%VDD_c2 VSS x_PM_OR2_X1%VDD_2 6.54571e-17
R_x_PM_OR2_X1%VDD_r3 x_PM_OR2_X1%VDD_12 x_PM_OR2_X1%VDD_6 0.145286
R_x_PM_OR2_X1%VDD_r4 N_VDD_M1_d x_PM_OR2_X1%VDD_6 0.556429
R_x_PM_OR2_X1%VDD_r5 x_PM_OR2_X1%VDD_12 x_PM_OR2_X1%VDD_2 0.0731438
R_x_PM_OR2_X1%VDD_r6 VDD x_PM_OR2_X1%VDD_2 0.469412
C_x_PM_OR2_X1%3_c0 VSS x_PM_OR2_X1%3_31 1.55893e-17
C_x_PM_OR2_X1%3_c1 VSS x_PM_OR2_X1%3_26 5.29956e-17
C_x_PM_OR2_X1%3_c2 VSS N_3_M3_d 4.31885e-17
C_x_PM_OR2_X1%3_c3 VSS x_PM_OR2_X1%3_18 2.10841e-17
C_x_PM_OR2_X1%3_c4 VSS x_PM_OR2_X1%3_17 1.19023e-17
C_x_PM_OR2_X1%3_c5 VSS N_3_M0_s 3.20288e-17
C_x_PM_OR2_X1%3_c6 VSS x_PM_OR2_X1%3_13 7.52727e-18
C_x_PM_OR2_X1%3_c7 VSS x_PM_OR2_X1%3_12 6.94036e-17
C_x_PM_OR2_X1%3_c8 VSS N_3_M2_g 1.01647e-16
C_x_PM_OR2_X1%3_c9 VSS N_3_M5_g 2.72282e-17
R_x_PM_OR2_X1%3_r10 x_PM_OR2_X1%3_31 x_PM_OR2_X1%3_29 5.46
R_x_PM_OR2_X1%3_r11 x_PM_OR2_X1%3_29 x_PM_OR2_X1%3_26 25.0012
R_x_PM_OR2_X1%3_r12 x_PM_OR2_X1%3_26 x_PM_OR2_X1%3_24 1.28929
R_x_PM_OR2_X1%3_r13 x_PM_OR2_X1%3_24 x_PM_OR2_X1%3_19 0.095
R_x_PM_OR2_X1%3_r14 N_3_M3_d x_PM_OR2_X1%3_19 0.637857
R_x_PM_OR2_X1%3_r15 x_PM_OR2_X1%3_24 x_PM_OR2_X1%3_17 0.19
R_x_PM_OR2_X1%3_r16 x_PM_OR2_X1%3_18 x_PM_OR2_X1%3_17 0.651429
R_x_PM_OR2_X1%3_r17 N_3_M0_s x_PM_OR2_X1%3_13 0.152
R_x_PM_OR2_X1%3_r18 x_PM_OR2_X1%3_12 x_PM_OR2_X1%3_13 0.192227
R_x_PM_OR2_X1%3_r19 x_PM_OR2_X1%3_18 x_PM_OR2_X1%3_11 0.212317
R_x_PM_OR2_X1%3_r20 x_PM_OR2_X1%3_12 x_PM_OR2_X1%3_11 3.69143
R_x_PM_OR2_X1%3_r21 x_PM_OR2_X1%3_31 x_PM_OR2_X1%3_5 1.95
R_x_PM_OR2_X1%3_r22 N_3_M2_g x_PM_OR2_X1%3_5 121.29
R_x_PM_OR2_X1%3_r23 x_PM_OR2_X1%3_31 x_PM_OR2_X1%3_VSS 1.95
R_x_PM_OR2_X1%3_r24 N_3_M5_g x_PM_OR2_X1%3_VSS 18.72
C_x_PM_OR2_X1%A1_c0 VSS x_PM_OR2_X1%A1_16 5.41908e-17
C_x_PM_OR2_X1%A1_c1 VSS x_PM_OR2_X1%A1_15 1.80685e-17
C_x_PM_OR2_X1%A1_c2 VSS x_PM_OR2_X1%A1_14 7.44681e-18
C_x_PM_OR2_X1%A1_c3 VSS x_PM_OR2_X1%A1_12 1.18004e-17
C_x_PM_OR2_X1%A1_c4 VSS x_PM_OR2_X1%A1_10 2.09293e-17
C_x_PM_OR2_X1%A1_c5 VSS N_A1_M0_g 3.57734e-17
C_x_PM_OR2_X1%A1_c6 VSS N_A1_M3_g 9.8326e-17
R_x_PM_OR2_X1%A1_r7 A1 x_PM_OR2_X1%A1_16 0.217143
R_x_PM_OR2_X1%A1_r8 x_PM_OR2_X1%A1_16 x_PM_OR2_X1%A1_15 0.212317
R_x_PM_OR2_X1%A1_r9 x_PM_OR2_X1%A1_15 x_PM_OR2_X1%A1_14 0.515714
R_x_PM_OR2_X1%A1_r10 x_PM_OR2_X1%A1_12 x_PM_OR2_X1%A1_20 3.38
R_x_PM_OR2_X1%A1_r11 x_PM_OR2_X1%A1_12 x_PM_OR2_X1%A1_10 25.0012
R_x_PM_OR2_X1%A1_r12 x_PM_OR2_X1%A1_14 x_PM_OR2_X1%A1_9 0.192227
R_x_PM_OR2_X1%A1_r13 x_PM_OR2_X1%A1_10 x_PM_OR2_X1%A1_9 0.152
R_x_PM_OR2_X1%A1_r14 x_PM_OR2_X1%A1_20 x_PM_OR2_X1%A1_5 1.95
R_x_PM_OR2_X1%A1_r15 N_A1_M0_g x_PM_OR2_X1%A1_5 28.47
R_x_PM_OR2_X1%A1_r16 x_PM_OR2_X1%A1_20 x_PM_OR2_X1%A1_VSS 1.95
R_x_PM_OR2_X1%A1_r17 N_A1_M3_g x_PM_OR2_X1%A1_VSS 116.22
C_x_PM_OR2_X1%A2_c0 VSS A2 3.78252e-17
C_x_PM_OR2_X1%A2_c1 VSS x_PM_OR2_X1%A2_11 8.72282e-18
C_x_PM_OR2_X1%A2_c2 VSS N_A2_M1_g 7.07568e-17
C_x_PM_OR2_X1%A2_c3 VSS N_A2_M4_g 5.24847e-17
R_x_PM_OR2_X1%A2_r4 x_PM_OR2_X1%A2_18 x_PM_OR2_X1%A2_11 4.7687
R_x_PM_OR2_X1%A2_r5 x_PM_OR2_X1%A2_17 x_PM_OR2_X1%A2_11 4.7687
R_x_PM_OR2_X1%A2_r6 x_PM_OR2_X1%A2_11 x_PM_OR2_X1%A2_9 25.0012
R_x_PM_OR2_X1%A2_r7 A2 x_PM_OR2_X1%A2_9 0.346071
R_x_PM_OR2_X1%A2_r8 N_A2_M1_g x_PM_OR2_X1%A2_18 84.63
R_x_PM_OR2_X1%A2_r9 N_A2_M4_g x_PM_OR2_X1%A2_17 60.06
C_x_PM_OR2_X1%ZN_c0 VSS N_ZN_M5_d 1.29058e-16
R_x_PM_OR2_X1%ZN_r1 N_ZN_M2_d ZN 2.83643
R_x_PM_OR2_X1%ZN_r2 ZN N_ZN_M5_d 2.23929
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X2 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 7 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g 7 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_3_M3_d N_A1_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g N_3_M3_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_OR2_X2%VSS_c0 VSS x_PM_OR2_X2%VSS_15 3.72032e-17
C_x_PM_OR2_X2%VSS_c1 VSS N_VSS_M4_d 1.48795e-17
C_x_PM_OR2_X2%VSS_c2 VSS x_PM_OR2_X2%VSS_6 1.07612e-17
C_x_PM_OR2_X2%VSS_c3 VSS x_PM_OR2_X2%VSS_5 3.45483e-17
C_x_PM_OR2_X2%VSS_c4 VSS x_PM_OR2_X2%VSS_4 2.26908e-17
R_x_PM_OR2_X2%VSS_r5 x_PM_OR2_X2%VSS_15 x_PM_OR2_X2%VSS_9 0.145286
R_x_PM_OR2_X2%VSS_r6 N_VSS_M4_d x_PM_OR2_X2%VSS_9 0.230714
R_x_PM_OR2_X2%VSS_r7 VSS x_PM_OR2_X2%VSS_6 0.603529
R_x_PM_OR2_X2%VSS_r8 x_PM_OR2_X2%VSS_15 x_PM_OR2_X2%VSS_5 0.0731438
R_x_PM_OR2_X2%VSS_r9 VSS x_PM_OR2_X2%VSS_5 0.134118
R_x_PM_OR2_X2%VSS_r10 x_PM_OR2_X2%VSS_6 x_PM_OR2_X2%VSS_4 0.264221
R_x_PM_OR2_X2%VSS_r11 x_PM_OR2_X2%VSS_4 N_VSS_M3_s 0.543196
C_x_PM_OR2_X2%VDD_c0 VSS x_PM_OR2_X2%VDD_12 4.05231e-17
C_x_PM_OR2_X2%VDD_c1 VSS N_VDD_M1_d 2.06356e-17
C_x_PM_OR2_X2%VDD_c2 VSS x_PM_OR2_X2%VDD_2 4.07936e-17
R_x_PM_OR2_X2%VDD_r3 x_PM_OR2_X2%VDD_12 x_PM_OR2_X2%VDD_6 0.145286
R_x_PM_OR2_X2%VDD_r4 N_VDD_M1_d x_PM_OR2_X2%VDD_6 0.420714
R_x_PM_OR2_X2%VDD_r5 x_PM_OR2_X2%VDD_12 x_PM_OR2_X2%VDD_2 0.0731438
R_x_PM_OR2_X2%VDD_r6 VDD x_PM_OR2_X2%VDD_2 0.0782353
C_x_PM_OR2_X2%3_c0 VSS x_PM_OR2_X2%3_31 1.75553e-17
C_x_PM_OR2_X2%3_c1 VSS x_PM_OR2_X2%3_28 1.72947e-17
C_x_PM_OR2_X2%3_c2 VSS x_PM_OR2_X2%3_25 5.24935e-17
C_x_PM_OR2_X2%3_c3 VSS x_PM_OR2_X2%3_22 2.8529e-17
C_x_PM_OR2_X2%3_c4 VSS N_3_M3_d 4.52149e-17
C_x_PM_OR2_X2%3_c5 VSS x_PM_OR2_X2%3_16 1.69957e-17
C_x_PM_OR2_X2%3_c6 VSS x_PM_OR2_X2%3_15 3.68802e-17
C_x_PM_OR2_X2%3_c7 VSS N_3_M0_s 4.3344e-17
C_x_PM_OR2_X2%3_c8 VSS N_3_M2_g 9.38216e-17
C_x_PM_OR2_X2%3_c9 VSS N_3_M5_g 4.44376e-17
R_x_PM_OR2_X2%3_r10 x_PM_OR2_X2%3_31 x_PM_OR2_X2%3_29 7.54
R_x_PM_OR2_X2%3_r11 x_PM_OR2_X2%3_29 x_PM_OR2_X2%3_25 25.0012
R_x_PM_OR2_X2%3_r12 x_PM_OR2_X2%3_28 x_PM_OR2_X2%3_23 0.0418175
R_x_PM_OR2_X2%3_r13 x_PM_OR2_X2%3_25 x_PM_OR2_X2%3_23 1.045
R_x_PM_OR2_X2%3_r14 x_PM_OR2_X2%3_28 x_PM_OR2_X2%3_21 0.160909
R_x_PM_OR2_X2%3_r15 x_PM_OR2_X2%3_22 x_PM_OR2_X2%3_21 0.705714
R_x_PM_OR2_X2%3_r16 x_PM_OR2_X2%3_28 x_PM_OR2_X2%3_17 0.160909
R_x_PM_OR2_X2%3_r17 N_3_M3_d x_PM_OR2_X2%3_17 1.045
R_x_PM_OR2_X2%3_r18 x_PM_OR2_X2%3_22 x_PM_OR2_X2%3_15 0.212317
R_x_PM_OR2_X2%3_r19 x_PM_OR2_X2%3_16 x_PM_OR2_X2%3_15 0.651429
R_x_PM_OR2_X2%3_r20 x_PM_OR2_X2%3_16 x_PM_OR2_X2%3_11 0.212317
R_x_PM_OR2_X2%3_r21 N_3_M0_s x_PM_OR2_X2%3_11 2.29357
R_x_PM_OR2_X2%3_r22 x_PM_OR2_X2%3_31 x_PM_OR2_X2%3_5 1.95
R_x_PM_OR2_X2%3_r23 N_3_M2_g x_PM_OR2_X2%3_5 99.84
R_x_PM_OR2_X2%3_r24 x_PM_OR2_X2%3_31 x_PM_OR2_X2%3_VSS 1.95
R_x_PM_OR2_X2%3_r25 N_3_M5_g x_PM_OR2_X2%3_VSS 38.22
C_x_PM_OR2_X2%A1_c0 VSS x_PM_OR2_X2%A1_18 8.81315e-18
C_x_PM_OR2_X2%A1_c1 VSS x_PM_OR2_X2%A1_12 5.4822e-17
C_x_PM_OR2_X2%A1_c2 VSS N_A1_M0_g 8.90209e-17
C_x_PM_OR2_X2%A1_c3 VSS N_A1_M3_g 3.57915e-17
R_x_PM_OR2_X2%A1_r4 x_PM_OR2_X2%A1_18 x_PM_OR2_X2%A1_14 3.38
R_x_PM_OR2_X2%A1_r5 x_PM_OR2_X2%A1_14 x_PM_OR2_X2%A1_12 25.0012
R_x_PM_OR2_X2%A1_r6 x_PM_OR2_X2%A1_12 A1 0.115357
R_x_PM_OR2_X2%A1_r7 x_PM_OR2_X2%A1_18 x_PM_OR2_X2%A1_5 1.95
R_x_PM_OR2_X2%A1_r8 N_A1_M0_g x_PM_OR2_X2%A1_5 101.01
R_x_PM_OR2_X2%A1_r9 x_PM_OR2_X2%A1_18 x_PM_OR2_X2%A1_VSS 1.95
R_x_PM_OR2_X2%A1_r10 N_A1_M3_g x_PM_OR2_X2%A1_VSS 35.88
C_x_PM_OR2_X2%A2_c0 VSS A2 6.95827e-17
C_x_PM_OR2_X2%A2_c1 VSS x_PM_OR2_X2%A2_11 1.12977e-17
C_x_PM_OR2_X2%A2_c2 VSS N_A2_M1_g 6.44459e-17
C_x_PM_OR2_X2%A2_c3 VSS N_A2_M4_g 5.20861e-17
R_x_PM_OR2_X2%A2_r4 x_PM_OR2_X2%A2_11 x_PM_OR2_X2%A2_16 4.42
R_x_PM_OR2_X2%A2_r5 x_PM_OR2_X2%A2_11 x_PM_OR2_X2%A2_9 25.0012
R_x_PM_OR2_X2%A2_r6 A2 x_PM_OR2_X2%A2_9 0.196786
R_x_PM_OR2_X2%A2_r7 x_PM_OR2_X2%A2_16 x_PM_OR2_X2%A2_5 1.95
R_x_PM_OR2_X2%A2_r8 N_A2_M1_g x_PM_OR2_X2%A2_5 79.95
R_x_PM_OR2_X2%A2_r9 x_PM_OR2_X2%A2_16 x_PM_OR2_X2%A2_VSS 1.95
R_x_PM_OR2_X2%A2_r10 N_A2_M4_g x_PM_OR2_X2%A2_VSS 56.94
C_x_PM_OR2_X2%ZN_c0 VSS N_ZN_M5_d 1.3351e-16
R_x_PM_OR2_X2%ZN_r1 N_ZN_M2_d ZN 2.23929
R_x_PM_OR2_X2%ZN_r2 ZN N_ZN_M5_d 2.91786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR2_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR2_X4 VSS VDD A1 A2 ZN
*.PININFO VSS:B VDD:B A1:I A2:I ZN:O
M_M3 7 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M4 N_VDD_M1_d N_A2_M1_g 7 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_3_M3_d N_A1_M3_g N_VSS_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M4_d N_A2_M4_g N_3_M3_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_OR2_X4%VSS_c0 VSS x_PM_OR2_X4%VSS_17 2.96954e-17
C_x_PM_OR2_X4%VSS_c1 VSS N_VSS_M4_d 2.63308e-17
C_x_PM_OR2_X4%VSS_c2 VSS x_PM_OR2_X4%VSS_8 1.14319e-17
C_x_PM_OR2_X4%VSS_c3 VSS x_PM_OR2_X4%VSS_7 3.41989e-17
C_x_PM_OR2_X4%VSS_c4 VSS N_VSS_M3_s 2.42571e-17
R_x_PM_OR2_X4%VSS_r5 x_PM_OR2_X4%VSS_17 x_PM_OR2_X4%VSS_11 0.145286
R_x_PM_OR2_X4%VSS_r6 N_VSS_M4_d x_PM_OR2_X4%VSS_11 0.637857
R_x_PM_OR2_X4%VSS_r7 VSS x_PM_OR2_X4%VSS_8 0.581176
R_x_PM_OR2_X4%VSS_r8 x_PM_OR2_X4%VSS_17 x_PM_OR2_X4%VSS_7 0.0731438
R_x_PM_OR2_X4%VSS_r9 VSS x_PM_OR2_X4%VSS_7 0.100588
R_x_PM_OR2_X4%VSS_r10 x_PM_OR2_X4%VSS_8 x_PM_OR2_X4%VSS_3 0.264221
R_x_PM_OR2_X4%VSS_r11 N_VSS_M3_s x_PM_OR2_X4%VSS_3 0.637857
C_x_PM_OR2_X4%VDD_c0 VSS x_PM_OR2_X4%VDD_11 2.94911e-17
C_x_PM_OR2_X4%VDD_c1 VSS N_VDD_M1_d 1.56319e-17
C_x_PM_OR2_X4%VDD_c2 VSS x_PM_OR2_X4%VDD_2 4.67893e-17
R_x_PM_OR2_X4%VDD_r3 x_PM_OR2_X4%VDD_11 x_PM_OR2_X4%VDD_5 0.145286
R_x_PM_OR2_X4%VDD_r4 N_VDD_M1_d x_PM_OR2_X4%VDD_5 0.230714
R_x_PM_OR2_X4%VDD_r5 x_PM_OR2_X4%VDD_11 x_PM_OR2_X4%VDD_2 0.0731438
R_x_PM_OR2_X4%VDD_r6 VDD x_PM_OR2_X4%VDD_2 0.100588
C_x_PM_OR2_X4%3_c0 VSS x_PM_OR2_X4%3_33 1.23446e-17
C_x_PM_OR2_X4%3_c1 VSS x_PM_OR2_X4%3_30 2.51577e-18
C_x_PM_OR2_X4%3_c2 VSS N_3_M3_d 4.9544e-17
C_x_PM_OR2_X4%3_c3 VSS x_PM_OR2_X4%3_23 3.20284e-17
C_x_PM_OR2_X4%3_c4 VSS x_PM_OR2_X4%3_19 4.33521e-17
C_x_PM_OR2_X4%3_c5 VSS x_PM_OR2_X4%3_18 8.57602e-17
C_x_PM_OR2_X4%3_c6 VSS x_PM_OR2_X4%3_16 7.28356e-18
C_x_PM_OR2_X4%3_c7 VSS x_PM_OR2_X4%3_15 9.91438e-18
C_x_PM_OR2_X4%3_c8 VSS N_3_M0_s 4.43001e-17
C_x_PM_OR2_X4%3_c9 VSS N_3_M2_g 6.44286e-17
C_x_PM_OR2_X4%3_c10 VSS N_3_M5_g 5.77278e-17
R_x_PM_OR2_X4%3_r11 x_PM_OR2_X4%3_33 x_PM_OR2_X4%3_31 3.9
R_x_PM_OR2_X4%3_r12 x_PM_OR2_X4%3_31 x_PM_OR2_X4%3_23 25.0012
R_x_PM_OR2_X4%3_r13 x_PM_OR2_X4%3_23 x_PM_OR2_X4%3_21 0.285
R_x_PM_OR2_X4%3_r14 x_PM_OR2_X4%3_30 x_PM_OR2_X4%3_20 0.160909
R_x_PM_OR2_X4%3_r15 x_PM_OR2_X4%3_21 x_PM_OR2_X4%3_19 0.212317
R_x_PM_OR2_X4%3_r16 x_PM_OR2_X4%3_20 x_PM_OR2_X4%3_19 1.14
R_x_PM_OR2_X4%3_r17 x_PM_OR2_X4%3_30 x_PM_OR2_X4%3_18 0.0418175
R_x_PM_OR2_X4%3_r18 x_PM_OR2_X4%3_17 N_3_M3_d 0.30478
R_x_PM_OR2_X4%3_r19 x_PM_OR2_X4%3_18 x_PM_OR2_X4%3_17 2.44286
R_x_PM_OR2_X4%3_r20 x_PM_OR2_X4%3_30 x_PM_OR2_X4%3_15 0.160909
R_x_PM_OR2_X4%3_r21 x_PM_OR2_X4%3_16 x_PM_OR2_X4%3_15 0.488571
R_x_PM_OR2_X4%3_r22 x_PM_OR2_X4%3_16 x_PM_OR2_X4%3_11 0.212317
R_x_PM_OR2_X4%3_r23 N_3_M0_s x_PM_OR2_X4%3_11 1.88643
R_x_PM_OR2_X4%3_r24 x_PM_OR2_X4%3_33 x_PM_OR2_X4%3_5 1.95
R_x_PM_OR2_X4%3_r25 N_3_M2_g x_PM_OR2_X4%3_5 49.92
R_x_PM_OR2_X4%3_r26 x_PM_OR2_X4%3_33 x_PM_OR2_X4%3_VSS 1.95
R_x_PM_OR2_X4%3_r27 N_3_M5_g x_PM_OR2_X4%3_VSS 46.8
C_x_PM_OR2_X4%A1_c0 VSS x_PM_OR2_X4%A1_18 1.07885e-17
C_x_PM_OR2_X4%A1_c1 VSS x_PM_OR2_X4%A1_12 3.77837e-17
C_x_PM_OR2_X4%A1_c2 VSS N_A1_M0_g 9.12071e-17
C_x_PM_OR2_X4%A1_c3 VSS N_A1_M3_g 3.65541e-17
R_x_PM_OR2_X4%A1_r4 x_PM_OR2_X4%A1_18 x_PM_OR2_X4%A1_14 6.5
R_x_PM_OR2_X4%A1_r5 x_PM_OR2_X4%A1_14 x_PM_OR2_X4%A1_12 25.0012
R_x_PM_OR2_X4%A1_r6 x_PM_OR2_X4%A1_12 A1 0.0610714
R_x_PM_OR2_X4%A1_r7 x_PM_OR2_X4%A1_18 x_PM_OR2_X4%A1_5 1.95
R_x_PM_OR2_X4%A1_r8 N_A1_M0_g x_PM_OR2_X4%A1_5 106.47
R_x_PM_OR2_X4%A1_r9 x_PM_OR2_X4%A1_18 x_PM_OR2_X4%A1_VSS 1.95
R_x_PM_OR2_X4%A1_r10 N_A1_M3_g x_PM_OR2_X4%A1_VSS 38.22
C_x_PM_OR2_X4%A2_c0 VSS x_PM_OR2_X4%A2_14 3.92539e-17
C_x_PM_OR2_X4%A2_c1 VSS x_PM_OR2_X4%A2_12 8.54095e-18
C_x_PM_OR2_X4%A2_c2 VSS x_PM_OR2_X4%A2_10 4.01382e-17
C_x_PM_OR2_X4%A2_c3 VSS N_A2_M1_g 7.6359e-17
C_x_PM_OR2_X4%A2_c4 VSS N_A2_M4_g 4.30075e-17
R_x_PM_OR2_X4%A2_r5 A2 x_PM_OR2_X4%A2_14 0.298571
R_x_PM_OR2_X4%A2_r6 x_PM_OR2_X4%A2_19 x_PM_OR2_X4%A2_12 4.7687
R_x_PM_OR2_X4%A2_r7 x_PM_OR2_X4%A2_18 x_PM_OR2_X4%A2_12 4.7687
R_x_PM_OR2_X4%A2_r8 x_PM_OR2_X4%A2_12 x_PM_OR2_X4%A2_10 25.0012
R_x_PM_OR2_X4%A2_r9 x_PM_OR2_X4%A2_14 x_PM_OR2_X4%A2_9 0.212317
R_x_PM_OR2_X4%A2_r10 x_PM_OR2_X4%A2_10 x_PM_OR2_X4%A2_9 0.339286
R_x_PM_OR2_X4%A2_r11 N_A2_M1_g x_PM_OR2_X4%A2_19 91.65
R_x_PM_OR2_X4%A2_r12 N_A2_M4_g x_PM_OR2_X4%A2_18 53.04
C_x_PM_OR2_X4%ZN_c0 VSS N_ZN_M5_d 9.0912e-17
R_x_PM_OR2_X4%ZN_r1 N_ZN_M2_d ZN 1.72357
R_x_PM_OR2_X4%ZN_r2 ZN N_ZN_M5_d 0.773571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X1 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 8 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M5 9 N_A2_M1_g 8 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g 9 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M4_d N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_3_M5_d N_A2_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_OR3_X1%VSS_c0 VSS x_PM_OR3_X1%VSS_20 4.06149e-17
C_x_PM_OR3_X1%VSS_c1 VSS x_PM_OR3_X1%VSS_19 4.40645e-17
C_x_PM_OR3_X1%VSS_c2 VSS N_VSS_M6_d 4.14256e-17
C_x_PM_OR3_X1%VSS_c3 VSS x_PM_OR3_X1%VSS_9 3.20004e-17
C_x_PM_OR3_X1%VSS_c4 VSS N_VSS_M4_d 4.17341e-17
R_x_PM_OR3_X1%VSS_r5 x_PM_OR3_X1%VSS_20 x_PM_OR3_X1%VSS_13 0.145286
R_x_PM_OR3_X1%VSS_r6 N_VSS_M6_d x_PM_OR3_X1%VSS_13 0.637857
R_x_PM_OR3_X1%VSS_r7 x_PM_OR3_X1%VSS_19 x_PM_OR3_X1%VSS_10 0.0731438
R_x_PM_OR3_X1%VSS_r8 VSS x_PM_OR3_X1%VSS_10 0.324118
R_x_PM_OR3_X1%VSS_r9 x_PM_OR3_X1%VSS_20 x_PM_OR3_X1%VSS_9 0.0731438
R_x_PM_OR3_X1%VSS_r10 VSS x_PM_OR3_X1%VSS_9 0.368824
R_x_PM_OR3_X1%VSS_r11 x_PM_OR3_X1%VSS_19 x_PM_OR3_X1%VSS_5 0.145286
R_x_PM_OR3_X1%VSS_r12 N_VSS_M4_d x_PM_OR3_X1%VSS_5 0.637857
C_x_PM_OR3_X1%VDD_c0 VSS x_PM_OR3_X1%VDD_12 2.76494e-17
C_x_PM_OR3_X1%VDD_c1 VSS N_VDD_M2_d 3.97844e-17
C_x_PM_OR3_X1%VDD_c2 VSS x_PM_OR3_X1%VDD_2 6.6293e-17
R_x_PM_OR3_X1%VDD_r3 x_PM_OR3_X1%VDD_12 x_PM_OR3_X1%VDD_6 0.145286
R_x_PM_OR3_X1%VDD_r4 N_VDD_M2_d x_PM_OR3_X1%VDD_6 1.15357
R_x_PM_OR3_X1%VDD_r5 x_PM_OR3_X1%VDD_12 x_PM_OR3_X1%VDD_2 0.0731438
R_x_PM_OR3_X1%VDD_r6 VDD x_PM_OR3_X1%VDD_2 0.715294
C_x_PM_OR3_X1%3_c0 VSS x_PM_OR3_X1%3_41 1.40027e-17
C_x_PM_OR3_X1%3_c1 VSS x_PM_OR3_X1%3_33 4.06223e-17
C_x_PM_OR3_X1%3_c2 VSS x_PM_OR3_X1%3_32 4.86566e-18
C_x_PM_OR3_X1%3_c3 VSS x_PM_OR3_X1%3_30 2.77906e-18
C_x_PM_OR3_X1%3_c4 VSS x_PM_OR3_X1%3_28 1.94413e-17
C_x_PM_OR3_X1%3_c5 VSS N_3_M5_d 4.01904e-17
C_x_PM_OR3_X1%3_c6 VSS x_PM_OR3_X1%3_22 4.20016e-17
C_x_PM_OR3_X1%3_c7 VSS N_3_M0_s 4.4081e-17
C_x_PM_OR3_X1%3_c8 VSS x_PM_OR3_X1%3_18 4.09434e-18
C_x_PM_OR3_X1%3_c9 VSS x_PM_OR3_X1%3_17 5.72424e-17
C_x_PM_OR3_X1%3_c10 VSS N_3_M4_s 4.51261e-17
C_x_PM_OR3_X1%3_c11 VSS N_3_M3_g 8.69421e-17
C_x_PM_OR3_X1%3_c12 VSS N_3_M7_g 3.15859e-17
R_x_PM_OR3_X1%3_r13 x_PM_OR3_X1%3_41 x_PM_OR3_X1%3_39 5.46
R_x_PM_OR3_X1%3_r14 x_PM_OR3_X1%3_39 x_PM_OR3_X1%3_36 25.0012
R_x_PM_OR3_X1%3_r15 x_PM_OR3_X1%3_36 x_PM_OR3_X1%3_33 0.176429
R_x_PM_OR3_X1%3_r16 x_PM_OR3_X1%3_32 x_PM_OR3_X1%3_29 0.160909
R_x_PM_OR3_X1%3_r17 x_PM_OR3_X1%3_33 x_PM_OR3_X1%3_28 0.095
R_x_PM_OR3_X1%3_r18 x_PM_OR3_X1%3_29 x_PM_OR3_X1%3_28 0.895714
R_x_PM_OR3_X1%3_r19 x_PM_OR3_X1%3_32 x_PM_OR3_X1%3_24 0.0418175
R_x_PM_OR3_X1%3_r20 N_3_M5_d x_PM_OR3_X1%3_24 0.637857
R_x_PM_OR3_X1%3_r21 x_PM_OR3_X1%3_30 x_PM_OR3_X1%3_23 0.0604376
R_x_PM_OR3_X1%3_r22 x_PM_OR3_X1%3_32 x_PM_OR3_X1%3_22 0.160909
R_x_PM_OR3_X1%3_r23 x_PM_OR3_X1%3_23 x_PM_OR3_X1%3_22 1.65571
R_x_PM_OR3_X1%3_r24 N_3_M0_s x_PM_OR3_X1%3_18 0.64
R_x_PM_OR3_X1%3_r25 x_PM_OR3_X1%3_17 x_PM_OR3_X1%3_18 0.217071
R_x_PM_OR3_X1%3_r26 x_PM_OR3_X1%3_30 x_PM_OR3_X1%3_16 0.140052
R_x_PM_OR3_X1%3_r27 x_PM_OR3_X1%3_17 x_PM_OR3_X1%3_16 3.09429
R_x_PM_OR3_X1%3_r28 x_PM_OR3_X1%3_30 x_PM_OR3_X1%3_12 0.140052
R_x_PM_OR3_X1%3_r29 N_3_M4_s x_PM_OR3_X1%3_12 0.47
R_x_PM_OR3_X1%3_r30 x_PM_OR3_X1%3_41 x_PM_OR3_X1%3_5 1.95
R_x_PM_OR3_X1%3_r31 N_3_M3_g x_PM_OR3_X1%3_5 98.67
R_x_PM_OR3_X1%3_r32 x_PM_OR3_X1%3_41 x_PM_OR3_X1%3_VSS 1.95
R_x_PM_OR3_X1%3_r33 N_3_M7_g x_PM_OR3_X1%3_VSS 24.18
C_x_PM_OR3_X1%A1_c0 VSS A1 6.3916e-17
C_x_PM_OR3_X1%A1_c1 VSS x_PM_OR3_X1%A1_11 9.88995e-18
C_x_PM_OR3_X1%A1_c2 VSS N_A1_M0_g 7.34828e-17
C_x_PM_OR3_X1%A1_c3 VSS N_A1_M4_g 5.77126e-17
R_x_PM_OR3_X1%A1_r4 x_PM_OR3_X1%A1_18 x_PM_OR3_X1%A1_11 4.7687
R_x_PM_OR3_X1%A1_r5 x_PM_OR3_X1%A1_17 x_PM_OR3_X1%A1_11 4.7687
R_x_PM_OR3_X1%A1_r6 x_PM_OR3_X1%A1_11 x_PM_OR3_X1%A1_9 25.0012
R_x_PM_OR3_X1%A1_r7 A1 x_PM_OR3_X1%A1_9 0.183214
R_x_PM_OR3_X1%A1_r8 N_A1_M0_g x_PM_OR3_X1%A1_18 73.32
R_x_PM_OR3_X1%A1_r9 N_A1_M4_g x_PM_OR3_X1%A1_17 59.28
C_x_PM_OR3_X1%A2_c0 VSS A2 4.17645e-17
C_x_PM_OR3_X1%A2_c1 VSS x_PM_OR3_X1%A2_11 9.42155e-18
C_x_PM_OR3_X1%A2_c2 VSS N_A2_M1_g 6.36361e-17
C_x_PM_OR3_X1%A2_c3 VSS N_A2_M5_g 5.09843e-17
R_x_PM_OR3_X1%A2_r4 x_PM_OR3_X1%A2_11 x_PM_OR3_X1%A2_16 2.34
R_x_PM_OR3_X1%A2_r5 x_PM_OR3_X1%A2_11 x_PM_OR3_X1%A2_9 25.0012
R_x_PM_OR3_X1%A2_r6 A2 x_PM_OR3_X1%A2_9 0.156071
R_x_PM_OR3_X1%A2_r7 x_PM_OR3_X1%A2_16 x_PM_OR3_X1%A2_5 1.95
R_x_PM_OR3_X1%A2_r8 N_A2_M1_g x_PM_OR3_X1%A2_5 73.32
R_x_PM_OR3_X1%A2_r9 x_PM_OR3_X1%A2_16 x_PM_OR3_X1%A2_VSS 1.95
R_x_PM_OR3_X1%A2_r10 N_A2_M5_g x_PM_OR3_X1%A2_VSS 59.28
C_x_PM_OR3_X1%A3_c0 VSS A3 3.10221e-17
C_x_PM_OR3_X1%A3_c1 VSS x_PM_OR3_X1%A3_11 8.22534e-18
C_x_PM_OR3_X1%A3_c2 VSS N_A3_M2_g 4.05263e-17
C_x_PM_OR3_X1%A3_c3 VSS N_A3_M6_g 7.87657e-17
R_x_PM_OR3_X1%A3_r4 x_PM_OR3_X1%A3_18 x_PM_OR3_X1%A3_11 4.7687
R_x_PM_OR3_X1%A3_r5 x_PM_OR3_X1%A3_17 x_PM_OR3_X1%A3_11 4.7687
R_x_PM_OR3_X1%A3_r6 x_PM_OR3_X1%A3_11 x_PM_OR3_X1%A3_9 25.0012
R_x_PM_OR3_X1%A3_r7 A3 x_PM_OR3_X1%A3_9 0.502143
R_x_PM_OR3_X1%A3_r8 N_A3_M2_g x_PM_OR3_X1%A3_18 29.64
R_x_PM_OR3_X1%A3_r9 N_A3_M6_g x_PM_OR3_X1%A3_17 102.96
C_x_PM_OR3_X1%ZN_c0 VSS N_ZN_M7_d 1.34701e-16
R_x_PM_OR3_X1%ZN_r1 N_ZN_M3_d ZN 1.95938
R_x_PM_OR3_X1%ZN_r2 ZN N_ZN_M7_d 1.95938
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X2 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 8 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M5 9 N_A2_M1_g 8 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g 9 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M4_d N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_3_M5_d N_A2_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_OR3_X2%VSS_c0 VSS x_PM_OR3_X2%VSS_20 3.00757e-17
C_x_PM_OR3_X2%VSS_c1 VSS x_PM_OR3_X2%VSS_19 4.32297e-17
C_x_PM_OR3_X2%VSS_c2 VSS N_VSS_M6_d 3.4177e-17
C_x_PM_OR3_X2%VSS_c3 VSS x_PM_OR3_X2%VSS_9 3.33766e-17
C_x_PM_OR3_X2%VSS_c4 VSS N_VSS_M4_d 3.48682e-17
R_x_PM_OR3_X2%VSS_r5 x_PM_OR3_X2%VSS_20 x_PM_OR3_X2%VSS_13 0.145286
R_x_PM_OR3_X2%VSS_r6 N_VSS_M6_d x_PM_OR3_X2%VSS_13 0.637857
R_x_PM_OR3_X2%VSS_r7 x_PM_OR3_X2%VSS_19 x_PM_OR3_X2%VSS_10 0.0731438
R_x_PM_OR3_X2%VSS_r8 VSS x_PM_OR3_X2%VSS_10 0.346471
R_x_PM_OR3_X2%VSS_r9 x_PM_OR3_X2%VSS_20 x_PM_OR3_X2%VSS_9 0.0731438
R_x_PM_OR3_X2%VSS_r10 VSS x_PM_OR3_X2%VSS_9 0.346471
R_x_PM_OR3_X2%VSS_r11 x_PM_OR3_X2%VSS_19 x_PM_OR3_X2%VSS_5 0.145286
R_x_PM_OR3_X2%VSS_r12 N_VSS_M4_d x_PM_OR3_X2%VSS_5 0.637857
C_x_PM_OR3_X2%VDD_c0 VSS x_PM_OR3_X2%VDD_12 2.99573e-17
C_x_PM_OR3_X2%VDD_c1 VSS N_VDD_M2_d 2.4519e-17
C_x_PM_OR3_X2%VDD_c2 VSS x_PM_OR3_X2%VDD_2 6.11137e-17
R_x_PM_OR3_X2%VDD_r3 x_PM_OR3_X2%VDD_12 x_PM_OR3_X2%VDD_6 0.145286
R_x_PM_OR3_X2%VDD_r4 N_VDD_M2_d x_PM_OR3_X2%VDD_6 0.230714
R_x_PM_OR3_X2%VDD_r5 x_PM_OR3_X2%VDD_12 x_PM_OR3_X2%VDD_2 0.0731438
R_x_PM_OR3_X2%VDD_r6 VDD x_PM_OR3_X2%VDD_2 0.346471
C_x_PM_OR3_X2%3_c0 VSS x_PM_OR3_X2%3_36 1.25891e-17
C_x_PM_OR3_X2%3_c1 VSS x_PM_OR3_X2%3_28 3.72813e-17
C_x_PM_OR3_X2%3_c2 VSS x_PM_OR3_X2%3_27 6.83849e-18
C_x_PM_OR3_X2%3_c3 VSS N_3_M0_s 1.93365e-17
C_x_PM_OR3_X2%3_c4 VSS x_PM_OR3_X2%3_22 2.78594e-18
C_x_PM_OR3_X2%3_c5 VSS x_PM_OR3_X2%3_20 1.68546e-17
C_x_PM_OR3_X2%3_c6 VSS x_PM_OR3_X2%3_19 4.72915e-17
C_x_PM_OR3_X2%3_c7 VSS x_PM_OR3_X2%3_16 4.23999e-17
C_x_PM_OR3_X2%3_c8 VSS x_PM_OR3_X2%3_15 5.85797e-17
C_x_PM_OR3_X2%3_c9 VSS x_PM_OR3_X2%3_13 4.65821e-17
C_x_PM_OR3_X2%3_c10 VSS N_3_M3_g 9.93078e-17
C_x_PM_OR3_X2%3_c11 VSS N_3_M7_g 3.18899e-17
R_x_PM_OR3_X2%3_r12 x_PM_OR3_X2%3_36 x_PM_OR3_X2%3_34 4.42
R_x_PM_OR3_X2%3_r13 x_PM_OR3_X2%3_34 x_PM_OR3_X2%3_31 25.0012
R_x_PM_OR3_X2%3_r14 x_PM_OR3_X2%3_31 x_PM_OR3_X2%3_28 0.176429
R_x_PM_OR3_X2%3_r15 x_PM_OR3_X2%3_27 x_PM_OR3_X2%3_21 0.179556
R_x_PM_OR3_X2%3_r16 x_PM_OR3_X2%3_28 x_PM_OR3_X2%3_20 0.095
R_x_PM_OR3_X2%3_r17 x_PM_OR3_X2%3_21 x_PM_OR3_X2%3_20 0.868571
R_x_PM_OR3_X2%3_r18 x_PM_OR3_X2%3_27 x_PM_OR3_X2%3_19 0.026987
R_x_PM_OR3_X2%3_r19 x_PM_OR3_X2%3_19 N_3_M5_d 0.548724
R_x_PM_OR3_X2%3_r20 x_PM_OR3_X2%3_22 x_PM_OR3_X2%3_17 0.0604376
R_x_PM_OR3_X2%3_r21 x_PM_OR3_X2%3_27 x_PM_OR3_X2%3_16 0.179556
R_x_PM_OR3_X2%3_r22 x_PM_OR3_X2%3_17 x_PM_OR3_X2%3_16 1.68286
R_x_PM_OR3_X2%3_r23 x_PM_OR3_X2%3_15 N_3_M0_s 0.297071
R_x_PM_OR3_X2%3_r24 x_PM_OR3_X2%3_22 x_PM_OR3_X2%3_14 0.140052
R_x_PM_OR3_X2%3_r25 x_PM_OR3_X2%3_15 x_PM_OR3_X2%3_14 3.17571
R_x_PM_OR3_X2%3_r26 x_PM_OR3_X2%3_22 x_PM_OR3_X2%3_13 0.140052
R_x_PM_OR3_X2%3_r27 x_PM_OR3_X2%3_13 N_3_M4_s 0.467567
R_x_PM_OR3_X2%3_r28 x_PM_OR3_X2%3_36 x_PM_OR3_X2%3_5 1.95
R_x_PM_OR3_X2%3_r29 N_3_M3_g x_PM_OR3_X2%3_5 109.98
R_x_PM_OR3_X2%3_r30 x_PM_OR3_X2%3_36 x_PM_OR3_X2%3_VSS 1.95
R_x_PM_OR3_X2%3_r31 N_3_M7_g x_PM_OR3_X2%3_VSS 21.84
C_x_PM_OR3_X2%A1_c0 VSS A1 6.85526e-17
C_x_PM_OR3_X2%A1_c1 VSS x_PM_OR3_X2%A1_11 9.92086e-18
C_x_PM_OR3_X2%A1_c2 VSS N_A1_M0_g 7.53703e-17
C_x_PM_OR3_X2%A1_c3 VSS N_A1_M4_g 5.78093e-17
R_x_PM_OR3_X2%A1_r4 x_PM_OR3_X2%A1_18 x_PM_OR3_X2%A1_11 4.7687
R_x_PM_OR3_X2%A1_r5 x_PM_OR3_X2%A1_17 x_PM_OR3_X2%A1_11 4.7687
R_x_PM_OR3_X2%A1_r6 x_PM_OR3_X2%A1_11 x_PM_OR3_X2%A1_9 25.0012
R_x_PM_OR3_X2%A1_r7 A1 x_PM_OR3_X2%A1_9 0.210357
R_x_PM_OR3_X2%A1_r8 N_A1_M0_g x_PM_OR3_X2%A1_18 80.34
R_x_PM_OR3_X2%A1_r9 N_A1_M4_g x_PM_OR3_X2%A1_17 59.28
C_x_PM_OR3_X2%A2_c0 VSS A2 4.50716e-17
C_x_PM_OR3_X2%A2_c1 VSS x_PM_OR3_X2%A2_11 1.07434e-17
C_x_PM_OR3_X2%A2_c2 VSS N_A2_M1_g 6.86698e-17
C_x_PM_OR3_X2%A2_c3 VSS N_A2_M5_g 5.1379e-17
R_x_PM_OR3_X2%A2_r4 x_PM_OR3_X2%A2_11 x_PM_OR3_X2%A2_16 3.38
R_x_PM_OR3_X2%A2_r5 x_PM_OR3_X2%A2_11 x_PM_OR3_X2%A2_9 25.0012
R_x_PM_OR3_X2%A2_r6 A2 x_PM_OR3_X2%A2_9 0.156071
R_x_PM_OR3_X2%A2_r7 x_PM_OR3_X2%A2_16 x_PM_OR3_X2%A2_5 1.95
R_x_PM_OR3_X2%A2_r8 N_A2_M1_g x_PM_OR3_X2%A2_5 80.34
R_x_PM_OR3_X2%A2_r9 x_PM_OR3_X2%A2_16 x_PM_OR3_X2%A2_VSS 1.95
R_x_PM_OR3_X2%A2_r10 N_A2_M5_g x_PM_OR3_X2%A2_VSS 59.28
C_x_PM_OR3_X2%A3_c0 VSS x_PM_OR3_X2%A3_11 8.5453e-18
C_x_PM_OR3_X2%A3_c1 VSS x_PM_OR3_X2%A3_9 4.53477e-17
C_x_PM_OR3_X2%A3_c2 VSS N_A3_M2_g 3.69294e-17
C_x_PM_OR3_X2%A3_c3 VSS N_A3_M6_g 8.38994e-17
R_x_PM_OR3_X2%A3_r4 x_PM_OR3_X2%A3_16 x_PM_OR3_X2%A3_11 4.7687
R_x_PM_OR3_X2%A3_r5 x_PM_OR3_X2%A3_15 x_PM_OR3_X2%A3_11 4.7687
R_x_PM_OR3_X2%A3_r6 x_PM_OR3_X2%A3_11 x_PM_OR3_X2%A3_9 25.0012
R_x_PM_OR3_X2%A3_r7 A3 x_PM_OR3_X2%A3_9 0.226453
R_x_PM_OR3_X2%A3_r8 N_A3_M2_g x_PM_OR3_X2%A3_16 28.08
R_x_PM_OR3_X2%A3_r9 N_A3_M6_g x_PM_OR3_X2%A3_15 111.54
C_x_PM_OR3_X2%ZN_c0 VSS N_ZN_M7_d 1.0669e-16
R_x_PM_OR3_X2%ZN_r1 N_ZN_M3_d ZN 2.42929
R_x_PM_OR3_X2%ZN_r2 ZN N_ZN_M7_d 1.75071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR3_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR3_X4 VSS VDD A1 A2 A3 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I ZN:O
M_M4 8 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.260000U L=0.050000U
M_M5 9 N_A2_M1_g 8 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M6 N_VDD_M2_d N_A3_M2_g 9 VDD PMOS_VTL W=0.260000U L=0.050000U
M_M7 N_ZN_M3_d N_3_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_VSS_M4_d N_A1_M4_g N_3_M4_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_3_M5_d N_A2_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_VSS_M6_d N_A3_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_ZN_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.360000U L=0.050000U
C_x_PM_OR3_X4%VSS_c0 VSS x_PM_OR3_X4%VSS_20 3.40777e-17
C_x_PM_OR3_X4%VSS_c1 VSS x_PM_OR3_X4%VSS_19 3.96589e-17
C_x_PM_OR3_X4%VSS_c2 VSS N_VSS_M6_d 4.06924e-17
C_x_PM_OR3_X4%VSS_c3 VSS x_PM_OR3_X4%VSS_9 3.19574e-17
C_x_PM_OR3_X4%VSS_c4 VSS N_VSS_M4_d 4.18008e-17
R_x_PM_OR3_X4%VSS_r5 x_PM_OR3_X4%VSS_20 x_PM_OR3_X4%VSS_13 0.145286
R_x_PM_OR3_X4%VSS_r6 N_VSS_M6_d x_PM_OR3_X4%VSS_13 0.637857
R_x_PM_OR3_X4%VSS_r7 x_PM_OR3_X4%VSS_19 x_PM_OR3_X4%VSS_10 0.0731438
R_x_PM_OR3_X4%VSS_r8 VSS x_PM_OR3_X4%VSS_10 0.357647
R_x_PM_OR3_X4%VSS_r9 x_PM_OR3_X4%VSS_20 x_PM_OR3_X4%VSS_9 0.0731438
R_x_PM_OR3_X4%VSS_r10 VSS x_PM_OR3_X4%VSS_9 0.335294
R_x_PM_OR3_X4%VSS_r11 x_PM_OR3_X4%VSS_19 x_PM_OR3_X4%VSS_5 0.145286
R_x_PM_OR3_X4%VSS_r12 N_VSS_M4_d x_PM_OR3_X4%VSS_5 0.637857
C_x_PM_OR3_X4%VDD_c0 VSS x_PM_OR3_X4%VDD_12 2.94443e-17
C_x_PM_OR3_X4%VDD_c1 VSS N_VDD_M2_d 5.9193e-17
C_x_PM_OR3_X4%VDD_c2 VSS x_PM_OR3_X4%VDD_2 5.85983e-17
R_x_PM_OR3_X4%VDD_r3 x_PM_OR3_X4%VDD_12 x_PM_OR3_X4%VDD_6 0.145286
R_x_PM_OR3_X4%VDD_r4 N_VDD_M2_d x_PM_OR3_X4%VDD_6 1.75071
R_x_PM_OR3_X4%VDD_r5 x_PM_OR3_X4%VDD_12 x_PM_OR3_X4%VDD_2 0.0731438
R_x_PM_OR3_X4%VDD_r6 VDD x_PM_OR3_X4%VDD_2 0.698529
C_x_PM_OR3_X4%3_c0 VSS x_PM_OR3_X4%3_38 1.23212e-17
C_x_PM_OR3_X4%3_c1 VSS x_PM_OR3_X4%3_35 2.16e-18
C_x_PM_OR3_X4%3_c2 VSS x_PM_OR3_X4%3_33 2.23477e-18
C_x_PM_OR3_X4%3_c3 VSS x_PM_OR3_X4%3_32 3.96344e-17
C_x_PM_OR3_X4%3_c4 VSS x_PM_OR3_X4%3_28 5.56354e-17
C_x_PM_OR3_X4%3_c5 VSS N_3_M5_d 4.0411e-17
C_x_PM_OR3_X4%3_c6 VSS x_PM_OR3_X4%3_22 3.41327e-17
C_x_PM_OR3_X4%3_c7 VSS N_3_M0_s 2.95483e-17
C_x_PM_OR3_X4%3_c8 VSS x_PM_OR3_X4%3_18 7.57398e-18
C_x_PM_OR3_X4%3_c9 VSS x_PM_OR3_X4%3_17 4.17824e-17
C_x_PM_OR3_X4%3_c10 VSS N_3_M4_s 3.83261e-17
C_x_PM_OR3_X4%3_c11 VSS N_3_M3_g 8.77776e-17
C_x_PM_OR3_X4%3_c12 VSS N_3_M7_g 5.07157e-17
R_x_PM_OR3_X4%3_r13 x_PM_OR3_X4%3_38 x_PM_OR3_X4%3_36 3.9
R_x_PM_OR3_X4%3_r14 x_PM_OR3_X4%3_32 x_PM_OR3_X4%3_30 0.543196
R_x_PM_OR3_X4%3_r15 x_PM_OR3_X4%3_36 x_PM_OR3_X4%3_30 25.0012
R_x_PM_OR3_X4%3_r16 x_PM_OR3_X4%3_35 x_PM_OR3_X4%3_29 0.160909
R_x_PM_OR3_X4%3_r17 x_PM_OR3_X4%3_32 x_PM_OR3_X4%3_28 0.212317
R_x_PM_OR3_X4%3_r18 x_PM_OR3_X4%3_29 x_PM_OR3_X4%3_28 0.977143
R_x_PM_OR3_X4%3_r19 x_PM_OR3_X4%3_35 x_PM_OR3_X4%3_24 0.0418175
R_x_PM_OR3_X4%3_r20 N_3_M5_d x_PM_OR3_X4%3_24 0.637857
R_x_PM_OR3_X4%3_r21 x_PM_OR3_X4%3_33 x_PM_OR3_X4%3_23 0.0457628
R_x_PM_OR3_X4%3_r22 x_PM_OR3_X4%3_35 x_PM_OR3_X4%3_22 0.160909
R_x_PM_OR3_X4%3_r23 x_PM_OR3_X4%3_23 x_PM_OR3_X4%3_22 1.65571
R_x_PM_OR3_X4%3_r24 N_3_M0_s x_PM_OR3_X4%3_18 0.152
R_x_PM_OR3_X4%3_r25 x_PM_OR3_X4%3_17 x_PM_OR3_X4%3_18 0.192227
R_x_PM_OR3_X4%3_r26 x_PM_OR3_X4%3_33 x_PM_OR3_X4%3_16 0.156262
R_x_PM_OR3_X4%3_r27 x_PM_OR3_X4%3_17 x_PM_OR3_X4%3_16 1.81857
R_x_PM_OR3_X4%3_r28 x_PM_OR3_X4%3_33 x_PM_OR3_X4%3_12 0.156262
R_x_PM_OR3_X4%3_r29 N_3_M4_s x_PM_OR3_X4%3_12 0.595333
R_x_PM_OR3_X4%3_r30 x_PM_OR3_X4%3_38 x_PM_OR3_X4%3_5 1.95
R_x_PM_OR3_X4%3_r31 N_3_M3_g x_PM_OR3_X4%3_5 72.54
R_x_PM_OR3_X4%3_r32 x_PM_OR3_X4%3_38 x_PM_OR3_X4%3_VSS 1.95
R_x_PM_OR3_X4%3_r33 N_3_M7_g x_PM_OR3_X4%3_VSS 35.88
C_x_PM_OR3_X4%A1_c0 VSS x_PM_OR3_X4%A1_19 4.29685e-17
C_x_PM_OR3_X4%A1_c1 VSS x_PM_OR3_X4%A1_15 5.03847e-17
C_x_PM_OR3_X4%A1_c2 VSS x_PM_OR3_X4%A1_14 9.63445e-18
C_x_PM_OR3_X4%A1_c3 VSS x_PM_OR3_X4%A1_12 1.18828e-17
C_x_PM_OR3_X4%A1_c4 VSS x_PM_OR3_X4%A1_10 2.80372e-17
C_x_PM_OR3_X4%A1_c5 VSS N_A1_M0_g 3.52419e-17
C_x_PM_OR3_X4%A1_c6 VSS N_A1_M4_g 5.9616e-17
R_x_PM_OR3_X4%A1_r7 x_PM_OR3_X4%A1_19 A1 0.366429
R_x_PM_OR3_X4%A1_r8 x_PM_OR3_X4%A1_19 x_PM_OR3_X4%A1_15 0.095
R_x_PM_OR3_X4%A1_r9 x_PM_OR3_X4%A1_15 x_PM_OR3_X4%A1_14 1.43857
R_x_PM_OR3_X4%A1_r10 x_PM_OR3_X4%A1_12 x_PM_OR3_X4%A1_22 3.38
R_x_PM_OR3_X4%A1_r11 x_PM_OR3_X4%A1_12 x_PM_OR3_X4%A1_10 25.0012
R_x_PM_OR3_X4%A1_r12 x_PM_OR3_X4%A1_14 x_PM_OR3_X4%A1_9 0.192227
R_x_PM_OR3_X4%A1_r13 x_PM_OR3_X4%A1_10 x_PM_OR3_X4%A1_9 0.152
R_x_PM_OR3_X4%A1_r14 x_PM_OR3_X4%A1_22 x_PM_OR3_X4%A1_5 1.95
R_x_PM_OR3_X4%A1_r15 N_A1_M0_g x_PM_OR3_X4%A1_5 33.54
R_x_PM_OR3_X4%A1_r16 x_PM_OR3_X4%A1_22 x_PM_OR3_X4%A1_VSS 1.95
R_x_PM_OR3_X4%A1_r17 N_A1_M4_g x_PM_OR3_X4%A1_VSS 62.4
C_x_PM_OR3_X4%A2_c0 VSS A2 4.11543e-17
C_x_PM_OR3_X4%A2_c1 VSS x_PM_OR3_X4%A2_12 9.05244e-18
C_x_PM_OR3_X4%A2_c2 VSS x_PM_OR3_X4%A2_10 6.36766e-17
C_x_PM_OR3_X4%A2_c3 VSS N_A2_M1_g 3.13441e-17
C_x_PM_OR3_X4%A2_c4 VSS N_A2_M5_g 5.61914e-17
R_x_PM_OR3_X4%A2_r5 x_PM_OR3_X4%A2_16 A2 0.286226
R_x_PM_OR3_X4%A2_r6 x_PM_OR3_X4%A2_20 x_PM_OR3_X4%A2_12 4.7687
R_x_PM_OR3_X4%A2_r7 x_PM_OR3_X4%A2_19 x_PM_OR3_X4%A2_12 4.7687
R_x_PM_OR3_X4%A2_r8 x_PM_OR3_X4%A2_12 x_PM_OR3_X4%A2_10 25.0012
R_x_PM_OR3_X4%A2_r9 x_PM_OR3_X4%A2_10 x_PM_OR3_X4%A2_16 1.615
R_x_PM_OR3_X4%A2_r10 N_A2_M1_g x_PM_OR3_X4%A2_20 28.08
R_x_PM_OR3_X4%A2_r11 N_A2_M5_g x_PM_OR3_X4%A2_19 67.86
C_x_PM_OR3_X4%A3_c0 VSS x_PM_OR3_X4%A3_11 8.81042e-18
C_x_PM_OR3_X4%A3_c1 VSS x_PM_OR3_X4%A3_9 6.15148e-17
C_x_PM_OR3_X4%A3_c2 VSS N_A3_M2_g 3.46712e-17
C_x_PM_OR3_X4%A3_c3 VSS N_A3_M6_g 5.64678e-17
R_x_PM_OR3_X4%A3_r4 x_PM_OR3_X4%A3_16 x_PM_OR3_X4%A3_11 4.7687
R_x_PM_OR3_X4%A3_r5 x_PM_OR3_X4%A3_15 x_PM_OR3_X4%A3_11 4.7687
R_x_PM_OR3_X4%A3_r6 x_PM_OR3_X4%A3_11 x_PM_OR3_X4%A3_9 25.0012
R_x_PM_OR3_X4%A3_r7 A3 x_PM_OR3_X4%A3_9 0.23477
R_x_PM_OR3_X4%A3_r8 N_A3_M2_g x_PM_OR3_X4%A3_16 28.08
R_x_PM_OR3_X4%A3_r9 N_A3_M6_g x_PM_OR3_X4%A3_15 67.86
C_x_PM_OR3_X4%ZN_c0 VSS N_ZN_M7_d 1.16005e-16
R_x_PM_OR3_X4%ZN_r1 N_ZN_M3_d ZN 1.72357
R_x_PM_OR3_X4%ZN_r2 ZN N_ZN_M7_d 1.18071
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X1.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X1 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 9 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.325000U L=0.050000U
M_M6 10 N_A2_M1_g 9 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M7 11 N_A3_M2_g 10 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g 11 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M9 N_ZN_M4_d N_3_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_3_M5_d N_A1_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M6_d N_A2_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_3_M7_d N_A3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g N_3_M7_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_ZN_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_OR4_X1%VSS_c0 VSS x_PM_OR4_X1%VSS_25 4.28203e-17
C_x_PM_OR4_X1%VSS_c1 VSS x_PM_OR4_X1%VSS_24 2.92048e-18
C_x_PM_OR4_X1%VSS_c2 VSS N_VSS_M8_d 4.11767e-17
C_x_PM_OR4_X1%VSS_c3 VSS x_PM_OR4_X1%VSS_14 3.19852e-17
C_x_PM_OR4_X1%VSS_c4 VSS N_VSS_M6_d 3.96415e-17
C_x_PM_OR4_X1%VSS_c5 VSS x_PM_OR4_X1%VSS_9 1.30299e-17
C_x_PM_OR4_X1%VSS_c6 VSS x_PM_OR4_X1%VSS_8 3.1411e-17
C_x_PM_OR4_X1%VSS_c7 VSS N_VSS_M5_s 3.37407e-17
R_x_PM_OR4_X1%VSS_r8 x_PM_OR4_X1%VSS_25 x_PM_OR4_X1%VSS_18 0.145286
R_x_PM_OR4_X1%VSS_r9 N_VSS_M8_d x_PM_OR4_X1%VSS_18 0.637857
R_x_PM_OR4_X1%VSS_r10 x_PM_OR4_X1%VSS_24 x_PM_OR4_X1%VSS_15 0.0731438
R_x_PM_OR4_X1%VSS_r11 VSS x_PM_OR4_X1%VSS_15 0.134118
R_x_PM_OR4_X1%VSS_r12 x_PM_OR4_X1%VSS_25 x_PM_OR4_X1%VSS_14 0.0731438
R_x_PM_OR4_X1%VSS_r13 VSS x_PM_OR4_X1%VSS_14 0.558824
R_x_PM_OR4_X1%VSS_r14 x_PM_OR4_X1%VSS_24 x_PM_OR4_X1%VSS_10 0.145286
R_x_PM_OR4_X1%VSS_r15 N_VSS_M6_d x_PM_OR4_X1%VSS_10 0.637857
R_x_PM_OR4_X1%VSS_r16 x_PM_OR4_X1%VSS_24 x_PM_OR4_X1%VSS_8 0.0731438
R_x_PM_OR4_X1%VSS_r17 x_PM_OR4_X1%VSS_9 x_PM_OR4_X1%VSS_8 0.681765
R_x_PM_OR4_X1%VSS_r18 x_PM_OR4_X1%VSS_9 x_PM_OR4_X1%VSS_4 0.264221
R_x_PM_OR4_X1%VSS_r19 N_VSS_M5_s x_PM_OR4_X1%VSS_4 0.637857
C_x_PM_OR4_X1%VDD_c0 VSS x_PM_OR4_X1%VDD_12 2.8481e-17
C_x_PM_OR4_X1%VDD_c1 VSS N_VDD_M3_d 3.45617e-17
C_x_PM_OR4_X1%VDD_c2 VSS x_PM_OR4_X1%VDD_2 8.33401e-17
R_x_PM_OR4_X1%VDD_r3 x_PM_OR4_X1%VDD_12 x_PM_OR4_X1%VDD_6 0.145286
R_x_PM_OR4_X1%VDD_r4 N_VDD_M3_d x_PM_OR4_X1%VDD_6 1.26214
R_x_PM_OR4_X1%VDD_r5 x_PM_OR4_X1%VDD_12 x_PM_OR4_X1%VDD_2 0.0731438
R_x_PM_OR4_X1%VDD_r6 VDD x_PM_OR4_X1%VDD_2 0.916471
C_x_PM_OR4_X1%3_c0 VSS x_PM_OR4_X1%3_39 1.49406e-17
C_x_PM_OR4_X1%3_c1 VSS x_PM_OR4_X1%3_34 5.6894e-17
C_x_PM_OR4_X1%3_c2 VSS x_PM_OR4_X1%3_31 5.2813e-18
C_x_PM_OR4_X1%3_c3 VSS N_3_M7_d 4.03962e-17
C_x_PM_OR4_X1%3_c4 VSS x_PM_OR4_X1%3_24 3.58225e-17
C_x_PM_OR4_X1%3_c5 VSS N_3_M5_d 4.19117e-17
C_x_PM_OR4_X1%3_c6 VSS x_PM_OR4_X1%3_19 1.67736e-17
C_x_PM_OR4_X1%3_c7 VSS x_PM_OR4_X1%3_18 1.76888e-17
C_x_PM_OR4_X1%3_c8 VSS N_3_M0_s 3.59996e-17
C_x_PM_OR4_X1%3_c9 VSS x_PM_OR4_X1%3_14 4.32113e-18
C_x_PM_OR4_X1%3_c10 VSS x_PM_OR4_X1%3_13 5.75461e-17
C_x_PM_OR4_X1%3_c11 VSS N_3_M4_g 8.71753e-17
C_x_PM_OR4_X1%3_c12 VSS N_3_M9_g 2.80682e-17
R_x_PM_OR4_X1%3_r13 x_PM_OR4_X1%3_39 x_PM_OR4_X1%3_37 5.46
R_x_PM_OR4_X1%3_r14 x_PM_OR4_X1%3_37 x_PM_OR4_X1%3_34 25.0012
R_x_PM_OR4_X1%3_r15 x_PM_OR4_X1%3_34 x_PM_OR4_X1%3_32 1.28929
R_x_PM_OR4_X1%3_r16 x_PM_OR4_X1%3_32 x_PM_OR4_X1%3_26 0.095
R_x_PM_OR4_X1%3_r17 N_3_M7_d x_PM_OR4_X1%3_26 0.637857
R_x_PM_OR4_X1%3_r18 x_PM_OR4_X1%3_31 x_PM_OR4_X1%3_25 0.160909
R_x_PM_OR4_X1%3_r19 x_PM_OR4_X1%3_32 x_PM_OR4_X1%3_24 0.19
R_x_PM_OR4_X1%3_r20 x_PM_OR4_X1%3_25 x_PM_OR4_X1%3_24 1.68286
R_x_PM_OR4_X1%3_r21 x_PM_OR4_X1%3_31 x_PM_OR4_X1%3_20 0.0418175
R_x_PM_OR4_X1%3_r22 N_3_M5_d x_PM_OR4_X1%3_20 0.637857
R_x_PM_OR4_X1%3_r23 x_PM_OR4_X1%3_31 x_PM_OR4_X1%3_18 0.160909
R_x_PM_OR4_X1%3_r24 x_PM_OR4_X1%3_19 x_PM_OR4_X1%3_18 0.76
R_x_PM_OR4_X1%3_r25 N_3_M0_s x_PM_OR4_X1%3_14 0.64
R_x_PM_OR4_X1%3_r26 x_PM_OR4_X1%3_13 x_PM_OR4_X1%3_14 0.217071
R_x_PM_OR4_X1%3_r27 x_PM_OR4_X1%3_19 x_PM_OR4_X1%3_12 0.212317
R_x_PM_OR4_X1%3_r28 x_PM_OR4_X1%3_13 x_PM_OR4_X1%3_12 2.98571
R_x_PM_OR4_X1%3_r29 x_PM_OR4_X1%3_39 x_PM_OR4_X1%3_5 1.95
R_x_PM_OR4_X1%3_r30 N_3_M4_g x_PM_OR4_X1%3_5 100.23
R_x_PM_OR4_X1%3_r31 x_PM_OR4_X1%3_39 x_PM_OR4_X1%3_VSS 1.95
R_x_PM_OR4_X1%3_r32 N_3_M9_g x_PM_OR4_X1%3_VSS 19.5
C_x_PM_OR4_X1%A1_c0 VSS A1 4.47551e-17
C_x_PM_OR4_X1%A1_c1 VSS x_PM_OR4_X1%A1_11 9.86804e-18
C_x_PM_OR4_X1%A1_c2 VSS N_A1_M0_g 7.77616e-17
C_x_PM_OR4_X1%A1_c3 VSS N_A1_M5_g 5.63914e-17
R_x_PM_OR4_X1%A1_r4 x_PM_OR4_X1%A1_18 x_PM_OR4_X1%A1_11 4.7687
R_x_PM_OR4_X1%A1_r5 x_PM_OR4_X1%A1_17 x_PM_OR4_X1%A1_11 4.7687
R_x_PM_OR4_X1%A1_r6 x_PM_OR4_X1%A1_11 x_PM_OR4_X1%A1_9 25.0012
R_x_PM_OR4_X1%A1_r7 A1 x_PM_OR4_X1%A1_9 0.210357
R_x_PM_OR4_X1%A1_r8 N_A1_M0_g x_PM_OR4_X1%A1_18 75.27
R_x_PM_OR4_X1%A1_r9 N_A1_M5_g x_PM_OR4_X1%A1_17 59.28
C_x_PM_OR4_X1%A2_c0 VSS A2 1.73404e-17
C_x_PM_OR4_X1%A2_c1 VSS x_PM_OR4_X1%A2_11 1.0066e-17
C_x_PM_OR4_X1%A2_c2 VSS N_A2_M1_g 5.52911e-17
C_x_PM_OR4_X1%A2_c3 VSS N_A2_M6_g 6.448e-17
R_x_PM_OR4_X1%A2_r4 x_PM_OR4_X1%A2_11 x_PM_OR4_X1%A2_16 3.38
R_x_PM_OR4_X1%A2_r5 x_PM_OR4_X1%A2_11 x_PM_OR4_X1%A2_9 25.0012
R_x_PM_OR4_X1%A2_r6 A2 x_PM_OR4_X1%A2_9 0.156071
R_x_PM_OR4_X1%A2_r7 x_PM_OR4_X1%A2_16 x_PM_OR4_X1%A2_5 1.95
R_x_PM_OR4_X1%A2_r8 N_A2_M1_g x_PM_OR4_X1%A2_5 53.43
R_x_PM_OR4_X1%A2_r9 x_PM_OR4_X1%A2_16 x_PM_OR4_X1%A2_VSS 1.95
R_x_PM_OR4_X1%A2_r10 N_A2_M6_g x_PM_OR4_X1%A2_VSS 81.12
C_x_PM_OR4_X1%A3_c0 VSS A3 4.14162e-17
C_x_PM_OR4_X1%A3_c1 VSS x_PM_OR4_X1%A3_11 1.02238e-17
C_x_PM_OR4_X1%A3_c2 VSS N_A3_M2_g 6.89166e-17
C_x_PM_OR4_X1%A3_c3 VSS N_A3_M7_g 5.08813e-17
R_x_PM_OR4_X1%A3_r4 x_PM_OR4_X1%A3_11 x_PM_OR4_X1%A3_16 3.38
R_x_PM_OR4_X1%A3_r5 x_PM_OR4_X1%A3_11 x_PM_OR4_X1%A3_9 25.0012
R_x_PM_OR4_X1%A3_r6 A3 x_PM_OR4_X1%A3_9 0.156071
R_x_PM_OR4_X1%A3_r7 x_PM_OR4_X1%A3_16 x_PM_OR4_X1%A3_5 1.95
R_x_PM_OR4_X1%A3_r8 N_A3_M2_g x_PM_OR4_X1%A3_5 75.27
R_x_PM_OR4_X1%A3_r9 x_PM_OR4_X1%A3_16 x_PM_OR4_X1%A3_VSS 1.95
R_x_PM_OR4_X1%A3_r10 N_A3_M7_g x_PM_OR4_X1%A3_VSS 59.28
C_x_PM_OR4_X1%A4_c0 VSS A4 4.73309e-17
C_x_PM_OR4_X1%A4_c1 VSS x_PM_OR4_X1%A4_11 1.0747e-17
C_x_PM_OR4_X1%A4_c2 VSS N_A4_M3_g 7.12731e-17
C_x_PM_OR4_X1%A4_c3 VSS N_A4_M8_g 5.28464e-17
R_x_PM_OR4_X1%A4_r4 x_PM_OR4_X1%A4_11 x_PM_OR4_X1%A4_16 3.38
R_x_PM_OR4_X1%A4_r5 x_PM_OR4_X1%A4_11 x_PM_OR4_X1%A4_9 25.0012
R_x_PM_OR4_X1%A4_r6 A4 x_PM_OR4_X1%A4_9 0.156071
R_x_PM_OR4_X1%A4_r7 x_PM_OR4_X1%A4_16 x_PM_OR4_X1%A4_5 1.95
R_x_PM_OR4_X1%A4_r8 N_A4_M3_g x_PM_OR4_X1%A4_5 74.49
R_x_PM_OR4_X1%A4_r9 x_PM_OR4_X1%A4_16 x_PM_OR4_X1%A4_VSS 1.95
R_x_PM_OR4_X1%A4_r10 N_A4_M8_g x_PM_OR4_X1%A4_VSS 60.06
C_x_PM_OR4_X1%ZN_c0 VSS N_ZN_M9_d 3.9707e-17
C_x_PM_OR4_X1%ZN_c1 VSS x_PM_OR4_X1%ZN_7 6.3528e-17
C_x_PM_OR4_X1%ZN_c2 VSS N_ZN_M4_d 2.27703e-17
R_x_PM_OR4_X1%ZN_r3 ZN N_ZN_M4_d 0.01
R_x_PM_OR4_X1%ZN_r4 x_PM_OR4_X1%ZN_7 N_ZN_M4_d 0.297071
R_x_PM_OR4_X1%ZN_r5 x_PM_OR4_X1%ZN_3 N_ZN_M9_d 0.30478
R_x_PM_OR4_X1%ZN_r6 x_PM_OR4_X1%ZN_7 x_PM_OR4_X1%ZN_3 3.77286
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X2.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X2 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 9 N_A1_M0_g N_3_M0_s VDD PMOS_VTL W=0.325000U L=0.050000U
M_M6 10 N_A2_M1_g 9 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M7 11 N_A3_M2_g 10 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g 11 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M9 N_ZN_M4_d N_3_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_3_M5_d N_A1_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M6_d N_A2_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_3_M7_d N_A3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g N_3_M7_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_ZN_M9_d N_3_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.160000U L=0.050000U
C_x_PM_OR4_X2%VSS_c0 VSS x_PM_OR4_X2%VSS_25 3.09849e-17
C_x_PM_OR4_X2%VSS_c1 VSS x_PM_OR4_X2%VSS_24 2.92048e-18
C_x_PM_OR4_X2%VSS_c2 VSS N_VSS_M8_d 3.12663e-17
C_x_PM_OR4_X2%VSS_c3 VSS x_PM_OR4_X2%VSS_14 3.18026e-17
C_x_PM_OR4_X2%VSS_c4 VSS N_VSS_M6_d 3.20111e-17
C_x_PM_OR4_X2%VSS_c5 VSS x_PM_OR4_X2%VSS_9 1.25763e-17
C_x_PM_OR4_X2%VSS_c6 VSS x_PM_OR4_X2%VSS_8 3.12295e-17
C_x_PM_OR4_X2%VSS_c7 VSS N_VSS_M5_s 2.60989e-17
R_x_PM_OR4_X2%VSS_r8 x_PM_OR4_X2%VSS_25 x_PM_OR4_X2%VSS_18 0.145286
R_x_PM_OR4_X2%VSS_r9 N_VSS_M8_d x_PM_OR4_X2%VSS_18 0.637857
R_x_PM_OR4_X2%VSS_r10 x_PM_OR4_X2%VSS_24 x_PM_OR4_X2%VSS_15 0.0731438
R_x_PM_OR4_X2%VSS_r11 VSS x_PM_OR4_X2%VSS_15 0.145294
R_x_PM_OR4_X2%VSS_r12 x_PM_OR4_X2%VSS_25 x_PM_OR4_X2%VSS_14 0.0731438
R_x_PM_OR4_X2%VSS_r13 VSS x_PM_OR4_X2%VSS_14 0.547647
R_x_PM_OR4_X2%VSS_r14 x_PM_OR4_X2%VSS_24 x_PM_OR4_X2%VSS_10 0.145286
R_x_PM_OR4_X2%VSS_r15 N_VSS_M6_d x_PM_OR4_X2%VSS_10 0.637857
R_x_PM_OR4_X2%VSS_r16 x_PM_OR4_X2%VSS_24 x_PM_OR4_X2%VSS_8 0.0731438
R_x_PM_OR4_X2%VSS_r17 x_PM_OR4_X2%VSS_9 x_PM_OR4_X2%VSS_8 0.681765
R_x_PM_OR4_X2%VSS_r18 x_PM_OR4_X2%VSS_9 x_PM_OR4_X2%VSS_4 0.264221
R_x_PM_OR4_X2%VSS_r19 N_VSS_M5_s x_PM_OR4_X2%VSS_4 0.637857
C_x_PM_OR4_X2%VDD_c0 VSS x_PM_OR4_X2%VDD_12 2.87042e-17
C_x_PM_OR4_X2%VDD_c1 VSS N_VDD_M3_d 3.86698e-17
C_x_PM_OR4_X2%VDD_c2 VSS x_PM_OR4_X2%VDD_2 8.27814e-17
R_x_PM_OR4_X2%VDD_r3 x_PM_OR4_X2%VDD_12 x_PM_OR4_X2%VDD_6 0.145286
R_x_PM_OR4_X2%VDD_r4 N_VDD_M3_d x_PM_OR4_X2%VDD_6 0.529286
R_x_PM_OR4_X2%VDD_r5 x_PM_OR4_X2%VDD_12 x_PM_OR4_X2%VDD_2 0.0731438
R_x_PM_OR4_X2%VDD_r6 VDD x_PM_OR4_X2%VDD_2 0.910882
C_x_PM_OR4_X2%3_c0 VSS x_PM_OR4_X2%3_39 1.50137e-17
C_x_PM_OR4_X2%3_c1 VSS x_PM_OR4_X2%3_34 5.66088e-17
C_x_PM_OR4_X2%3_c2 VSS x_PM_OR4_X2%3_31 7.64543e-18
C_x_PM_OR4_X2%3_c3 VSS N_3_M7_d 4.36971e-17
C_x_PM_OR4_X2%3_c4 VSS x_PM_OR4_X2%3_24 3.90305e-17
C_x_PM_OR4_X2%3_c5 VSS N_3_M5_d 4.58822e-17
C_x_PM_OR4_X2%3_c6 VSS x_PM_OR4_X2%3_19 1.0509e-17
C_x_PM_OR4_X2%3_c7 VSS x_PM_OR4_X2%3_18 1.72682e-17
C_x_PM_OR4_X2%3_c8 VSS N_3_M0_s 3.58537e-17
C_x_PM_OR4_X2%3_c9 VSS x_PM_OR4_X2%3_14 4.30213e-18
C_x_PM_OR4_X2%3_c10 VSS x_PM_OR4_X2%3_13 5.51576e-17
C_x_PM_OR4_X2%3_c11 VSS N_3_M4_g 9.51623e-17
C_x_PM_OR4_X2%3_c12 VSS N_3_M9_g 3.01638e-17
R_x_PM_OR4_X2%3_r13 x_PM_OR4_X2%3_39 x_PM_OR4_X2%3_37 5.46
R_x_PM_OR4_X2%3_r14 x_PM_OR4_X2%3_37 x_PM_OR4_X2%3_34 25.0012
R_x_PM_OR4_X2%3_r15 x_PM_OR4_X2%3_34 x_PM_OR4_X2%3_32 1.28929
R_x_PM_OR4_X2%3_r16 x_PM_OR4_X2%3_32 x_PM_OR4_X2%3_26 0.095
R_x_PM_OR4_X2%3_r17 N_3_M7_d x_PM_OR4_X2%3_26 0.855
R_x_PM_OR4_X2%3_r18 x_PM_OR4_X2%3_31 x_PM_OR4_X2%3_25 0.160909
R_x_PM_OR4_X2%3_r19 x_PM_OR4_X2%3_32 x_PM_OR4_X2%3_24 0.19
R_x_PM_OR4_X2%3_r20 x_PM_OR4_X2%3_25 x_PM_OR4_X2%3_24 1.68286
R_x_PM_OR4_X2%3_r21 x_PM_OR4_X2%3_31 x_PM_OR4_X2%3_20 0.0418175
R_x_PM_OR4_X2%3_r22 N_3_M5_d x_PM_OR4_X2%3_20 0.855
R_x_PM_OR4_X2%3_r23 x_PM_OR4_X2%3_31 x_PM_OR4_X2%3_18 0.160909
R_x_PM_OR4_X2%3_r24 x_PM_OR4_X2%3_19 x_PM_OR4_X2%3_18 0.76
R_x_PM_OR4_X2%3_r25 N_3_M0_s x_PM_OR4_X2%3_14 0.64
R_x_PM_OR4_X2%3_r26 x_PM_OR4_X2%3_13 x_PM_OR4_X2%3_14 0.217071
R_x_PM_OR4_X2%3_r27 x_PM_OR4_X2%3_19 x_PM_OR4_X2%3_12 0.212317
R_x_PM_OR4_X2%3_r28 x_PM_OR4_X2%3_13 x_PM_OR4_X2%3_12 2.76857
R_x_PM_OR4_X2%3_r29 x_PM_OR4_X2%3_39 x_PM_OR4_X2%3_5 1.95
R_x_PM_OR4_X2%3_r30 N_3_M4_g x_PM_OR4_X2%3_5 104.52
R_x_PM_OR4_X2%3_r31 x_PM_OR4_X2%3_39 x_PM_OR4_X2%3_VSS 1.95
R_x_PM_OR4_X2%3_r32 N_3_M9_g x_PM_OR4_X2%3_VSS 20.28
C_x_PM_OR4_X2%A1_c0 VSS A1 7.09523e-17
C_x_PM_OR4_X2%A1_c1 VSS x_PM_OR4_X2%A1_11 9.93232e-18
C_x_PM_OR4_X2%A1_c2 VSS N_A1_M0_g 7.76163e-17
C_x_PM_OR4_X2%A1_c3 VSS N_A1_M5_g 5.54373e-17
R_x_PM_OR4_X2%A1_r4 x_PM_OR4_X2%A1_18 x_PM_OR4_X2%A1_11 4.7687
R_x_PM_OR4_X2%A1_r5 x_PM_OR4_X2%A1_17 x_PM_OR4_X2%A1_11 4.7687
R_x_PM_OR4_X2%A1_r6 x_PM_OR4_X2%A1_11 x_PM_OR4_X2%A1_9 25.0012
R_x_PM_OR4_X2%A1_r7 A1 x_PM_OR4_X2%A1_9 0.223929
R_x_PM_OR4_X2%A1_r8 N_A1_M0_g x_PM_OR4_X2%A1_18 75.27
R_x_PM_OR4_X2%A1_r9 N_A1_M5_g x_PM_OR4_X2%A1_17 59.28
C_x_PM_OR4_X2%A2_c0 VSS A2 6.65609e-17
C_x_PM_OR4_X2%A2_c1 VSS x_PM_OR4_X2%A2_11 1.12437e-17
C_x_PM_OR4_X2%A2_c2 VSS N_A2_M1_g 6.83316e-17
C_x_PM_OR4_X2%A2_c3 VSS N_A2_M6_g 5.1084e-17
R_x_PM_OR4_X2%A2_r4 x_PM_OR4_X2%A2_11 x_PM_OR4_X2%A2_16 3.9
R_x_PM_OR4_X2%A2_r5 x_PM_OR4_X2%A2_11 x_PM_OR4_X2%A2_9 25.0012
R_x_PM_OR4_X2%A2_r6 A2 x_PM_OR4_X2%A2_9 0.156071
R_x_PM_OR4_X2%A2_r7 x_PM_OR4_X2%A2_16 x_PM_OR4_X2%A2_5 1.95
R_x_PM_OR4_X2%A2_r8 N_A2_M1_g x_PM_OR4_X2%A2_5 75.27
R_x_PM_OR4_X2%A2_r9 x_PM_OR4_X2%A2_16 x_PM_OR4_X2%A2_VSS 1.95
R_x_PM_OR4_X2%A2_r10 N_A2_M6_g x_PM_OR4_X2%A2_VSS 59.28
C_x_PM_OR4_X2%A3_c0 VSS A3 6.65126e-17
C_x_PM_OR4_X2%A3_c1 VSS x_PM_OR4_X2%A3_11 1.13495e-17
C_x_PM_OR4_X2%A3_c2 VSS N_A3_M2_g 6.82754e-17
C_x_PM_OR4_X2%A3_c3 VSS N_A3_M7_g 5.11699e-17
R_x_PM_OR4_X2%A3_r4 x_PM_OR4_X2%A3_11 x_PM_OR4_X2%A3_16 3.9
R_x_PM_OR4_X2%A3_r5 x_PM_OR4_X2%A3_11 x_PM_OR4_X2%A3_9 25.0012
R_x_PM_OR4_X2%A3_r6 A3 x_PM_OR4_X2%A3_9 0.156071
R_x_PM_OR4_X2%A3_r7 x_PM_OR4_X2%A3_16 x_PM_OR4_X2%A3_5 1.95
R_x_PM_OR4_X2%A3_r8 N_A3_M2_g x_PM_OR4_X2%A3_5 75.27
R_x_PM_OR4_X2%A3_r9 x_PM_OR4_X2%A3_16 x_PM_OR4_X2%A3_VSS 1.95
R_x_PM_OR4_X2%A3_r10 N_A3_M7_g x_PM_OR4_X2%A3_VSS 59.28
C_x_PM_OR4_X2%A4_c0 VSS A4 5.3212e-17
C_x_PM_OR4_X2%A4_c1 VSS x_PM_OR4_X2%A4_11 1.147e-17
C_x_PM_OR4_X2%A4_c2 VSS N_A4_M3_g 6.91639e-17
C_x_PM_OR4_X2%A4_c3 VSS N_A4_M8_g 5.25901e-17
R_x_PM_OR4_X2%A4_r4 x_PM_OR4_X2%A4_11 x_PM_OR4_X2%A4_16 3.9
R_x_PM_OR4_X2%A4_r5 x_PM_OR4_X2%A4_11 x_PM_OR4_X2%A4_9 25.0012
R_x_PM_OR4_X2%A4_r6 A4 x_PM_OR4_X2%A4_9 0.156071
R_x_PM_OR4_X2%A4_r7 x_PM_OR4_X2%A4_16 x_PM_OR4_X2%A4_5 1.95
R_x_PM_OR4_X2%A4_r8 N_A4_M3_g x_PM_OR4_X2%A4_5 75.27
R_x_PM_OR4_X2%A4_r9 x_PM_OR4_X2%A4_16 x_PM_OR4_X2%A4_VSS 1.95
R_x_PM_OR4_X2%A4_r10 N_A4_M8_g x_PM_OR4_X2%A4_VSS 59.28
C_x_PM_OR4_X2%ZN_c0 VSS N_ZN_M9_d 4.27646e-17
C_x_PM_OR4_X2%ZN_c1 VSS ZN 5.15232e-17
C_x_PM_OR4_X2%ZN_c2 VSS x_PM_OR4_X2%ZN_3 6.09228e-18
R_x_PM_OR4_X2%ZN_r3 N_ZN_M9_d x_PM_OR4_X2%ZN_13 1.47929
R_x_PM_OR4_X2%ZN_r4 N_ZN_M4_d ZN 1.65722
R_x_PM_OR4_X2%ZN_r5 x_PM_OR4_X2%ZN_13 x_PM_OR4_X2%ZN_3 0.20978
R_x_PM_OR4_X2%ZN_r6 ZN x_PM_OR4_X2%ZN_3 0.105556
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   OR4_X4.                                                          *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT OR4_X4 VSS VDD A1 A2 A3 A4 ZN
*.PININFO VSS:B VDD:B A1:I A2:I A3:I A4:I ZN:O
M_M5 9 N_A1_M0_g N_4_M0_s VDD PMOS_VTL W=0.325000U L=0.050000U
M_M6 10 N_A2_M1_g 9 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M7 11 N_A3_M2_g 10 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M8 N_VDD_M3_d N_A4_M3_g 11 VDD PMOS_VTL W=0.325000U L=0.050000U
M_M9 N_ZN_M4_d N_4_M4_g N_VDD_M3_d VDD PMOS_VTL W=0.540000U L=0.050000U
M_M0 N_4_M5_d N_A1_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M6_d N_A2_M6_g N_4_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_4_M7_d N_A3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 N_VSS_M8_d N_A4_M8_g N_4_M7_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_ZN_M9_d N_4_M9_g N_VSS_M8_d VSS NMOS_VTL W=0.320000U L=0.050000U
C_x_PM_OR4_X4%VSS_c0 VSS x_PM_OR4_X4%VSS_25 3.78836e-17
C_x_PM_OR4_X4%VSS_c1 VSS x_PM_OR4_X4%VSS_24 5.6044e-18
C_x_PM_OR4_X4%VSS_c2 VSS N_VSS_M8_d 3.03771e-17
C_x_PM_OR4_X4%VSS_c3 VSS x_PM_OR4_X4%VSS_14 2.85274e-17
C_x_PM_OR4_X4%VSS_c4 VSS N_VSS_M6_d 4.92714e-17
C_x_PM_OR4_X4%VSS_c5 VSS x_PM_OR4_X4%VSS_9 1.22561e-17
C_x_PM_OR4_X4%VSS_c6 VSS x_PM_OR4_X4%VSS_8 2.83527e-17
C_x_PM_OR4_X4%VSS_c7 VSS N_VSS_M5_s 2.30539e-17
R_x_PM_OR4_X4%VSS_r8 x_PM_OR4_X4%VSS_25 x_PM_OR4_X4%VSS_18 0.145286
R_x_PM_OR4_X4%VSS_r9 N_VSS_M8_d x_PM_OR4_X4%VSS_18 0.637857
R_x_PM_OR4_X4%VSS_r10 x_PM_OR4_X4%VSS_24 x_PM_OR4_X4%VSS_15 0.132285
R_x_PM_OR4_X4%VSS_r11 VSS x_PM_OR4_X4%VSS_15 0.0670588
R_x_PM_OR4_X4%VSS_r12 x_PM_OR4_X4%VSS_25 x_PM_OR4_X4%VSS_14 0.0731438
R_x_PM_OR4_X4%VSS_r13 VSS x_PM_OR4_X4%VSS_14 0.547647
R_x_PM_OR4_X4%VSS_r14 x_PM_OR4_X4%VSS_24 x_PM_OR4_X4%VSS_10 0.0680382
R_x_PM_OR4_X4%VSS_r15 N_VSS_M6_d x_PM_OR4_X4%VSS_10 0.330741
R_x_PM_OR4_X4%VSS_r16 x_PM_OR4_X4%VSS_24 x_PM_OR4_X4%VSS_8 0.132285
R_x_PM_OR4_X4%VSS_r17 x_PM_OR4_X4%VSS_9 x_PM_OR4_X4%VSS_8 0.614706
R_x_PM_OR4_X4%VSS_r18 x_PM_OR4_X4%VSS_9 x_PM_OR4_X4%VSS_4 0.264221
R_x_PM_OR4_X4%VSS_r19 N_VSS_M5_s x_PM_OR4_X4%VSS_4 0.637857
C_x_PM_OR4_X4%VDD_c0 VSS x_PM_OR4_X4%VDD_12 3.09819e-17
C_x_PM_OR4_X4%VDD_c1 VSS N_VDD_M3_d 3.40316e-17
C_x_PM_OR4_X4%VDD_c2 VSS x_PM_OR4_X4%VDD_2 8.13771e-17
R_x_PM_OR4_X4%VDD_r3 x_PM_OR4_X4%VDD_12 x_PM_OR4_X4%VDD_6 0.145286
R_x_PM_OR4_X4%VDD_r4 N_VDD_M3_d x_PM_OR4_X4%VDD_6 0.230714
R_x_PM_OR4_X4%VDD_r5 x_PM_OR4_X4%VDD_12 x_PM_OR4_X4%VDD_2 0.0731438
R_x_PM_OR4_X4%VDD_r6 VDD x_PM_OR4_X4%VDD_2 0.910882
C_x_PM_OR4_X4%A1_c0 VSS x_PM_OR4_X4%A1_18 8.82802e-18
C_x_PM_OR4_X4%A1_c1 VSS x_PM_OR4_X4%A1_12 3.83216e-17
C_x_PM_OR4_X4%A1_c2 VSS N_A1_M0_g 8.54133e-17
C_x_PM_OR4_X4%A1_c3 VSS N_A1_M5_g 3.58927e-17
R_x_PM_OR4_X4%A1_r4 x_PM_OR4_X4%A1_18 x_PM_OR4_X4%A1_14 4.42
R_x_PM_OR4_X4%A1_r5 x_PM_OR4_X4%A1_14 x_PM_OR4_X4%A1_12 25.0012
R_x_PM_OR4_X4%A1_r6 x_PM_OR4_X4%A1_12 A1 0.1425
R_x_PM_OR4_X4%A1_r7 x_PM_OR4_X4%A1_18 x_PM_OR4_X4%A1_5 1.95
R_x_PM_OR4_X4%A1_r8 N_A1_M0_g x_PM_OR4_X4%A1_5 96.33
R_x_PM_OR4_X4%A1_r9 x_PM_OR4_X4%A1_18 x_PM_OR4_X4%A1_VSS 1.95
R_x_PM_OR4_X4%A1_r10 N_A1_M5_g x_PM_OR4_X4%A1_VSS 38.22
C_x_PM_OR4_X4%4_c0 VSS x_PM_OR4_X4%4_39 1.19959e-17
C_x_PM_OR4_X4%4_c1 VSS x_PM_OR4_X4%4_34 3.24061e-17
C_x_PM_OR4_X4%4_c2 VSS x_PM_OR4_X4%4_33 5.75475e-18
C_x_PM_OR4_X4%4_c3 VSS x_PM_OR4_X4%4_32 6.26156e-17
C_x_PM_OR4_X4%4_c4 VSS N_4_M7_d 4.13562e-17
C_x_PM_OR4_X4%4_c5 VSS x_PM_OR4_X4%4_24 4.77413e-17
C_x_PM_OR4_X4%4_c6 VSS x_PM_OR4_X4%4_23 9.6926e-17
C_x_PM_OR4_X4%4_c7 VSS N_4_M5_d 4.45892e-17
C_x_PM_OR4_X4%4_c8 VSS x_PM_OR4_X4%4_17 4.74221e-18
C_x_PM_OR4_X4%4_c9 VSS x_PM_OR4_X4%4_16 1.78908e-17
C_x_PM_OR4_X4%4_c10 VSS N_4_M0_s 2.90307e-17
C_x_PM_OR4_X4%4_c11 VSS N_4_M4_g 9.21197e-17
C_x_PM_OR4_X4%4_c12 VSS N_4_M9_g 4.86021e-17
R_x_PM_OR4_X4%4_r13 x_PM_OR4_X4%4_39 x_PM_OR4_X4%4_37 3.9
R_x_PM_OR4_X4%4_r14 x_PM_OR4_X4%4_35 x_PM_OR4_X4%4_34 0.800714
R_x_PM_OR4_X4%4_r15 x_PM_OR4_X4%4_35 x_PM_OR4_X4%4_32 0.095
R_x_PM_OR4_X4%4_r16 x_PM_OR4_X4%4_32 x_PM_OR4_X4%4_30 0.544324
R_x_PM_OR4_X4%4_r17 x_PM_OR4_X4%4_37 x_PM_OR4_X4%4_30 25.0012
R_x_PM_OR4_X4%4_r18 x_PM_OR4_X4%4_34 x_PM_OR4_X4%4_26 0.19
R_x_PM_OR4_X4%4_r19 N_4_M7_d x_PM_OR4_X4%4_26 0.529286
R_x_PM_OR4_X4%4_r20 x_PM_OR4_X4%4_33 x_PM_OR4_X4%4_25 0.0418175
R_x_PM_OR4_X4%4_r21 x_PM_OR4_X4%4_34 x_PM_OR4_X4%4_24 0.095
R_x_PM_OR4_X4%4_r22 x_PM_OR4_X4%4_25 x_PM_OR4_X4%4_24 1.68286
R_x_PM_OR4_X4%4_r23 x_PM_OR4_X4%4_33 x_PM_OR4_X4%4_22 0.160909
R_x_PM_OR4_X4%4_r24 x_PM_OR4_X4%4_23 x_PM_OR4_X4%4_22 2.93143
R_x_PM_OR4_X4%4_r25 x_PM_OR4_X4%4_33 x_PM_OR4_X4%4_18 0.160909
R_x_PM_OR4_X4%4_r26 N_4_M5_d x_PM_OR4_X4%4_18 0.529286
R_x_PM_OR4_X4%4_r27 x_PM_OR4_X4%4_23 x_PM_OR4_X4%4_16 0.212317
R_x_PM_OR4_X4%4_r28 x_PM_OR4_X4%4_17 x_PM_OR4_X4%4_16 0.597143
R_x_PM_OR4_X4%4_r29 x_PM_OR4_X4%4_17 x_PM_OR4_X4%4_12 0.212317
R_x_PM_OR4_X4%4_r30 N_4_M0_s x_PM_OR4_X4%4_12 0.909286
R_x_PM_OR4_X4%4_r31 x_PM_OR4_X4%4_39 x_PM_OR4_X4%4_5 1.95
R_x_PM_OR4_X4%4_r32 N_4_M4_g x_PM_OR4_X4%4_5 78.78
R_x_PM_OR4_X4%4_r33 x_PM_OR4_X4%4_39 x_PM_OR4_X4%4_VSS 1.95
R_x_PM_OR4_X4%4_r34 N_4_M9_g x_PM_OR4_X4%4_VSS 32.76
C_x_PM_OR4_X4%A2_c0 VSS A2 4.7612e-17
C_x_PM_OR4_X4%A2_c1 VSS x_PM_OR4_X4%A2_11 1.06087e-17
C_x_PM_OR4_X4%A2_c2 VSS N_A2_M1_g 5.58607e-17
C_x_PM_OR4_X4%A2_c3 VSS N_A2_M6_g 6.28153e-17
R_x_PM_OR4_X4%A2_r4 x_PM_OR4_X4%A2_11 x_PM_OR4_X4%A2_16 3.38
R_x_PM_OR4_X4%A2_r5 x_PM_OR4_X4%A2_11 x_PM_OR4_X4%A2_9 25.0012
R_x_PM_OR4_X4%A2_r6 A2 x_PM_OR4_X4%A2_9 0.169643
R_x_PM_OR4_X4%A2_r7 x_PM_OR4_X4%A2_16 x_PM_OR4_X4%A2_5 1.95
R_x_PM_OR4_X4%A2_r8 N_A2_M1_g x_PM_OR4_X4%A2_5 53.43
R_x_PM_OR4_X4%A2_r9 x_PM_OR4_X4%A2_16 x_PM_OR4_X4%A2_VSS 1.95
R_x_PM_OR4_X4%A2_r10 N_A2_M6_g x_PM_OR4_X4%A2_VSS 81.12
C_x_PM_OR4_X4%A3_c0 VSS x_PM_OR4_X4%A3_18 1.26955e-17
C_x_PM_OR4_X4%A3_c1 VSS x_PM_OR4_X4%A3_12 6.99853e-17
C_x_PM_OR4_X4%A3_c2 VSS N_A3_M2_g 7.90812e-17
C_x_PM_OR4_X4%A3_c3 VSS N_A3_M7_g 3.93473e-17
R_x_PM_OR4_X4%A3_r4 x_PM_OR4_X4%A3_18 x_PM_OR4_X4%A3_14 5.46
R_x_PM_OR4_X4%A3_r5 x_PM_OR4_X4%A3_14 x_PM_OR4_X4%A3_12 25.0012
R_x_PM_OR4_X4%A3_r6 x_PM_OR4_X4%A3_12 A3 0.11963
R_x_PM_OR4_X4%A3_r7 x_PM_OR4_X4%A3_18 x_PM_OR4_X4%A3_5 1.95
R_x_PM_OR4_X4%A3_r8 N_A3_M2_g x_PM_OR4_X4%A3_5 91.65
R_x_PM_OR4_X4%A3_r9 x_PM_OR4_X4%A3_18 x_PM_OR4_X4%A3_VSS 1.95
R_x_PM_OR4_X4%A3_r10 N_A3_M7_g x_PM_OR4_X4%A3_VSS 42.9
C_x_PM_OR4_X4%A4_c0 VSS A4 4.0155e-17
C_x_PM_OR4_X4%A4_c1 VSS x_PM_OR4_X4%A4_11 8.76007e-18
C_x_PM_OR4_X4%A4_c2 VSS N_A4_M3_g 5.60906e-17
C_x_PM_OR4_X4%A4_c3 VSS N_A4_M8_g 6.60797e-17
R_x_PM_OR4_X4%A4_r4 x_PM_OR4_X4%A4_18 x_PM_OR4_X4%A4_11 4.7687
R_x_PM_OR4_X4%A4_r5 x_PM_OR4_X4%A4_17 x_PM_OR4_X4%A4_11 4.7687
R_x_PM_OR4_X4%A4_r6 x_PM_OR4_X4%A4_11 x_PM_OR4_X4%A4_9 25.0012
R_x_PM_OR4_X4%A4_r7 A4 x_PM_OR4_X4%A4_9 0.281724
R_x_PM_OR4_X4%A4_r8 N_A4_M3_g x_PM_OR4_X4%A4_18 54.21
R_x_PM_OR4_X4%A4_r9 N_A4_M8_g x_PM_OR4_X4%A4_17 80.34
C_x_PM_OR4_X4%ZN_c0 VSS N_ZN_M9_d 1.24723e-16
R_x_PM_OR4_X4%ZN_r1 N_ZN_M4_d ZN 1.72357
R_x_PM_OR4_X4%ZN_r2 ZN N_ZN_M9_d 1.39786
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X1.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X1 VSS VDD SE SI D CK SN RN QN Q
*.PININFO VSS:B VDD:B SE:I SI:I D:I CK:I SN:I RN:I QN:O Q:O
M_M25 N_VDD_M0_d N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 20 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M27 N_7_M2_d N_SE_M2_g 20 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M28 21 N_3_M3_g N_7_M2_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M29 N_VDD_M4_d N_SI_M4_g 21 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M30 N_VDD_M5_d N_CK_M5_g N_8_M5_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M31 N_10_M6_d N_8_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 22 N_10_M7_g N_11_M7_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M33 N_VDD_M8_d N_7_M8_g 22 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M34 23 N_12_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 N_11_M10_d N_8_M10_g 23 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M36 24 N_8_M11_g N_11_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M37 N_VDD_M12_d N_SN_M12_g 24 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M38 N_12_M13_d N_11_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M39 N_VDD_M14_d N_RN_M14_g N_12_M13_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M40 25 N_8_M15_g N_14_M15_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M41 N_VDD_M16_d N_11_M16_g 25 VDD PMOS_VTL W=0.135000U L=0.050000U
M_M42 26 N_15_M17_g N_VDD_M16_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M43 N_14_M18_d N_10_M18_g 26 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M44 27 N_10_M19_g N_14_M18_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M45 N_VDD_M20_d N_RN_M20_g 27 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M46 N_15_M21_d N_SN_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M47 N_VDD_M22_d N_14_M22_g N_15_M21_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M48 N_17_M23_d N_RN_M23_g N_VDD_M22_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M49 N_VDD_M24_d N_15_M24_g N_17_M23_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M50 N_VDD_M25_d N_15_M25_g N_QN_M25_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M51 N_Q_M26_d N_17_M26_g N_VDD_M25_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M27_d N_SE_M27_g N_3_M27_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 28 N_SI_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_7_M29_d N_SE_M29_g 28 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 29 N_3_M30_g N_7_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M31_d N_D_M31_g 29 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M32_d N_CK_M32_g N_8_M32_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_10_M33_d N_8_M33_g N_VSS_M32_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 30 N_7_M34_g N_VSS_M34_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_11_M35_d N_8_M35_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 31 N_10_M36_g N_11_M35_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 32 N_12_M37_g 31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M38_d N_SN_M38_g 32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 33 N_11_M39_g N_12_M39_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 N_VSS_M40_d N_RN_M40_g 33 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 34 N_11_M41_g N_VSS_M40_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_14_M42_d N_10_M42_g 34 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 35 N_8_M43_g N_14_M42_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M17 36 N_15_M44_g 35 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M18 N_VSS_M45_d N_RN_M45_g 36 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M19 37 N_SN_M46_g N_VSS_M45_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M20 N_15_M47_d N_14_M47_g 37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M21 38 N_RN_M48_g N_VSS_M48_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M22 N_17_M49_d N_15_M49_g 38 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M23 N_VSS_M50_d N_15_M50_g N_QN_M50_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M24 N_Q_M51_d N_17_M51_g N_VSS_M50_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_SDFFRS_X1%VSS_c0 VSS x_PM_SDFFRS_X1%VSS_67 2.98924e-18
C_x_PM_SDFFRS_X1%VSS_c1 VSS x_PM_SDFFRS_X1%VSS_65 3.68446e-17
C_x_PM_SDFFRS_X1%VSS_c2 VSS x_PM_SDFFRS_X1%VSS_57 4.30961e-17
C_x_PM_SDFFRS_X1%VSS_c3 VSS x_PM_SDFFRS_X1%VSS_56 8.86015e-18
C_x_PM_SDFFRS_X1%VSS_c4 VSS x_PM_SDFFRS_X1%VSS_55 8.85742e-18
C_x_PM_SDFFRS_X1%VSS_c5 VSS x_PM_SDFFRS_X1%VSS_54 4.90006e-18
C_x_PM_SDFFRS_X1%VSS_c6 VSS x_PM_SDFFRS_X1%VSS_53 8.89791e-18
C_x_PM_SDFFRS_X1%VSS_c7 VSS x_PM_SDFFRS_X1%VSS_48 3.05606e-17
C_x_PM_SDFFRS_X1%VSS_c8 VSS x_PM_SDFFRS_X1%VSS_47 8.86015e-18
C_x_PM_SDFFRS_X1%VSS_c9 VSS x_PM_SDFFRS_X1%VSS_46 3.14565e-17
C_x_PM_SDFFRS_X1%VSS_c10 VSS VSS 2.36377e-17
C_x_PM_SDFFRS_X1%VSS_c11 VSS x_PM_SDFFRS_X1%VSS_41 5.74622e-17
C_x_PM_SDFFRS_X1%VSS_c12 VSS x_PM_SDFFRS_X1%VSS_38 9.32771e-17
C_x_PM_SDFFRS_X1%VSS_c13 VSS x_PM_SDFFRS_X1%VSS_36 5.67541e-17
C_x_PM_SDFFRS_X1%VSS_c14 VSS x_PM_SDFFRS_X1%VSS_35 4.99616e-17
C_x_PM_SDFFRS_X1%VSS_c15 VSS x_PM_SDFFRS_X1%VSS_32 1.03347e-16
C_x_PM_SDFFRS_X1%VSS_c16 VSS x_PM_SDFFRS_X1%VSS_31 2.29169e-17
C_x_PM_SDFFRS_X1%VSS_c17 VSS x_PM_SDFFRS_X1%VSS_28 4.83108e-17
C_x_PM_SDFFRS_X1%VSS_c18 VSS x_PM_SDFFRS_X1%VSS_27 7.14954e-17
C_x_PM_SDFFRS_X1%VSS_c19 VSS x_PM_SDFFRS_X1%VSS_24 1.01125e-16
C_x_PM_SDFFRS_X1%VSS_c20 VSS x_PM_SDFFRS_X1%VSS_23 5.90519e-17
C_x_PM_SDFFRS_X1%VSS_c21 VSS x_PM_SDFFRS_X1%VSS_20 2.87809e-17
C_x_PM_SDFFRS_X1%VSS_c22 VSS x_PM_SDFFRS_X1%VSS_18 3.92101e-17
C_x_PM_SDFFRS_X1%VSS_c23 VSS x_PM_SDFFRS_X1%VSS_17 5.87553e-17
C_x_PM_SDFFRS_X1%VSS_c24 VSS x_PM_SDFFRS_X1%VSS_14 6.49394e-17
C_x_PM_SDFFRS_X1%VSS_c25 VSS x_PM_SDFFRS_X1%VSS_13 2.63763e-17
R_x_PM_SDFFRS_X1%VSS_r26 x_PM_SDFFRS_X1%VSS_65 N_VSS_M50_d 0.285
R_x_PM_SDFFRS_X1%VSS_r27 N_VSS_M48_s x_PM_SDFFRS_X1%VSS_57 0.49963
R_x_PM_SDFFRS_X1%VSS_r28 N_VSS_M32_d x_PM_SDFFRS_X1%VSS_48 0.49963
R_x_PM_SDFFRS_X1%VSS_r29 x_PM_SDFFRS_X1%VSS_67 x_PM_SDFFRS_X1%VSS_42 0.0731438
R_x_PM_SDFFRS_X1%VSS_r30 VSS x_PM_SDFFRS_X1%VSS_42 0.480588
R_x_PM_SDFFRS_X1%VSS_r31 x_PM_SDFFRS_X1%VSS_65 x_PM_SDFFRS_X1%VSS_41 0.095
R_x_PM_SDFFRS_X1%VSS_r32 x_PM_SDFFRS_X1%VSS_67 x_PM_SDFFRS_X1%VSS_40 0.145286
R_x_PM_SDFFRS_X1%VSS_r33 x_PM_SDFFRS_X1%VSS_41 x_PM_SDFFRS_X1%VSS_40 1.81857
R_x_PM_SDFFRS_X1%VSS_r34 x_PM_SDFFRS_X1%VSS_57 x_PM_SDFFRS_X1%VSS_39 0.095
R_x_PM_SDFFRS_X1%VSS_r35 x_PM_SDFFRS_X1%VSS_67 x_PM_SDFFRS_X1%VSS_38 0.0731438
R_x_PM_SDFFRS_X1%VSS_r36 x_PM_SDFFRS_X1%VSS_39 x_PM_SDFFRS_X1%VSS_38 1.45294
R_x_PM_SDFFRS_X1%VSS_r37 x_PM_SDFFRS_X1%VSS_56 x_PM_SDFFRS_X1%VSS_37 0.132285
R_x_PM_SDFFRS_X1%VSS_r38 x_PM_SDFFRS_X1%VSS_57 x_PM_SDFFRS_X1%VSS_36 0.095
R_x_PM_SDFFRS_X1%VSS_r39 x_PM_SDFFRS_X1%VSS_37 x_PM_SDFFRS_X1%VSS_36 1.06176
R_x_PM_SDFFRS_X1%VSS_r40 x_PM_SDFFRS_X1%VSS_56 x_PM_SDFFRS_X1%VSS_35 0.0680382
R_x_PM_SDFFRS_X1%VSS_r41 x_PM_SDFFRS_X1%VSS_35 N_VSS_M45_d 0.403583
R_x_PM_SDFFRS_X1%VSS_r42 x_PM_SDFFRS_X1%VSS_55 x_PM_SDFFRS_X1%VSS_33 0.132285
R_x_PM_SDFFRS_X1%VSS_r43 x_PM_SDFFRS_X1%VSS_56 x_PM_SDFFRS_X1%VSS_32 0.132285
R_x_PM_SDFFRS_X1%VSS_r44 x_PM_SDFFRS_X1%VSS_33 x_PM_SDFFRS_X1%VSS_32 2.04529
R_x_PM_SDFFRS_X1%VSS_r45 x_PM_SDFFRS_X1%VSS_55 x_PM_SDFFRS_X1%VSS_31 0.0680382
R_x_PM_SDFFRS_X1%VSS_r46 x_PM_SDFFRS_X1%VSS_31 N_VSS_M40_d 0.403583
R_x_PM_SDFFRS_X1%VSS_r47 x_PM_SDFFRS_X1%VSS_54 x_PM_SDFFRS_X1%VSS_29 0.132285
R_x_PM_SDFFRS_X1%VSS_r48 x_PM_SDFFRS_X1%VSS_55 x_PM_SDFFRS_X1%VSS_28 0.132285
R_x_PM_SDFFRS_X1%VSS_r49 x_PM_SDFFRS_X1%VSS_29 x_PM_SDFFRS_X1%VSS_28 1.29647
R_x_PM_SDFFRS_X1%VSS_r50 x_PM_SDFFRS_X1%VSS_54 x_PM_SDFFRS_X1%VSS_27 0.0680382
R_x_PM_SDFFRS_X1%VSS_r51 x_PM_SDFFRS_X1%VSS_27 N_VSS_M38_d 0.558398
R_x_PM_SDFFRS_X1%VSS_r52 x_PM_SDFFRS_X1%VSS_53 x_PM_SDFFRS_X1%VSS_25 0.132285
R_x_PM_SDFFRS_X1%VSS_r53 x_PM_SDFFRS_X1%VSS_54 x_PM_SDFFRS_X1%VSS_24 0.132285
R_x_PM_SDFFRS_X1%VSS_r54 x_PM_SDFFRS_X1%VSS_25 x_PM_SDFFRS_X1%VSS_24 2.00059
R_x_PM_SDFFRS_X1%VSS_r55 x_PM_SDFFRS_X1%VSS_53 x_PM_SDFFRS_X1%VSS_23 0.0680382
R_x_PM_SDFFRS_X1%VSS_r56 x_PM_SDFFRS_X1%VSS_23 N_VSS_M34_s 0.558398
R_x_PM_SDFFRS_X1%VSS_r57 x_PM_SDFFRS_X1%VSS_48 x_PM_SDFFRS_X1%VSS_21 0.095
R_x_PM_SDFFRS_X1%VSS_r58 x_PM_SDFFRS_X1%VSS_53 x_PM_SDFFRS_X1%VSS_20 0.132285
R_x_PM_SDFFRS_X1%VSS_r59 x_PM_SDFFRS_X1%VSS_21 x_PM_SDFFRS_X1%VSS_20 0.536471
R_x_PM_SDFFRS_X1%VSS_r60 x_PM_SDFFRS_X1%VSS_47 x_PM_SDFFRS_X1%VSS_19 0.132285
R_x_PM_SDFFRS_X1%VSS_r61 x_PM_SDFFRS_X1%VSS_48 x_PM_SDFFRS_X1%VSS_18 0.095
R_x_PM_SDFFRS_X1%VSS_r62 x_PM_SDFFRS_X1%VSS_19 x_PM_SDFFRS_X1%VSS_18 0.625882
R_x_PM_SDFFRS_X1%VSS_r63 x_PM_SDFFRS_X1%VSS_47 x_PM_SDFFRS_X1%VSS_17 0.0680382
R_x_PM_SDFFRS_X1%VSS_r64 x_PM_SDFFRS_X1%VSS_17 N_VSS_M31_d 0.403583
R_x_PM_SDFFRS_X1%VSS_r65 x_PM_SDFFRS_X1%VSS_46 x_PM_SDFFRS_X1%VSS_15 0.132285
R_x_PM_SDFFRS_X1%VSS_r66 x_PM_SDFFRS_X1%VSS_47 x_PM_SDFFRS_X1%VSS_14 0.132285
R_x_PM_SDFFRS_X1%VSS_r67 x_PM_SDFFRS_X1%VSS_15 x_PM_SDFFRS_X1%VSS_14 1.38588
R_x_PM_SDFFRS_X1%VSS_r68 x_PM_SDFFRS_X1%VSS_46 x_PM_SDFFRS_X1%VSS_13 0.0680382
R_x_PM_SDFFRS_X1%VSS_r69 x_PM_SDFFRS_X1%VSS_13 N_VSS_M27_d 0.403583
C_x_PM_SDFFRS_X1%VDD_c0 VSS x_PM_SDFFRS_X1%VDD_80 2.50129e-17
C_x_PM_SDFFRS_X1%VDD_c1 VSS N_VDD_M24_d 3.85279e-17
C_x_PM_SDFFRS_X1%VDD_c2 VSS x_PM_SDFFRS_X1%VDD_76 8.85742e-18
C_x_PM_SDFFRS_X1%VDD_c3 VSS N_VDD_M20_d 4.78633e-17
C_x_PM_SDFFRS_X1%VDD_c4 VSS N_VDD_M16_d 4.45596e-17
C_x_PM_SDFFRS_X1%VDD_c5 VSS x_PM_SDFFRS_X1%VDD_65 8.86015e-18
C_x_PM_SDFFRS_X1%VDD_c6 VSS x_PM_SDFFRS_X1%VDD_64 8.86015e-18
C_x_PM_SDFFRS_X1%VDD_c7 VSS x_PM_SDFFRS_X1%VDD_63 5.64357e-18
C_x_PM_SDFFRS_X1%VDD_c8 VSS x_PM_SDFFRS_X1%VDD_62 5.74485e-18
C_x_PM_SDFFRS_X1%VDD_c9 VSS N_VDD_M4_d 1.88619e-17
C_x_PM_SDFFRS_X1%VDD_c10 VSS N_VDD_M0_d 3.04192e-17
C_x_PM_SDFFRS_X1%VDD_c11 VSS N_VDD_M25_d 3.79527e-17
C_x_PM_SDFFRS_X1%VDD_c12 VSS x_PM_SDFFRS_X1%VDD_44 2.11037e-17
C_x_PM_SDFFRS_X1%VDD_c13 VSS x_PM_SDFFRS_X1%VDD_43 3.87968e-17
C_x_PM_SDFFRS_X1%VDD_c14 VSS x_PM_SDFFRS_X1%VDD_40 3.18517e-17
C_x_PM_SDFFRS_X1%VDD_c15 VSS x_PM_SDFFRS_X1%VDD_38 7.73001e-17
C_x_PM_SDFFRS_X1%VDD_c16 VSS x_PM_SDFFRS_X1%VDD_36 5.28513e-17
C_x_PM_SDFFRS_X1%VDD_c17 VSS x_PM_SDFFRS_X1%VDD_35 3.73579e-17
C_x_PM_SDFFRS_X1%VDD_c18 VSS x_PM_SDFFRS_X1%VDD_32 4.56324e-17
C_x_PM_SDFFRS_X1%VDD_c19 VSS x_PM_SDFFRS_X1%VDD_31 3.135e-17
C_x_PM_SDFFRS_X1%VDD_c20 VSS x_PM_SDFFRS_X1%VDD_28 7.04591e-17
C_x_PM_SDFFRS_X1%VDD_c21 VSS x_PM_SDFFRS_X1%VDD_27 5.28055e-17
C_x_PM_SDFFRS_X1%VDD_c22 VSS x_PM_SDFFRS_X1%VDD_24 6.05293e-17
C_x_PM_SDFFRS_X1%VDD_c23 VSS N_VDD_M5_d 6.56241e-17
C_x_PM_SDFFRS_X1%VDD_c24 VSS x_PM_SDFFRS_X1%VDD_18 1.88222e-17
C_x_PM_SDFFRS_X1%VDD_c25 VSS x_PM_SDFFRS_X1%VDD_16 5.23104e-17
C_x_PM_SDFFRS_X1%VDD_c26 VSS x_PM_SDFFRS_X1%VDD_12 5.23035e-17
R_x_PM_SDFFRS_X1%VDD_r27 x_PM_SDFFRS_X1%VDD_80 N_VDD_M24_d 0.309216
R_x_PM_SDFFRS_X1%VDD_r28 x_PM_SDFFRS_X1%VDD_79 N_VDD_M24_d 0.273845
R_x_PM_SDFFRS_X1%VDD_r29 x_PM_SDFFRS_X1%VDD_74 N_VDD_M20_d 0.49963
R_x_PM_SDFFRS_X1%VDD_r30 x_PM_SDFFRS_X1%VDD_69 N_VDD_M16_d 0.49963
R_x_PM_SDFFRS_X1%VDD_r31 x_PM_SDFFRS_X1%VDD_60 N_VDD_M4_d 0.471481
R_x_PM_SDFFRS_X1%VDD_r32 x_PM_SDFFRS_X1%VDD_55 N_VDD_M0_d 0.471481
R_x_PM_SDFFRS_X1%VDD_r33 N_VDD_M25_d x_PM_SDFFRS_X1%VDD_79 1.37071
R_x_PM_SDFFRS_X1%VDD_r34 x_PM_SDFFRS_X1%VDD_76 x_PM_SDFFRS_X1%VDD_45 0.132285
R_x_PM_SDFFRS_X1%VDD_r35 x_PM_SDFFRS_X1%VDD_80 x_PM_SDFFRS_X1%VDD_44 0.095
R_x_PM_SDFFRS_X1%VDD_r36 x_PM_SDFFRS_X1%VDD_45 x_PM_SDFFRS_X1%VDD_44 0.536471
R_x_PM_SDFFRS_X1%VDD_r37 x_PM_SDFFRS_X1%VDD_76 x_PM_SDFFRS_X1%VDD_43 0.0680382
R_x_PM_SDFFRS_X1%VDD_r38 x_PM_SDFFRS_X1%VDD_43 N_VDD_M22_d 0.403583
R_x_PM_SDFFRS_X1%VDD_r39 x_PM_SDFFRS_X1%VDD_74 x_PM_SDFFRS_X1%VDD_41 0.095
R_x_PM_SDFFRS_X1%VDD_r40 x_PM_SDFFRS_X1%VDD_76 x_PM_SDFFRS_X1%VDD_40 0.132285
R_x_PM_SDFFRS_X1%VDD_r41 x_PM_SDFFRS_X1%VDD_41 x_PM_SDFFRS_X1%VDD_40 0.625882
R_x_PM_SDFFRS_X1%VDD_r42 x_PM_SDFFRS_X1%VDD_69 x_PM_SDFFRS_X1%VDD_39 0.095
R_x_PM_SDFFRS_X1%VDD_r43 x_PM_SDFFRS_X1%VDD_74 x_PM_SDFFRS_X1%VDD_38 0.095
R_x_PM_SDFFRS_X1%VDD_r44 x_PM_SDFFRS_X1%VDD_39 x_PM_SDFFRS_X1%VDD_38 1.58706
R_x_PM_SDFFRS_X1%VDD_r45 x_PM_SDFFRS_X1%VDD_65 x_PM_SDFFRS_X1%VDD_37 0.132285
R_x_PM_SDFFRS_X1%VDD_r46 x_PM_SDFFRS_X1%VDD_69 x_PM_SDFFRS_X1%VDD_36 0.095
R_x_PM_SDFFRS_X1%VDD_r47 x_PM_SDFFRS_X1%VDD_37 x_PM_SDFFRS_X1%VDD_36 0.938824
R_x_PM_SDFFRS_X1%VDD_r48 x_PM_SDFFRS_X1%VDD_65 x_PM_SDFFRS_X1%VDD_35 0.0680382
R_x_PM_SDFFRS_X1%VDD_r49 x_PM_SDFFRS_X1%VDD_35 N_VDD_M14_d 0.403583
R_x_PM_SDFFRS_X1%VDD_r50 x_PM_SDFFRS_X1%VDD_64 x_PM_SDFFRS_X1%VDD_33 0.132285
R_x_PM_SDFFRS_X1%VDD_r51 x_PM_SDFFRS_X1%VDD_65 x_PM_SDFFRS_X1%VDD_32 0.132285
R_x_PM_SDFFRS_X1%VDD_r52 x_PM_SDFFRS_X1%VDD_33 x_PM_SDFFRS_X1%VDD_32 0.95
R_x_PM_SDFFRS_X1%VDD_r53 x_PM_SDFFRS_X1%VDD_64 x_PM_SDFFRS_X1%VDD_31 0.0680382
R_x_PM_SDFFRS_X1%VDD_r54 x_PM_SDFFRS_X1%VDD_31 N_VDD_M12_d 0.403583
R_x_PM_SDFFRS_X1%VDD_r55 x_PM_SDFFRS_X1%VDD_63 x_PM_SDFFRS_X1%VDD_29 0.132285
R_x_PM_SDFFRS_X1%VDD_r56 x_PM_SDFFRS_X1%VDD_64 x_PM_SDFFRS_X1%VDD_28 0.132285
R_x_PM_SDFFRS_X1%VDD_r57 x_PM_SDFFRS_X1%VDD_29 x_PM_SDFFRS_X1%VDD_28 1.43059
R_x_PM_SDFFRS_X1%VDD_r58 x_PM_SDFFRS_X1%VDD_63 x_PM_SDFFRS_X1%VDD_27 0.0680382
R_x_PM_SDFFRS_X1%VDD_r59 x_PM_SDFFRS_X1%VDD_27 N_VDD_M8_d 0.403583
R_x_PM_SDFFRS_X1%VDD_r60 x_PM_SDFFRS_X1%VDD_62 x_PM_SDFFRS_X1%VDD_25 0.132285
R_x_PM_SDFFRS_X1%VDD_r61 x_PM_SDFFRS_X1%VDD_63 x_PM_SDFFRS_X1%VDD_24 0.132285
R_x_PM_SDFFRS_X1%VDD_r62 x_PM_SDFFRS_X1%VDD_25 x_PM_SDFFRS_X1%VDD_24 1.49765
R_x_PM_SDFFRS_X1%VDD_r63 x_PM_SDFFRS_X1%VDD_62 x_PM_SDFFRS_X1%VDD_20 0.0680382
R_x_PM_SDFFRS_X1%VDD_r64 N_VDD_M5_d x_PM_SDFFRS_X1%VDD_20 0.935926
R_x_PM_SDFFRS_X1%VDD_r65 x_PM_SDFFRS_X1%VDD_60 x_PM_SDFFRS_X1%VDD_19 0.095
R_x_PM_SDFFRS_X1%VDD_r66 x_PM_SDFFRS_X1%VDD_62 x_PM_SDFFRS_X1%VDD_18 0.132285
R_x_PM_SDFFRS_X1%VDD_r67 x_PM_SDFFRS_X1%VDD_19 x_PM_SDFFRS_X1%VDD_18 0.57
R_x_PM_SDFFRS_X1%VDD_r68 x_PM_SDFFRS_X1%VDD_55 x_PM_SDFFRS_X1%VDD_17 0.095
R_x_PM_SDFFRS_X1%VDD_r69 x_PM_SDFFRS_X1%VDD_60 x_PM_SDFFRS_X1%VDD_16 0.095
R_x_PM_SDFFRS_X1%VDD_r70 x_PM_SDFFRS_X1%VDD_17 x_PM_SDFFRS_X1%VDD_16 1.38588
R_x_PM_SDFFRS_X1%VDD_r71 x_PM_SDFFRS_X1%VDD_55 x_PM_SDFFRS_X1%VDD_12 0.095
R_x_PM_SDFFRS_X1%VDD_r72 VDD x_PM_SDFFRS_X1%VDD_12 0.296176
C_x_PM_SDFFRS_X1%3_c0 VSS x_PM_SDFFRS_X1%3_28 8.6005e-18
C_x_PM_SDFFRS_X1%3_c1 VSS N_3_M0_s 5.0746e-17
C_x_PM_SDFFRS_X1%3_c2 VSS x_PM_SDFFRS_X1%3_22 2.7648e-18
C_x_PM_SDFFRS_X1%3_c3 VSS x_PM_SDFFRS_X1%3_19 1.77009e-16
C_x_PM_SDFFRS_X1%3_c4 VSS x_PM_SDFFRS_X1%3_16 5.52711e-17
C_x_PM_SDFFRS_X1%3_c5 VSS N_3_M27_s 4.15459e-17
C_x_PM_SDFFRS_X1%3_c6 VSS N_3_M3_g 6.64576e-17
C_x_PM_SDFFRS_X1%3_c7 VSS N_3_M30_g 5.19859e-17
R_x_PM_SDFFRS_X1%3_r8 x_PM_SDFFRS_X1%3_30 x_PM_SDFFRS_X1%3_28 4.7687
R_x_PM_SDFFRS_X1%3_r9 N_3_M0_s x_PM_SDFFRS_X1%3_23 0.285
R_x_PM_SDFFRS_X1%3_r10 x_PM_SDFFRS_X1%3_28 x_PM_SDFFRS_X1%3_19 25.0012
R_x_PM_SDFFRS_X1%3_r11 x_PM_SDFFRS_X1%3_22 x_PM_SDFFRS_X1%3_17 0.0604376
R_x_PM_SDFFRS_X1%3_r12 x_PM_SDFFRS_X1%3_19 x_PM_SDFFRS_X1%3_17 3.56929
R_x_PM_SDFFRS_X1%3_r13 x_PM_SDFFRS_X1%3_23 x_PM_SDFFRS_X1%3_16 0.095
R_x_PM_SDFFRS_X1%3_r14 x_PM_SDFFRS_X1%3_22 x_PM_SDFFRS_X1%3_15 0.140052
R_x_PM_SDFFRS_X1%3_r15 x_PM_SDFFRS_X1%3_16 x_PM_SDFFRS_X1%3_15 2.52429
R_x_PM_SDFFRS_X1%3_r16 x_PM_SDFFRS_X1%3_22 x_PM_SDFFRS_X1%3_11 0.140052
R_x_PM_SDFFRS_X1%3_r17 N_3_M27_s x_PM_SDFFRS_X1%3_11 1.15
R_x_PM_SDFFRS_X1%3_r18 N_3_M3_g x_PM_SDFFRS_X1%3_30 58.5
R_x_PM_SDFFRS_X1%3_r19 x_PM_SDFFRS_X1%3_VSS x_PM_SDFFRS_X1%3_28 4.7687
R_x_PM_SDFFRS_X1%3_r20 N_3_M30_g x_PM_SDFFRS_X1%3_VSS 52.26
C_x_PM_SDFFRS_X1%SE_c0 VSS x_PM_SDFFRS_X1%SE_25 8.48627e-18
C_x_PM_SDFFRS_X1%SE_c1 VSS x_PM_SDFFRS_X1%SE_23 8.27883e-17
C_x_PM_SDFFRS_X1%SE_c2 VSS x_PM_SDFFRS_X1%SE_22 7.64623e-18
C_x_PM_SDFFRS_X1%SE_c3 VSS x_PM_SDFFRS_X1%SE_21 9.48689e-18
C_x_PM_SDFFRS_X1%SE_c4 VSS N_SE_M2_g 6.50607e-17
C_x_PM_SDFFRS_X1%SE_c5 VSS N_SE_M29_g 4.82133e-17
C_x_PM_SDFFRS_X1%SE_c6 VSS x_PM_SDFFRS_X1%SE_11 3.38108e-17
C_x_PM_SDFFRS_X1%SE_c7 VSS N_SE_M0_g 4.59689e-17
C_x_PM_SDFFRS_X1%SE_c8 VSS x_PM_SDFFRS_X1%SE_6 1.81433e-17
C_x_PM_SDFFRS_X1%SE_c9 VSS N_SE_M27_g 4.66595e-17
R_x_PM_SDFFRS_X1%SE_r10 x_PM_SDFFRS_X1%SE_31 x_PM_SDFFRS_X1%SE_25 5.00559
R_x_PM_SDFFRS_X1%SE_r11 x_PM_SDFFRS_X1%SE_25 x_PM_SDFFRS_X1%SE_23 25.0012
R_x_PM_SDFFRS_X1%SE_r12 SE x_PM_SDFFRS_X1%SE_23 0.169643
R_x_PM_SDFFRS_X1%SE_r13 x_PM_SDFFRS_X1%SE_22 x_PM_SDFFRS_X1%SE_17 4.08464
R_x_PM_SDFFRS_X1%SE_r14 N_SE_M2_g x_PM_SDFFRS_X1%SE_17 59.28
R_x_PM_SDFFRS_X1%SE_r15 x_PM_SDFFRS_X1%SE_22 x_PM_SDFFRS_X1%SE_13 4.08464
R_x_PM_SDFFRS_X1%SE_r16 N_SE_M29_g x_PM_SDFFRS_X1%SE_13 53.04
R_x_PM_SDFFRS_X1%SE_r17 x_PM_SDFFRS_X1%SE_21 x_PM_SDFFRS_X1%SE_12 1.34254
R_x_PM_SDFFRS_X1%SE_r18 x_PM_SDFFRS_X1%SE_22 x_PM_SDFFRS_X1%SE_11 0.266723
R_x_PM_SDFFRS_X1%SE_r19 x_PM_SDFFRS_X1%SE_12 x_PM_SDFFRS_X1%SE_11 34.2
R_x_PM_SDFFRS_X1%SE_r20 N_SE_M0_g x_PM_SDFFRS_X1%SE_31 53.04
R_x_PM_SDFFRS_X1%SE_r21 x_PM_SDFFRS_X1%SE_25 x_PM_SDFFRS_X1%SE_6 1.24091
R_x_PM_SDFFRS_X1%SE_r22 x_PM_SDFFRS_X1%SE_21 x_PM_SDFFRS_X1%SE_5 2.76957
R_x_PM_SDFFRS_X1%SE_r23 x_PM_SDFFRS_X1%SE_6 x_PM_SDFFRS_X1%SE_5 8.50909
R_x_PM_SDFFRS_X1%SE_r24 x_PM_SDFFRS_X1%SE_21 x_PM_SDFFRS_X1%SE_VSS 2.76957
R_x_PM_SDFFRS_X1%SE_r25 N_SE_M27_g x_PM_SDFFRS_X1%SE_VSS 46.02
C_x_PM_SDFFRS_X1%SI_c0 VSS x_PM_SDFFRS_X1%SI_20 9.6761e-18
C_x_PM_SDFFRS_X1%SI_c1 VSS x_PM_SDFFRS_X1%SI_18 6.18895e-17
C_x_PM_SDFFRS_X1%SI_c2 VSS x_PM_SDFFRS_X1%SI_14 5.3184e-17
C_x_PM_SDFFRS_X1%SI_c3 VSS x_PM_SDFFRS_X1%SI_12 7.06336e-18
C_x_PM_SDFFRS_X1%SI_c4 VSS x_PM_SDFFRS_X1%SI_11 2.30466e-17
C_x_PM_SDFFRS_X1%SI_c5 VSS N_SI_M4_g 6.93761e-17
C_x_PM_SDFFRS_X1%SI_c6 VSS x_PM_SDFFRS_X1%SI_6 5.10473e-18
C_x_PM_SDFFRS_X1%SI_c7 VSS x_PM_SDFFRS_X1%SI_5 9.59378e-17
C_x_PM_SDFFRS_X1%SI_c8 VSS N_SI_M28_g 3.34291e-17
R_x_PM_SDFFRS_X1%SI_r9 x_PM_SDFFRS_X1%SI_23 x_PM_SDFFRS_X1%SI_20 4.7687
R_x_PM_SDFFRS_X1%SI_r10 x_PM_SDFFRS_X1%SI_20 x_PM_SDFFRS_X1%SI_18 25.0012
R_x_PM_SDFFRS_X1%SI_r11 x_PM_SDFFRS_X1%SI_18 SI 0.291786
R_x_PM_SDFFRS_X1%SI_r12 x_PM_SDFFRS_X1%SI_14 x_PM_SDFFRS_X1%SI_13 89.7
R_x_PM_SDFFRS_X1%SI_r13 x_PM_SDFFRS_X1%SI_14 x_PM_SDFFRS_X1%SI_11 4.35808
R_x_PM_SDFFRS_X1%SI_r14 x_PM_SDFFRS_X1%SI_12 x_PM_SDFFRS_X1%SI_11 21.06
R_x_PM_SDFFRS_X1%SI_r15 x_PM_SDFFRS_X1%SI_12 x_PM_SDFFRS_X1%SI_7 4.35808
R_x_PM_SDFFRS_X1%SI_r16 N_SI_M4_g x_PM_SDFFRS_X1%SI_7 58.5
R_x_PM_SDFFRS_X1%SI_r17 x_PM_SDFFRS_X1%SI_13 x_PM_SDFFRS_X1%SI_5 4.35808
R_x_PM_SDFFRS_X1%SI_r18 x_PM_SDFFRS_X1%SI_6 x_PM_SDFFRS_X1%SI_5 113.1
R_x_PM_SDFFRS_X1%SI_r19 N_SI_M28_g x_PM_SDFFRS_X1%SI_23 21.84
R_x_PM_SDFFRS_X1%SI_r20 x_PM_SDFFRS_X1%SI_6 x_PM_SDFFRS_X1%SI_VSS 4.35808
R_x_PM_SDFFRS_X1%SI_r21 N_SI_M28_g x_PM_SDFFRS_X1%SI_VSS 33.54
C_x_PM_SDFFRS_X1%D_c0 VSS x_PM_SDFFRS_X1%D_20 1.24052e-17
C_x_PM_SDFFRS_X1%D_c1 VSS x_PM_SDFFRS_X1%D_16 7.83004e-17
C_x_PM_SDFFRS_X1%D_c2 VSS x_PM_SDFFRS_X1%D_14 1.08128e-17
C_x_PM_SDFFRS_X1%D_c3 VSS x_PM_SDFFRS_X1%D_12 8.72019e-17
C_x_PM_SDFFRS_X1%D_c4 VSS x_PM_SDFFRS_X1%D_9 1.57326e-16
C_x_PM_SDFFRS_X1%D_c5 VSS N_D_M31_g 3.86277e-17
C_x_PM_SDFFRS_X1%D_c6 VSS N_D_M1_g 4.33554e-17
R_x_PM_SDFFRS_X1%D_r7 x_PM_SDFFRS_X1%D_20 x_PM_SDFFRS_X1%D_24 2.86
R_x_PM_SDFFRS_X1%D_r8 x_PM_SDFFRS_X1%D_20 x_PM_SDFFRS_X1%D_18 25.0012
R_x_PM_SDFFRS_X1%D_r9 D x_PM_SDFFRS_X1%D_18 0.246296
R_x_PM_SDFFRS_X1%D_r10 x_PM_SDFFRS_X1%D_18 x_PM_SDFFRS_X1%D_16 0.0211111
R_x_PM_SDFFRS_X1%D_r11 x_PM_SDFFRS_X1%D_29 x_PM_SDFFRS_X1%D_14 4.7687
R_x_PM_SDFFRS_X1%D_r12 x_PM_SDFFRS_X1%D_14 x_PM_SDFFRS_X1%D_12 25.0012
R_x_PM_SDFFRS_X1%D_r13 x_PM_SDFFRS_X1%D_12 x_PM_SDFFRS_X1%D_11 1.235
R_x_PM_SDFFRS_X1%D_r14 x_PM_SDFFRS_X1%D_16 x_PM_SDFFRS_X1%D_10 0.095
R_x_PM_SDFFRS_X1%D_r15 x_PM_SDFFRS_X1%D_11 x_PM_SDFFRS_X1%D_9 0.212317
R_x_PM_SDFFRS_X1%D_r16 x_PM_SDFFRS_X1%D_10 x_PM_SDFFRS_X1%D_9 2.22571
R_x_PM_SDFFRS_X1%D_r17 N_D_M31_g x_PM_SDFFRS_X1%D_29 32.76
R_x_PM_SDFFRS_X1%D_r18 x_PM_SDFFRS_X1%D_24 x_PM_SDFFRS_X1%D_VSS 1.95
R_x_PM_SDFFRS_X1%D_r19 N_D_M1_g x_PM_SDFFRS_X1%D_VSS 35.88
C_x_PM_SDFFRS_X1%7_c0 VSS x_PM_SDFFRS_X1%7_34 2.68981e-17
C_x_PM_SDFFRS_X1%7_c1 VSS x_PM_SDFFRS_X1%7_27 1.90304e-17
C_x_PM_SDFFRS_X1%7_c2 VSS x_PM_SDFFRS_X1%7_23 1.34646e-16
C_x_PM_SDFFRS_X1%7_c3 VSS x_PM_SDFFRS_X1%7_22 1.00464e-16
C_x_PM_SDFFRS_X1%7_c4 VSS x_PM_SDFFRS_X1%7_20 1.90464e-17
C_x_PM_SDFFRS_X1%7_c5 VSS x_PM_SDFFRS_X1%7_19 7.64791e-17
C_x_PM_SDFFRS_X1%7_c6 VSS x_PM_SDFFRS_X1%7_15 9.09964e-17
C_x_PM_SDFFRS_X1%7_c7 VSS x_PM_SDFFRS_X1%7_12 5.87124e-18
C_x_PM_SDFFRS_X1%7_c8 VSS x_PM_SDFFRS_X1%7_11 1.36447e-17
C_x_PM_SDFFRS_X1%7_c9 VSS N_7_M8_g 5.16685e-17
C_x_PM_SDFFRS_X1%7_c10 VSS x_PM_SDFFRS_X1%7_5 3.23858e-17
C_x_PM_SDFFRS_X1%7_c11 VSS N_7_M34_g 6.38695e-17
R_x_PM_SDFFRS_X1%7_r12 x_PM_SDFFRS_X1%7_35 x_PM_SDFFRS_X1%7_34 0.624286
R_x_PM_SDFFRS_X1%7_r13 x_PM_SDFFRS_X1%7_37 x_PM_SDFFRS_X1%7_27 25.0012
R_x_PM_SDFFRS_X1%7_r14 x_PM_SDFFRS_X1%7_27 x_PM_SDFFRS_X1%7_25 0.149286
R_x_PM_SDFFRS_X1%7_r15 x_PM_SDFFRS_X1%7_34 x_PM_SDFFRS_X1%7_24 0.095
R_x_PM_SDFFRS_X1%7_r16 x_PM_SDFFRS_X1%7_25 x_PM_SDFFRS_X1%7_23 0.212317
R_x_PM_SDFFRS_X1%7_r17 x_PM_SDFFRS_X1%7_24 x_PM_SDFFRS_X1%7_23 3.61
R_x_PM_SDFFRS_X1%7_r18 x_PM_SDFFRS_X1%7_34 x_PM_SDFFRS_X1%7_22 0.19
R_x_PM_SDFFRS_X1%7_r19 x_PM_SDFFRS_X1%7_22 x_PM_SDFFRS_X1%7_21 2.06286
R_x_PM_SDFFRS_X1%7_r20 x_PM_SDFFRS_X1%7_20 N_7_M29_d 0.297071
R_x_PM_SDFFRS_X1%7_r21 x_PM_SDFFRS_X1%7_21 x_PM_SDFFRS_X1%7_19 0.212317
R_x_PM_SDFFRS_X1%7_r22 x_PM_SDFFRS_X1%7_20 x_PM_SDFFRS_X1%7_19 1.65571
R_x_PM_SDFFRS_X1%7_r23 x_PM_SDFFRS_X1%7_35 x_PM_SDFFRS_X1%7_15 0.095
R_x_PM_SDFFRS_X1%7_r24 N_7_M2_d x_PM_SDFFRS_X1%7_15 1.91357
R_x_PM_SDFFRS_X1%7_r25 x_PM_SDFFRS_X1%7_37 x_PM_SDFFRS_X1%7_11 9.1
R_x_PM_SDFFRS_X1%7_r26 x_PM_SDFFRS_X1%7_12 x_PM_SDFFRS_X1%7_11 2.32903
R_x_PM_SDFFRS_X1%7_r27 N_7_M8_g x_PM_SDFFRS_X1%7_7 51.48
R_x_PM_SDFFRS_X1%7_r28 x_PM_SDFFRS_X1%7_12 x_PM_SDFFRS_X1%7_6 2.32903
R_x_PM_SDFFRS_X1%7_r29 x_PM_SDFFRS_X1%7_7 x_PM_SDFFRS_X1%7_5 4.58872
R_x_PM_SDFFRS_X1%7_r30 x_PM_SDFFRS_X1%7_6 x_PM_SDFFRS_X1%7_5 16.12
R_x_PM_SDFFRS_X1%7_r31 x_PM_SDFFRS_X1%7_12 x_PM_SDFFRS_X1%7_VSS 1.81308
R_x_PM_SDFFRS_X1%7_r32 N_7_M34_g x_PM_SDFFRS_X1%7_VSS 65.52
C_x_PM_SDFFRS_X1%8_c0 VSS x_PM_SDFFRS_X1%8_69 7.43835e-18
C_x_PM_SDFFRS_X1%8_c1 VSS x_PM_SDFFRS_X1%8_62 4.91228e-17
C_x_PM_SDFFRS_X1%8_c2 VSS x_PM_SDFFRS_X1%8_58 5.43607e-17
C_x_PM_SDFFRS_X1%8_c3 VSS x_PM_SDFFRS_X1%8_57 5.82166e-17
C_x_PM_SDFFRS_X1%8_c4 VSS N_8_M32_s 5.01003e-17
C_x_PM_SDFFRS_X1%8_c5 VSS x_PM_SDFFRS_X1%8_52 2.72888e-17
C_x_PM_SDFFRS_X1%8_c6 VSS x_PM_SDFFRS_X1%8_51 6.64569e-17
C_x_PM_SDFFRS_X1%8_c7 VSS x_PM_SDFFRS_X1%8_49 1.07132e-17
C_x_PM_SDFFRS_X1%8_c8 VSS x_PM_SDFFRS_X1%8_47 5.60591e-17
C_x_PM_SDFFRS_X1%8_c9 VSS x_PM_SDFFRS_X1%8_43 3.25872e-17
C_x_PM_SDFFRS_X1%8_c10 VSS x_PM_SDFFRS_X1%8_36 1.64879e-17
C_x_PM_SDFFRS_X1%8_c11 VSS x_PM_SDFFRS_X1%8_35 6.58127e-18
C_x_PM_SDFFRS_X1%8_c12 VSS N_8_M43_g 7.5976e-17
C_x_PM_SDFFRS_X1%8_c13 VSS x_PM_SDFFRS_X1%8_30 7.35563e-18
C_x_PM_SDFFRS_X1%8_c14 VSS x_PM_SDFFRS_X1%8_29 2.70759e-17
C_x_PM_SDFFRS_X1%8_c15 VSS N_8_M15_g 5.18753e-17
C_x_PM_SDFFRS_X1%8_c16 VSS x_PM_SDFFRS_X1%8_24 6.34466e-18
C_x_PM_SDFFRS_X1%8_c17 VSS x_PM_SDFFRS_X1%8_23 1.33033e-16
C_x_PM_SDFFRS_X1%8_c18 VSS N_8_M11_g 2.731e-17
C_x_PM_SDFFRS_X1%8_c19 VSS N_8_M10_g 2.24207e-17
C_x_PM_SDFFRS_X1%8_c20 VSS N_8_M35_g 5.10972e-17
C_x_PM_SDFFRS_X1%8_c21 VSS x_PM_SDFFRS_X1%8_10 6.71974e-18
C_x_PM_SDFFRS_X1%8_c22 VSS x_PM_SDFFRS_X1%8_9 6.60411e-17
C_x_PM_SDFFRS_X1%8_c23 VSS N_8_M6_g 4.74415e-17
C_x_PM_SDFFRS_X1%8_c24 VSS N_8_M33_g 4.91389e-17
R_x_PM_SDFFRS_X1%8_r25 x_PM_SDFFRS_X1%8_71 x_PM_SDFFRS_X1%8_69 4.7687
R_x_PM_SDFFRS_X1%8_r26 x_PM_SDFFRS_X1%8_68 x_PM_SDFFRS_X1%8_65 25.0012
R_x_PM_SDFFRS_X1%8_r27 x_PM_SDFFRS_X1%8_65 x_PM_SDFFRS_X1%8_62 0.358889
R_x_PM_SDFFRS_X1%8_r28 N_8_M5_s x_PM_SDFFRS_X1%8_57 0.274444
R_x_PM_SDFFRS_X1%8_r29 x_PM_SDFFRS_X1%8_58 x_PM_SDFFRS_X1%8_57 0.186267
R_x_PM_SDFFRS_X1%8_r30 x_PM_SDFFRS_X1%8_62 x_PM_SDFFRS_X1%8_51 0.095
R_x_PM_SDFFRS_X1%8_r31 x_PM_SDFFRS_X1%8_52 x_PM_SDFFRS_X1%8_51 2.41571
R_x_PM_SDFFRS_X1%8_r32 x_PM_SDFFRS_X1%8_73 x_PM_SDFFRS_X1%8_49 4.7687
R_x_PM_SDFFRS_X1%8_r33 x_PM_SDFFRS_X1%8_49 x_PM_SDFFRS_X1%8_47 25.0012
R_x_PM_SDFFRS_X1%8_r34 x_PM_SDFFRS_X1%8_52 x_PM_SDFFRS_X1%8_46 0.212317
R_x_PM_SDFFRS_X1%8_r35 x_PM_SDFFRS_X1%8_47 x_PM_SDFFRS_X1%8_46 0.990714
R_x_PM_SDFFRS_X1%8_r36 x_PM_SDFFRS_X1%8_69 x_PM_SDFFRS_X1%8_43 25.0012
R_x_PM_SDFFRS_X1%8_r37 x_PM_SDFFRS_X1%8_57 x_PM_SDFFRS_X1%8_41 0.095
R_x_PM_SDFFRS_X1%8_r38 x_PM_SDFFRS_X1%8_43 x_PM_SDFFRS_X1%8_41 1.09929
R_x_PM_SDFFRS_X1%8_r39 x_PM_SDFFRS_X1%8_39 N_8_M32_s 0.29113
R_x_PM_SDFFRS_X1%8_r40 x_PM_SDFFRS_X1%8_58 x_PM_SDFFRS_X1%8_39 1.49286
R_x_PM_SDFFRS_X1%8_r41 x_PM_SDFFRS_X1%8_68 x_PM_SDFFRS_X1%8_36 7.54
R_x_PM_SDFFRS_X1%8_r42 x_PM_SDFFRS_X1%8_68 x_PM_SDFFRS_X1%8_35 7.02
R_x_PM_SDFFRS_X1%8_r43 N_8_M43_g x_PM_SDFFRS_X1%8_31 83.46
R_x_PM_SDFFRS_X1%8_r44 x_PM_SDFFRS_X1%8_31 x_PM_SDFFRS_X1%8_29 4.35808
R_x_PM_SDFFRS_X1%8_r45 x_PM_SDFFRS_X1%8_30 x_PM_SDFFRS_X1%8_29 21.84
R_x_PM_SDFFRS_X1%8_r46 N_8_M15_g x_PM_SDFFRS_X1%8_26 18.33
R_x_PM_SDFFRS_X1%8_r47 x_PM_SDFFRS_X1%8_30 x_PM_SDFFRS_X1%8_25 4.35808
R_x_PM_SDFFRS_X1%8_r48 N_8_M15_g x_PM_SDFFRS_X1%8_25 54.21
R_x_PM_SDFFRS_X1%8_r49 x_PM_SDFFRS_X1%8_26 x_PM_SDFFRS_X1%8_23 4.35808
R_x_PM_SDFFRS_X1%8_r50 x_PM_SDFFRS_X1%8_24 x_PM_SDFFRS_X1%8_23 166.14
R_x_PM_SDFFRS_X1%8_r51 x_PM_SDFFRS_X1%8_24 x_PM_SDFFRS_X1%8_20 4.35808
R_x_PM_SDFFRS_X1%8_r52 N_8_M11_g x_PM_SDFFRS_X1%8_20 26.52
R_x_PM_SDFFRS_X1%8_r53 x_PM_SDFFRS_X1%8_36 x_PM_SDFFRS_X1%8_19 4.58872
R_x_PM_SDFFRS_X1%8_r54 N_8_M11_g x_PM_SDFFRS_X1%8_19 21.06
R_x_PM_SDFFRS_X1%8_r55 x_PM_SDFFRS_X1%8_35 x_PM_SDFFRS_X1%8_15 4.58872
R_x_PM_SDFFRS_X1%8_r56 N_8_M10_g x_PM_SDFFRS_X1%8_15 21.06
R_x_PM_SDFFRS_X1%8_r57 N_8_M35_g x_PM_SDFFRS_X1%8_73 42.12
R_x_PM_SDFFRS_X1%8_r58 N_8_M35_g x_PM_SDFFRS_X1%8_11 35.1
R_x_PM_SDFFRS_X1%8_r59 x_PM_SDFFRS_X1%8_11 x_PM_SDFFRS_X1%8_9 4.35808
R_x_PM_SDFFRS_X1%8_r60 x_PM_SDFFRS_X1%8_10 x_PM_SDFFRS_X1%8_9 80.34
R_x_PM_SDFFRS_X1%8_r61 N_8_M6_g x_PM_SDFFRS_X1%8_71 53.04
R_x_PM_SDFFRS_X1%8_r62 x_PM_SDFFRS_X1%8_2 x_PM_SDFFRS_X1%8_69 4.7687
R_x_PM_SDFFRS_X1%8_r63 N_8_M33_g x_PM_SDFFRS_X1%8_2 51.48
R_x_PM_SDFFRS_X1%8_r64 x_PM_SDFFRS_X1%8_10 x_PM_SDFFRS_X1%8_VSS 4.35808
R_x_PM_SDFFRS_X1%8_r65 N_8_M33_g x_PM_SDFFRS_X1%8_VSS 21.84
C_x_PM_SDFFRS_X1%CK_c0 VSS x_PM_SDFFRS_X1%CK_13 9.36959e-18
C_x_PM_SDFFRS_X1%CK_c1 VSS CK 5.67314e-17
C_x_PM_SDFFRS_X1%CK_c2 VSS N_CK_M5_g 6.82044e-17
C_x_PM_SDFFRS_X1%CK_c3 VSS N_CK_M32_g 3.02305e-17
R_x_PM_SDFFRS_X1%CK_r4 x_PM_SDFFRS_X1%CK_16 x_PM_SDFFRS_X1%CK_13 4.74714
R_x_PM_SDFFRS_X1%CK_r5 x_PM_SDFFRS_X1%CK_15 x_PM_SDFFRS_X1%CK_13 4.74714
R_x_PM_SDFFRS_X1%CK_r6 x_PM_SDFFRS_X1%CK_13 x_PM_SDFFRS_X1%CK_11 25.0012
R_x_PM_SDFFRS_X1%CK_r7 x_PM_SDFFRS_X1%CK_11 CK 0.26074
R_x_PM_SDFFRS_X1%CK_r8 N_CK_M5_g x_PM_SDFFRS_X1%CK_16 61.62
R_x_PM_SDFFRS_X1%CK_r9 N_CK_M32_g x_PM_SDFFRS_X1%CK_15 21.84
C_x_PM_SDFFRS_X1%10_c0 VSS x_PM_SDFFRS_X1%10_66 1.02598e-17
C_x_PM_SDFFRS_X1%10_c1 VSS x_PM_SDFFRS_X1%10_59 1.56374e-17
C_x_PM_SDFFRS_X1%10_c2 VSS x_PM_SDFFRS_X1%10_58 9.81345e-18
C_x_PM_SDFFRS_X1%10_c3 VSS x_PM_SDFFRS_X1%10_56 5.00553e-18
C_x_PM_SDFFRS_X1%10_c4 VSS x_PM_SDFFRS_X1%10_55 5.53482e-17
C_x_PM_SDFFRS_X1%10_c5 VSS x_PM_SDFFRS_X1%10_53 7.37677e-17
C_x_PM_SDFFRS_X1%10_c6 VSS x_PM_SDFFRS_X1%10_49 2.73113e-16
C_x_PM_SDFFRS_X1%10_c7 VSS x_PM_SDFFRS_X1%10_46 2.81746e-17
C_x_PM_SDFFRS_X1%10_c8 VSS x_PM_SDFFRS_X1%10_43 8.46248e-18
C_x_PM_SDFFRS_X1%10_c9 VSS x_PM_SDFFRS_X1%10_42 3.58777e-16
C_x_PM_SDFFRS_X1%10_c10 VSS x_PM_SDFFRS_X1%10_41 3.64741e-18
C_x_PM_SDFFRS_X1%10_c11 VSS x_PM_SDFFRS_X1%10_39 8.54843e-18
C_x_PM_SDFFRS_X1%10_c12 VSS x_PM_SDFFRS_X1%10_35 7.68397e-17
C_x_PM_SDFFRS_X1%10_c13 VSS x_PM_SDFFRS_X1%10_34 1.19301e-16
C_x_PM_SDFFRS_X1%10_c14 VSS x_PM_SDFFRS_X1%10_32 9.3858e-18
C_x_PM_SDFFRS_X1%10_c15 VSS x_PM_SDFFRS_X1%10_31 3.11734e-17
C_x_PM_SDFFRS_X1%10_c16 VSS x_PM_SDFFRS_X1%10_30 3.65142e-17
C_x_PM_SDFFRS_X1%10_c17 VSS x_PM_SDFFRS_X1%10_25 8.86753e-17
C_x_PM_SDFFRS_X1%10_c18 VSS N_10_M19_g 2.55402e-17
C_x_PM_SDFFRS_X1%10_c19 VSS x_PM_SDFFRS_X1%10_19 4.81551e-18
C_x_PM_SDFFRS_X1%10_c20 VSS x_PM_SDFFRS_X1%10_18 7.52807e-18
C_x_PM_SDFFRS_X1%10_c21 VSS x_PM_SDFFRS_X1%10_17 1.26365e-17
C_x_PM_SDFFRS_X1%10_c22 VSS N_10_M18_g 2.57553e-17
C_x_PM_SDFFRS_X1%10_c23 VSS N_10_M42_g 2.54598e-17
C_x_PM_SDFFRS_X1%10_c24 VSS N_10_M36_g 2.08941e-17
C_x_PM_SDFFRS_X1%10_c25 VSS N_10_M7_g 2.78824e-17
R_x_PM_SDFFRS_X1%10_r26 x_PM_SDFFRS_X1%10_62 x_PM_SDFFRS_X1%10_58 4.7687
R_x_PM_SDFFRS_X1%10_r27 x_PM_SDFFRS_X1%10_58 x_PM_SDFFRS_X1%10_57 25.0012
R_x_PM_SDFFRS_X1%10_r28 x_PM_SDFFRS_X1%10_55 x_PM_SDFFRS_X1%10_54 1.65571
R_x_PM_SDFFRS_X1%10_r29 x_PM_SDFFRS_X1%10_55 x_PM_SDFFRS_X1%10_53 0.212317
R_x_PM_SDFFRS_X1%10_r30 x_PM_SDFFRS_X1%10_53 x_PM_SDFFRS_X1%10_51 0.543196
R_x_PM_SDFFRS_X1%10_r31 x_PM_SDFFRS_X1%10_52 x_PM_SDFFRS_X1%10_51 25.0012
R_x_PM_SDFFRS_X1%10_r32 x_PM_SDFFRS_X1%10_59 x_PM_SDFFRS_X1%10_50 0.160909
R_x_PM_SDFFRS_X1%10_r33 x_PM_SDFFRS_X1%10_54 x_PM_SDFFRS_X1%10_49 0.212317
R_x_PM_SDFFRS_X1%10_r34 x_PM_SDFFRS_X1%10_50 x_PM_SDFFRS_X1%10_49 5.13
R_x_PM_SDFFRS_X1%10_r35 x_PM_SDFFRS_X1%10_66 x_PM_SDFFRS_X1%10_46 25.0012
R_x_PM_SDFFRS_X1%10_r36 x_PM_SDFFRS_X1%10_59 x_PM_SDFFRS_X1%10_44 0.0418175
R_x_PM_SDFFRS_X1%10_r37 x_PM_SDFFRS_X1%10_46 x_PM_SDFFRS_X1%10_44 0.583571
R_x_PM_SDFFRS_X1%10_r38 x_PM_SDFFRS_X1%10_59 x_PM_SDFFRS_X1%10_42 0.160909
R_x_PM_SDFFRS_X1%10_r39 x_PM_SDFFRS_X1%10_43 x_PM_SDFFRS_X1%10_42 7.35571
R_x_PM_SDFFRS_X1%10_r40 x_PM_SDFFRS_X1%10_43 x_PM_SDFFRS_X1%10_41 0.212317
R_x_PM_SDFFRS_X1%10_r41 x_PM_SDFFRS_X1%10_41 x_PM_SDFFRS_X1%10_40 0.298571
R_x_PM_SDFFRS_X1%10_r42 x_PM_SDFFRS_X1%10_64 x_PM_SDFFRS_X1%10_39 4.7687
R_x_PM_SDFFRS_X1%10_r43 x_PM_SDFFRS_X1%10_39 x_PM_SDFFRS_X1%10_37 25.0012
R_x_PM_SDFFRS_X1%10_r44 x_PM_SDFFRS_X1%10_56 x_PM_SDFFRS_X1%10_36 0.160909
R_x_PM_SDFFRS_X1%10_r45 x_PM_SDFFRS_X1%10_37 x_PM_SDFFRS_X1%10_36 2.13071
R_x_PM_SDFFRS_X1%10_r46 x_PM_SDFFRS_X1%10_40 x_PM_SDFFRS_X1%10_35 0.212317
R_x_PM_SDFFRS_X1%10_r47 x_PM_SDFFRS_X1%10_37 x_PM_SDFFRS_X1%10_35 0.0678571
R_x_PM_SDFFRS_X1%10_r48 x_PM_SDFFRS_X1%10_57 x_PM_SDFFRS_X1%10_34 0.04004
R_x_PM_SDFFRS_X1%10_r49 x_PM_SDFFRS_X1%10_56 x_PM_SDFFRS_X1%10_33 0.0418175
R_x_PM_SDFFRS_X1%10_r50 x_PM_SDFFRS_X1%10_34 x_PM_SDFFRS_X1%10_33 2.49714
R_x_PM_SDFFRS_X1%10_r51 x_PM_SDFFRS_X1%10_56 x_PM_SDFFRS_X1%10_31 0.160909
R_x_PM_SDFFRS_X1%10_r52 x_PM_SDFFRS_X1%10_32 x_PM_SDFFRS_X1%10_31 1.27571
R_x_PM_SDFFRS_X1%10_r53 x_PM_SDFFRS_X1%10_32 x_PM_SDFFRS_X1%10_30 0.212317
R_x_PM_SDFFRS_X1%10_r54 x_PM_SDFFRS_X1%10_30 N_10_M33_d 0.570339
R_x_PM_SDFFRS_X1%10_r55 x_PM_SDFFRS_X1%10_57 x_PM_SDFFRS_X1%10_25 0.173507
R_x_PM_SDFFRS_X1%10_r56 N_10_M6_d x_PM_SDFFRS_X1%10_25 1.24688
R_x_PM_SDFFRS_X1%10_r57 x_PM_SDFFRS_X1%10_52 x_PM_SDFFRS_X1%10_19 3.67098
R_x_PM_SDFFRS_X1%10_r58 N_10_M19_g x_PM_SDFFRS_X1%10_19 27.3
R_x_PM_SDFFRS_X1%10_r59 x_PM_SDFFRS_X1%10_52 x_PM_SDFFRS_X1%10_17 0.917744
R_x_PM_SDFFRS_X1%10_r60 x_PM_SDFFRS_X1%10_18 x_PM_SDFFRS_X1%10_17 14.56
R_x_PM_SDFFRS_X1%10_r61 x_PM_SDFFRS_X1%10_18 x_PM_SDFFRS_X1%10_13 4.58872
R_x_PM_SDFFRS_X1%10_r62 N_10_M18_g x_PM_SDFFRS_X1%10_13 27.3
R_x_PM_SDFFRS_X1%10_r63 x_PM_SDFFRS_X1%10_9 x_PM_SDFFRS_X1%10_66 4.7687
R_x_PM_SDFFRS_X1%10_r64 N_10_M42_g x_PM_SDFFRS_X1%10_9 21.84
R_x_PM_SDFFRS_X1%10_r65 N_10_M36_g x_PM_SDFFRS_X1%10_64 15.6
R_x_PM_SDFFRS_X1%10_r66 N_10_M7_g x_PM_SDFFRS_X1%10_62 21.84
C_x_PM_SDFFRS_X1%11_c0 VSS x_PM_SDFFRS_X1%11_71 1.38389e-17
C_x_PM_SDFFRS_X1%11_c1 VSS x_PM_SDFFRS_X1%11_66 9.52226e-18
C_x_PM_SDFFRS_X1%11_c2 VSS x_PM_SDFFRS_X1%11_59 1.85341e-17
C_x_PM_SDFFRS_X1%11_c3 VSS x_PM_SDFFRS_X1%11_53 1.07853e-16
C_x_PM_SDFFRS_X1%11_c4 VSS x_PM_SDFFRS_X1%11_49 9.35871e-18
C_x_PM_SDFFRS_X1%11_c5 VSS x_PM_SDFFRS_X1%11_46 2.30705e-17
C_x_PM_SDFFRS_X1%11_c6 VSS x_PM_SDFFRS_X1%11_45 2.50891e-16
C_x_PM_SDFFRS_X1%11_c7 VSS x_PM_SDFFRS_X1%11_44 2.26655e-17
C_x_PM_SDFFRS_X1%11_c8 VSS x_PM_SDFFRS_X1%11_40 1.86187e-17
C_x_PM_SDFFRS_X1%11_c9 VSS x_PM_SDFFRS_X1%11_39 7.27073e-17
C_x_PM_SDFFRS_X1%11_c10 VSS x_PM_SDFFRS_X1%11_38 2.46391e-18
C_x_PM_SDFFRS_X1%11_c11 VSS x_PM_SDFFRS_X1%11_31 7.48889e-17
C_x_PM_SDFFRS_X1%11_c12 VSS x_PM_SDFFRS_X1%11_29 2.55361e-17
C_x_PM_SDFFRS_X1%11_c13 VSS x_PM_SDFFRS_X1%11_28 7.14648e-17
C_x_PM_SDFFRS_X1%11_c14 VSS x_PM_SDFFRS_X1%11_27 4.77695e-18
C_x_PM_SDFFRS_X1%11_c15 VSS x_PM_SDFFRS_X1%11_22 7.88712e-17
C_x_PM_SDFFRS_X1%11_c16 VSS N_11_M16_g 3.61413e-17
C_x_PM_SDFFRS_X1%11_c17 VSS N_11_M41_g 7.00958e-17
C_x_PM_SDFFRS_X1%11_c18 VSS N_11_M39_g 7.86727e-17
C_x_PM_SDFFRS_X1%11_c19 VSS N_11_M13_g 3.93089e-17
C_x_PM_SDFFRS_X1%11_c20 VSS x_PM_SDFFRS_X1%11_VSS 1.07404e-16
R_x_PM_SDFFRS_X1%11_r21 x_PM_SDFFRS_X1%11_61 x_PM_SDFFRS_X1%11_59 6.5
R_x_PM_SDFFRS_X1%11_r22 x_PM_SDFFRS_X1%11_71 x_PM_SDFFRS_X1%11_57 2.86
R_x_PM_SDFFRS_X1%11_r23 x_PM_SDFFRS_X1%11_57 x_PM_SDFFRS_X1%11_55 25.0012
R_x_PM_SDFFRS_X1%11_r24 x_PM_SDFFRS_X1%11_55 x_PM_SDFFRS_X1%11_53 0.302593
R_x_PM_SDFFRS_X1%11_r25 x_PM_SDFFRS_X1%11_66 x_PM_SDFFRS_X1%11_51 25.0012
R_x_PM_SDFFRS_X1%11_r26 x_PM_SDFFRS_X1%11_65 x_PM_SDFFRS_X1%11_49 4.7687
R_x_PM_SDFFRS_X1%11_r27 x_PM_SDFFRS_X1%11_64 x_PM_SDFFRS_X1%11_49 4.7687
R_x_PM_SDFFRS_X1%11_r28 x_PM_SDFFRS_X1%11_49 x_PM_SDFFRS_X1%11_47 25.0012
R_x_PM_SDFFRS_X1%11_r29 x_PM_SDFFRS_X1%11_51 x_PM_SDFFRS_X1%11_47 2.82286
R_x_PM_SDFFRS_X1%11_r30 x_PM_SDFFRS_X1%11_47 x_PM_SDFFRS_X1%11_46 1.31643
R_x_PM_SDFFRS_X1%11_r31 x_PM_SDFFRS_X1%11_53 x_PM_SDFFRS_X1%11_45 0.095
R_x_PM_SDFFRS_X1%11_r32 x_PM_SDFFRS_X1%11_51 x_PM_SDFFRS_X1%11_45 1.615
R_x_PM_SDFFRS_X1%11_r33 x_PM_SDFFRS_X1%11_46 x_PM_SDFFRS_X1%11_43 0.212317
R_x_PM_SDFFRS_X1%11_r34 x_PM_SDFFRS_X1%11_44 x_PM_SDFFRS_X1%11_43 1.14
R_x_PM_SDFFRS_X1%11_r35 N_11_M10_d x_PM_SDFFRS_X1%11_40 1.01786
R_x_PM_SDFFRS_X1%11_r36 x_PM_SDFFRS_X1%11_44 x_PM_SDFFRS_X1%11_39 0.212317
R_x_PM_SDFFRS_X1%11_r37 N_11_M10_d x_PM_SDFFRS_X1%11_39 0.963571
R_x_PM_SDFFRS_X1%11_r38 x_PM_SDFFRS_X1%11_40 x_PM_SDFFRS_X1%11_38 0.212317
R_x_PM_SDFFRS_X1%11_r39 x_PM_SDFFRS_X1%11_38 x_PM_SDFFRS_X1%11_37 0.325714
R_x_PM_SDFFRS_X1%11_r40 N_11_M35_d x_PM_SDFFRS_X1%11_31 0.394074
R_x_PM_SDFFRS_X1%11_r41 x_PM_SDFFRS_X1%11_61 x_PM_SDFFRS_X1%11_31 25.0012
R_x_PM_SDFFRS_X1%11_r42 x_PM_SDFFRS_X1%11_37 x_PM_SDFFRS_X1%11_28 0.212317
R_x_PM_SDFFRS_X1%11_r43 x_PM_SDFFRS_X1%11_29 x_PM_SDFFRS_X1%11_28 1.49286
R_x_PM_SDFFRS_X1%11_r44 x_PM_SDFFRS_X1%11_29 x_PM_SDFFRS_X1%11_26 0.212317
R_x_PM_SDFFRS_X1%11_r45 x_PM_SDFFRS_X1%11_27 x_PM_SDFFRS_X1%11_26 0.325714
R_x_PM_SDFFRS_X1%11_r46 x_PM_SDFFRS_X1%11_27 x_PM_SDFFRS_X1%11_22 0.212317
R_x_PM_SDFFRS_X1%11_r47 N_11_M7_s x_PM_SDFFRS_X1%11_22 1.09929
R_x_PM_SDFFRS_X1%11_r48 x_PM_SDFFRS_X1%11_71 x_PM_SDFFRS_X1%11_15 1.95
R_x_PM_SDFFRS_X1%11_r49 N_11_M16_g x_PM_SDFFRS_X1%11_15 30.81
R_x_PM_SDFFRS_X1%11_r50 x_PM_SDFFRS_X1%11_11 x_PM_SDFFRS_X1%11_66 4.7687
R_x_PM_SDFFRS_X1%11_r51 N_11_M41_g x_PM_SDFFRS_X1%11_11 85.8
R_x_PM_SDFFRS_X1%11_r52 N_11_M39_g x_PM_SDFFRS_X1%11_64 85.8
R_x_PM_SDFFRS_X1%11_r53 N_11_M39_g x_PM_SDFFRS_X1%11_7 17.94
R_x_PM_SDFFRS_X1%11_r54 N_11_M13_g x_PM_SDFFRS_X1%11_65 39.78
R_x_PM_SDFFRS_X1%11_r55 x_PM_SDFFRS_X1%11_59 x_PM_SDFFRS_X1%11_2 1.95
R_x_PM_SDFFRS_X1%11_r56 x_PM_SDFFRS_X1%11_7 x_PM_SDFFRS_X1%11_VSS 4.35808
R_x_PM_SDFFRS_X1%11_r57 x_PM_SDFFRS_X1%11_2 x_PM_SDFFRS_X1%11_VSS 131.04
C_x_PM_SDFFRS_X1%12_c0 VSS x_PM_SDFFRS_X1%12_41 1.09756e-17
C_x_PM_SDFFRS_X1%12_c1 VSS x_PM_SDFFRS_X1%12_35 4.86392e-17
C_x_PM_SDFFRS_X1%12_c2 VSS x_PM_SDFFRS_X1%12_32 1.0864e-17
C_x_PM_SDFFRS_X1%12_c3 VSS x_PM_SDFFRS_X1%12_30 8.18377e-17
C_x_PM_SDFFRS_X1%12_c4 VSS N_12_M13_d 1.79544e-17
C_x_PM_SDFFRS_X1%12_c5 VSS x_PM_SDFFRS_X1%12_24 4.12682e-17
C_x_PM_SDFFRS_X1%12_c6 VSS x_PM_SDFFRS_X1%12_21 3.692e-18
C_x_PM_SDFFRS_X1%12_c7 VSS x_PM_SDFFRS_X1%12_18 1.31022e-16
C_x_PM_SDFFRS_X1%12_c8 VSS x_PM_SDFFRS_X1%12_15 3.47252e-17
C_x_PM_SDFFRS_X1%12_c9 VSS x_PM_SDFFRS_X1%12_12 5.78954e-17
C_x_PM_SDFFRS_X1%12_c10 VSS N_12_M37_g 2.09137e-17
C_x_PM_SDFFRS_X1%12_c11 VSS x_PM_SDFFRS_X1%12_6 4.55149e-18
C_x_PM_SDFFRS_X1%12_c12 VSS x_PM_SDFFRS_X1%12_5 2.65205e-17
C_x_PM_SDFFRS_X1%12_c13 VSS N_12_M9_g 5.01079e-17
R_x_PM_SDFFRS_X1%12_r14 x_PM_SDFFRS_X1%12_38 x_PM_SDFFRS_X1%12_35 0.302593
R_x_PM_SDFFRS_X1%12_r15 x_PM_SDFFRS_X1%12_41 x_PM_SDFFRS_X1%12_35 25.0012
R_x_PM_SDFFRS_X1%12_r16 x_PM_SDFFRS_X1%12_46 x_PM_SDFFRS_X1%12_32 4.7687
R_x_PM_SDFFRS_X1%12_r17 x_PM_SDFFRS_X1%12_32 x_PM_SDFFRS_X1%12_30 25.0012
R_x_PM_SDFFRS_X1%12_r18 x_PM_SDFFRS_X1%12_30 x_PM_SDFFRS_X1%12_29 1.24857
R_x_PM_SDFFRS_X1%12_r19 x_PM_SDFFRS_X1%12_38 x_PM_SDFFRS_X1%12_25 0.095
R_x_PM_SDFFRS_X1%12_r20 N_12_M13_d x_PM_SDFFRS_X1%12_25 0.312143
R_x_PM_SDFFRS_X1%12_r21 x_PM_SDFFRS_X1%12_29 x_PM_SDFFRS_X1%12_24 0.095
R_x_PM_SDFFRS_X1%12_r22 x_PM_SDFFRS_X1%12_21 x_PM_SDFFRS_X1%12_19 25.0012
R_x_PM_SDFFRS_X1%12_r23 x_PM_SDFFRS_X1%12_29 x_PM_SDFFRS_X1%12_18 0.366429
R_x_PM_SDFFRS_X1%12_r24 x_PM_SDFFRS_X1%12_19 x_PM_SDFFRS_X1%12_18 2.185
R_x_PM_SDFFRS_X1%12_r25 x_PM_SDFFRS_X1%12_24 N_12_M39_s 0.333213
R_x_PM_SDFFRS_X1%12_r26 x_PM_SDFFRS_X1%12_21 x_PM_SDFFRS_X1%12_15 29.9
R_x_PM_SDFFRS_X1%12_r27 x_PM_SDFFRS_X1%12_14 x_PM_SDFFRS_X1%12_21 4.7687
R_x_PM_SDFFRS_X1%12_r28 x_PM_SDFFRS_X1%12_12 x_PM_SDFFRS_X1%12_41 4.7687
R_x_PM_SDFFRS_X1%12_r29 x_PM_SDFFRS_X1%12_12 x_PM_SDFFRS_X1%12_46 71.76
R_x_PM_SDFFRS_X1%12_r30 N_12_M37_g x_PM_SDFFRS_X1%12_14 14.82
R_x_PM_SDFFRS_X1%12_r31 x_PM_SDFFRS_X1%12_15 x_PM_SDFFRS_X1%12_5 4.58872
R_x_PM_SDFFRS_X1%12_r32 x_PM_SDFFRS_X1%12_6 x_PM_SDFFRS_X1%12_5 24.96
R_x_PM_SDFFRS_X1%12_r33 x_PM_SDFFRS_X1%12_6 x_PM_SDFFRS_X1%12_VSS 4.35808
R_x_PM_SDFFRS_X1%12_r34 N_12_M9_g x_PM_SDFFRS_X1%12_VSS 55.38
C_x_PM_SDFFRS_X1%SN_c0 VSS x_PM_SDFFRS_X1%SN_31 9.53708e-18
C_x_PM_SDFFRS_X1%SN_c1 VSS x_PM_SDFFRS_X1%SN_29 9.74629e-17
C_x_PM_SDFFRS_X1%SN_c2 VSS x_PM_SDFFRS_X1%SN_28 5.42035e-16
C_x_PM_SDFFRS_X1%SN_c3 VSS N_SN_M21_g 4.89542e-17
C_x_PM_SDFFRS_X1%SN_c4 VSS x_PM_SDFFRS_X1%SN_15 4.69072e-17
C_x_PM_SDFFRS_X1%SN_c5 VSS N_SN_M46_g 5.76813e-17
C_x_PM_SDFFRS_X1%SN_c6 VSS N_SN_M12_g 5.33473e-17
C_x_PM_SDFFRS_X1%SN_c7 VSS x_PM_SDFFRS_X1%SN_7 4.88015e-18
C_x_PM_SDFFRS_X1%SN_c8 VSS x_PM_SDFFRS_X1%SN_6 6.98108e-18
C_x_PM_SDFFRS_X1%SN_c9 VSS x_PM_SDFFRS_X1%SN_5 1.46091e-17
C_x_PM_SDFFRS_X1%SN_c10 VSS N_SN_M38_g 5.54103e-17
R_x_PM_SDFFRS_X1%SN_r11 x_PM_SDFFRS_X1%SN_35 x_PM_SDFFRS_X1%SN_31 3.38
R_x_PM_SDFFRS_X1%SN_r12 x_PM_SDFFRS_X1%SN_34 x_PM_SDFFRS_X1%SN_31 4.7687
R_x_PM_SDFFRS_X1%SN_r13 x_PM_SDFFRS_X1%SN_31 x_PM_SDFFRS_X1%SN_29 25.0012
R_x_PM_SDFFRS_X1%SN_r14 x_PM_SDFFRS_X1%SN_29 SN 0.288519
R_x_PM_SDFFRS_X1%SN_r15 x_PM_SDFFRS_X1%SN_28 SN 0.284786
R_x_PM_SDFFRS_X1%SN_r16 x_PM_SDFFRS_X1%SN_24 x_PM_SDFFRS_X1%SN_22 25.0012
R_x_PM_SDFFRS_X1%SN_r17 x_PM_SDFFRS_X1%SN_22 x_PM_SDFFRS_X1%SN_28 8.86214
R_x_PM_SDFFRS_X1%SN_r18 N_SN_M21_g x_PM_SDFFRS_X1%SN_17 38.22
R_x_PM_SDFFRS_X1%SN_r19 x_PM_SDFFRS_X1%SN_35 x_PM_SDFFRS_X1%SN_16 1.95
R_x_PM_SDFFRS_X1%SN_r20 x_PM_SDFFRS_X1%SN_17 x_PM_SDFFRS_X1%SN_15 4.35808
R_x_PM_SDFFRS_X1%SN_r21 x_PM_SDFFRS_X1%SN_16 x_PM_SDFFRS_X1%SN_15 48.36
R_x_PM_SDFFRS_X1%SN_r22 N_SN_M46_g x_PM_SDFFRS_X1%SN_34 56.16
R_x_PM_SDFFRS_X1%SN_r23 x_PM_SDFFRS_X1%SN_24 x_PM_SDFFRS_X1%SN_7 3.67098
R_x_PM_SDFFRS_X1%SN_r24 N_SN_M12_g x_PM_SDFFRS_X1%SN_7 39
R_x_PM_SDFFRS_X1%SN_r25 x_PM_SDFFRS_X1%SN_24 x_PM_SDFFRS_X1%SN_5 0.917744
R_x_PM_SDFFRS_X1%SN_r26 x_PM_SDFFRS_X1%SN_6 x_PM_SDFFRS_X1%SN_5 12.48
R_x_PM_SDFFRS_X1%SN_r27 x_PM_SDFFRS_X1%SN_6 x_PM_SDFFRS_X1%SN_VSS 4.58872
R_x_PM_SDFFRS_X1%SN_r28 N_SN_M38_g x_PM_SDFFRS_X1%SN_VSS 56.94
C_x_PM_SDFFRS_X1%14_c0 VSS x_PM_SDFFRS_X1%14_60 3.91623e-18
C_x_PM_SDFFRS_X1%14_c1 VSS x_PM_SDFFRS_X1%14_55 7.8258e-17
C_x_PM_SDFFRS_X1%14_c2 VSS x_PM_SDFFRS_X1%14_50 3.37558e-17
C_x_PM_SDFFRS_X1%14_c3 VSS x_PM_SDFFRS_X1%14_49 1.38554e-17
C_x_PM_SDFFRS_X1%14_c4 VSS N_14_M42_d 2.51949e-17
C_x_PM_SDFFRS_X1%14_c5 VSS x_PM_SDFFRS_X1%14_42 6.75511e-17
C_x_PM_SDFFRS_X1%14_c6 VSS x_PM_SDFFRS_X1%14_40 1.60559e-17
C_x_PM_SDFFRS_X1%14_c7 VSS x_PM_SDFFRS_X1%14_39 3.48291e-17
C_x_PM_SDFFRS_X1%14_c8 VSS x_PM_SDFFRS_X1%14_36 9.67575e-17
C_x_PM_SDFFRS_X1%14_c9 VSS x_PM_SDFFRS_X1%14_34 3.3993e-17
C_x_PM_SDFFRS_X1%14_c10 VSS x_PM_SDFFRS_X1%14_30 5.6193e-17
C_x_PM_SDFFRS_X1%14_c11 VSS x_PM_SDFFRS_X1%14_26 5.59412e-17
C_x_PM_SDFFRS_X1%14_c12 VSS x_PM_SDFFRS_X1%14_24 3.28756e-17
C_x_PM_SDFFRS_X1%14_c13 VSS x_PM_SDFFRS_X1%14_23 1.30438e-17
C_x_PM_SDFFRS_X1%14_c14 VSS x_PM_SDFFRS_X1%14_21 1.063e-17
C_x_PM_SDFFRS_X1%14_c15 VSS x_PM_SDFFRS_X1%14_20 6.69969e-17
C_x_PM_SDFFRS_X1%14_c16 VSS N_14_M15_s 2.83004e-17
C_x_PM_SDFFRS_X1%14_c17 VSS N_14_M22_g 4.25176e-17
C_x_PM_SDFFRS_X1%14_c18 VSS x_PM_SDFFRS_X1%14_8 1.48696e-17
C_x_PM_SDFFRS_X1%14_c19 VSS x_PM_SDFFRS_X1%14_6 7.05692e-18
C_x_PM_SDFFRS_X1%14_c20 VSS x_PM_SDFFRS_X1%14_5 4.13082e-17
C_x_PM_SDFFRS_X1%14_c21 VSS N_14_M47_g 4.04054e-17
R_x_PM_SDFFRS_X1%14_r22 N_14_M18_d x_PM_SDFFRS_X1%14_50 0.204074
R_x_PM_SDFFRS_X1%14_r23 x_PM_SDFFRS_X1%14_42 x_PM_SDFFRS_X1%14_40 1.26214
R_x_PM_SDFFRS_X1%14_r24 x_PM_SDFFRS_X1%14_40 x_PM_SDFFRS_X1%14_38 0.212317
R_x_PM_SDFFRS_X1%14_r25 x_PM_SDFFRS_X1%14_39 x_PM_SDFFRS_X1%14_38 1.11286
R_x_PM_SDFFRS_X1%14_r26 x_PM_SDFFRS_X1%14_50 x_PM_SDFFRS_X1%14_37 0.095
R_x_PM_SDFFRS_X1%14_r27 x_PM_SDFFRS_X1%14_39 x_PM_SDFFRS_X1%14_36 0.212317
R_x_PM_SDFFRS_X1%14_r28 x_PM_SDFFRS_X1%14_37 x_PM_SDFFRS_X1%14_36 1.68286
R_x_PM_SDFFRS_X1%14_r29 x_PM_SDFFRS_X1%14_49 x_PM_SDFFRS_X1%14_35 0.160909
R_x_PM_SDFFRS_X1%14_r30 x_PM_SDFFRS_X1%14_50 x_PM_SDFFRS_X1%14_34 0.095
R_x_PM_SDFFRS_X1%14_r31 x_PM_SDFFRS_X1%14_35 x_PM_SDFFRS_X1%14_34 1.73714
R_x_PM_SDFFRS_X1%14_r32 x_PM_SDFFRS_X1%14_32 x_PM_SDFFRS_X1%14_55 45.24
R_x_PM_SDFFRS_X1%14_r33 x_PM_SDFFRS_X1%14_32 x_PM_SDFFRS_X1%14_30 25.0012
R_x_PM_SDFFRS_X1%14_r34 x_PM_SDFFRS_X1%14_49 x_PM_SDFFRS_X1%14_29 0.0418175
R_x_PM_SDFFRS_X1%14_r35 x_PM_SDFFRS_X1%14_30 x_PM_SDFFRS_X1%14_29 0.936429
R_x_PM_SDFFRS_X1%14_r36 x_PM_SDFFRS_X1%14_55 x_PM_SDFFRS_X1%14_26 25.0012
R_x_PM_SDFFRS_X1%14_r37 x_PM_SDFFRS_X1%14_26 x_PM_SDFFRS_X1%14_24 0.936429
R_x_PM_SDFFRS_X1%14_r38 x_PM_SDFFRS_X1%14_24 x_PM_SDFFRS_X1%14_23 0.212317
R_x_PM_SDFFRS_X1%14_r39 x_PM_SDFFRS_X1%14_22 N_14_M42_d 0.30478
R_x_PM_SDFFRS_X1%14_r40 x_PM_SDFFRS_X1%14_23 x_PM_SDFFRS_X1%14_22 0.488571
R_x_PM_SDFFRS_X1%14_r41 x_PM_SDFFRS_X1%14_49 x_PM_SDFFRS_X1%14_20 0.160909
R_x_PM_SDFFRS_X1%14_r42 x_PM_SDFFRS_X1%14_21 x_PM_SDFFRS_X1%14_20 1.9
R_x_PM_SDFFRS_X1%14_r43 x_PM_SDFFRS_X1%14_21 x_PM_SDFFRS_X1%14_16 0.212317
R_x_PM_SDFFRS_X1%14_r44 N_14_M15_s x_PM_SDFFRS_X1%14_16 0.203571
R_x_PM_SDFFRS_X1%14_r45 N_14_M22_g x_PM_SDFFRS_X1%14_60 45.24
R_x_PM_SDFFRS_X1%14_r46 x_PM_SDFFRS_X1%14_8 x_PM_SDFFRS_X1%14_42 25.0012
R_x_PM_SDFFRS_X1%14_r47 x_PM_SDFFRS_X1%14_60 x_PM_SDFFRS_X1%14_8 4.7687
R_x_PM_SDFFRS_X1%14_r48 x_PM_SDFFRS_X1%14_8 x_PM_SDFFRS_X1%14_7 16.38
R_x_PM_SDFFRS_X1%14_r49 x_PM_SDFFRS_X1%14_7 x_PM_SDFFRS_X1%14_5 4.58872
R_x_PM_SDFFRS_X1%14_r50 x_PM_SDFFRS_X1%14_6 x_PM_SDFFRS_X1%14_5 50.7
R_x_PM_SDFFRS_X1%14_r51 x_PM_SDFFRS_X1%14_6 x_PM_SDFFRS_X1%14_VSS 4.35808
R_x_PM_SDFFRS_X1%14_r52 N_14_M47_g x_PM_SDFFRS_X1%14_VSS 35.88
C_x_PM_SDFFRS_X1%15_c0 VSS x_PM_SDFFRS_X1%15_45 1.46409e-17
C_x_PM_SDFFRS_X1%15_c1 VSS x_PM_SDFFRS_X1%15_43 1.54591e-16
C_x_PM_SDFFRS_X1%15_c2 VSS x_PM_SDFFRS_X1%15_36 1.01944e-16
C_x_PM_SDFFRS_X1%15_c3 VSS x_PM_SDFFRS_X1%15_34 9.55081e-17
C_x_PM_SDFFRS_X1%15_c4 VSS x_PM_SDFFRS_X1%15_32 1.27386e-17
C_x_PM_SDFFRS_X1%15_c5 VSS x_PM_SDFFRS_X1%15_29 1.05369e-16
C_x_PM_SDFFRS_X1%15_c6 VSS N_15_M50_g 6.79761e-17
C_x_PM_SDFFRS_X1%15_c7 VSS x_PM_SDFFRS_X1%15_20 5.14899e-18
C_x_PM_SDFFRS_X1%15_c8 VSS x_PM_SDFFRS_X1%15_19 1.95813e-17
C_x_PM_SDFFRS_X1%15_c9 VSS N_15_M24_g 2.10559e-17
C_x_PM_SDFFRS_X1%15_c10 VSS x_PM_SDFFRS_X1%15_14 1.19829e-17
C_x_PM_SDFFRS_X1%15_c11 VSS x_PM_SDFFRS_X1%15_13 3.8583e-17
C_x_PM_SDFFRS_X1%15_c12 VSS N_15_M49_g 2.65596e-17
C_x_PM_SDFFRS_X1%15_c13 VSS N_15_M17_g 9.58679e-17
C_x_PM_SDFFRS_X1%15_c14 VSS N_15_M44_g 1.96482e-17
R_x_PM_SDFFRS_X1%15_r15 x_PM_SDFFRS_X1%15_57 x_PM_SDFFRS_X1%15_55 3.9
R_x_PM_SDFFRS_X1%15_r16 x_PM_SDFFRS_X1%15_49 N_15_M47_d 0.0271429
R_x_PM_SDFFRS_X1%15_r17 N_15_M47_d x_PM_SDFFRS_X1%15_45 0.339286
R_x_PM_SDFFRS_X1%15_r18 x_PM_SDFFRS_X1%15_55 x_PM_SDFFRS_X1%15_43 25.0012
R_x_PM_SDFFRS_X1%15_r19 x_PM_SDFFRS_X1%15_43 x_PM_SDFFRS_X1%15_41 3.02643
R_x_PM_SDFFRS_X1%15_r20 x_PM_SDFFRS_X1%15_43 x_PM_SDFFRS_X1%15_40 0.0135714
R_x_PM_SDFFRS_X1%15_r21 x_PM_SDFFRS_X1%15_41 x_PM_SDFFRS_X1%15_36 0.212317
R_x_PM_SDFFRS_X1%15_r22 N_15_M21_d x_PM_SDFFRS_X1%15_36 1.34357
R_x_PM_SDFFRS_X1%15_r23 x_PM_SDFFRS_X1%15_45 x_PM_SDFFRS_X1%15_35 0.095
R_x_PM_SDFFRS_X1%15_r24 x_PM_SDFFRS_X1%15_40 x_PM_SDFFRS_X1%15_34 0.212317
R_x_PM_SDFFRS_X1%15_r25 x_PM_SDFFRS_X1%15_35 x_PM_SDFFRS_X1%15_34 2.03571
R_x_PM_SDFFRS_X1%15_r26 x_PM_SDFFRS_X1%15_32 x_PM_SDFFRS_X1%15_51 6.5
R_x_PM_SDFFRS_X1%15_r27 x_PM_SDFFRS_X1%15_32 x_PM_SDFFRS_X1%15_30 25.0012
R_x_PM_SDFFRS_X1%15_r28 x_PM_SDFFRS_X1%15_49 x_PM_SDFFRS_X1%15_29 0.095
R_x_PM_SDFFRS_X1%15_r29 x_PM_SDFFRS_X1%15_30 x_PM_SDFFRS_X1%15_29 3.078
R_x_PM_SDFFRS_X1%15_r30 N_15_M25_g N_15_M50_g 64.35
R_x_PM_SDFFRS_X1%15_r31 N_15_M25_g x_PM_SDFFRS_X1%15_22 18.33
R_x_PM_SDFFRS_X1%15_r32 N_15_M50_g x_PM_SDFFRS_X1%15_21 14.82
R_x_PM_SDFFRS_X1%15_r33 x_PM_SDFFRS_X1%15_22 x_PM_SDFFRS_X1%15_19 4.35808
R_x_PM_SDFFRS_X1%15_r34 x_PM_SDFFRS_X1%15_20 x_PM_SDFFRS_X1%15_19 15.6
R_x_PM_SDFFRS_X1%15_r35 x_PM_SDFFRS_X1%15_20 x_PM_SDFFRS_X1%15_15 4.35808
R_x_PM_SDFFRS_X1%15_r36 N_15_M24_g x_PM_SDFFRS_X1%15_15 18.33
R_x_PM_SDFFRS_X1%15_r37 x_PM_SDFFRS_X1%15_14 x_PM_SDFFRS_X1%15_57 3.4687
R_x_PM_SDFFRS_X1%15_r38 x_PM_SDFFRS_X1%15_21 x_PM_SDFFRS_X1%15_13 4.35808
R_x_PM_SDFFRS_X1%15_r39 x_PM_SDFFRS_X1%15_14 x_PM_SDFFRS_X1%15_13 42.12
R_x_PM_SDFFRS_X1%15_r40 x_PM_SDFFRS_X1%15_57 x_PM_SDFFRS_X1%15_9 1.95
R_x_PM_SDFFRS_X1%15_r41 N_15_M49_g x_PM_SDFFRS_X1%15_9 17.94
R_x_PM_SDFFRS_X1%15_r42 x_PM_SDFFRS_X1%15_51 x_PM_SDFFRS_X1%15_5 1.95
R_x_PM_SDFFRS_X1%15_r43 N_15_M17_g x_PM_SDFFRS_X1%15_5 115.44
R_x_PM_SDFFRS_X1%15_r44 x_PM_SDFFRS_X1%15_51 x_PM_SDFFRS_X1%15_VSS 1.95
R_x_PM_SDFFRS_X1%15_r45 N_15_M44_g x_PM_SDFFRS_X1%15_VSS 14.82
C_x_PM_SDFFRS_X1%RN_c0 VSS x_PM_SDFFRS_X1%RN_37 8.35828e-18
C_x_PM_SDFFRS_X1%RN_c1 VSS x_PM_SDFFRS_X1%RN_35 6.85533e-17
C_x_PM_SDFFRS_X1%RN_c2 VSS x_PM_SDFFRS_X1%RN_31 3.01228e-18
C_x_PM_SDFFRS_X1%RN_c3 VSS N_RN_M23_g 9.32389e-17
C_x_PM_SDFFRS_X1%RN_c4 VSS x_PM_SDFFRS_X1%RN_25 2.20356e-17
C_x_PM_SDFFRS_X1%RN_c5 VSS N_RN_M48_g 3.93545e-17
C_x_PM_SDFFRS_X1%RN_c6 VSS x_PM_SDFFRS_X1%RN_20 6.52386e-18
C_x_PM_SDFFRS_X1%RN_c7 VSS x_PM_SDFFRS_X1%RN_19 6.95882e-17
C_x_PM_SDFFRS_X1%RN_c8 VSS N_RN_M20_g 3.24321e-17
C_x_PM_SDFFRS_X1%RN_c9 VSS x_PM_SDFFRS_X1%RN_13 9.63407e-17
C_x_PM_SDFFRS_X1%RN_c10 VSS N_RN_M45_g 3.02053e-17
C_x_PM_SDFFRS_X1%RN_c11 VSS x_PM_SDFFRS_X1%RN_8 5.16355e-18
C_x_PM_SDFFRS_X1%RN_c12 VSS x_PM_SDFFRS_X1%RN_7 1.25009e-16
C_x_PM_SDFFRS_X1%RN_c13 VSS N_RN_M40_g 1.24208e-16
R_x_PM_SDFFRS_X1%RN_r14 x_PM_SDFFRS_X1%RN_41 x_PM_SDFFRS_X1%RN_37 1.3
R_x_PM_SDFFRS_X1%RN_r15 x_PM_SDFFRS_X1%RN_40 x_PM_SDFFRS_X1%RN_37 4.7687
R_x_PM_SDFFRS_X1%RN_r16 x_PM_SDFFRS_X1%RN_37 x_PM_SDFFRS_X1%RN_35 25.0012
R_x_PM_SDFFRS_X1%RN_r17 x_PM_SDFFRS_X1%RN_35 RN 0.318929
R_x_PM_SDFFRS_X1%RN_r18 N_RN_M23_g x_PM_SDFFRS_X1%RN_28 23.01
R_x_PM_SDFFRS_X1%RN_r19 N_RN_M23_g x_PM_SDFFRS_X1%RN_27 98.67
R_x_PM_SDFFRS_X1%RN_r20 x_PM_SDFFRS_X1%RN_41 x_PM_SDFFRS_X1%RN_26 1.95
R_x_PM_SDFFRS_X1%RN_r21 x_PM_SDFFRS_X1%RN_27 x_PM_SDFFRS_X1%RN_25 4.35808
R_x_PM_SDFFRS_X1%RN_r22 x_PM_SDFFRS_X1%RN_26 x_PM_SDFFRS_X1%RN_25 18.72
R_x_PM_SDFFRS_X1%RN_r23 N_RN_M48_g x_PM_SDFFRS_X1%RN_40 39
R_x_PM_SDFFRS_X1%RN_r24 N_RN_M48_g x_PM_SDFFRS_X1%RN_21 17.94
R_x_PM_SDFFRS_X1%RN_r25 x_PM_SDFFRS_X1%RN_28 x_PM_SDFFRS_X1%RN_19 4.35808
R_x_PM_SDFFRS_X1%RN_r26 x_PM_SDFFRS_X1%RN_20 x_PM_SDFFRS_X1%RN_19 85.8
R_x_PM_SDFFRS_X1%RN_r27 x_PM_SDFFRS_X1%RN_20 x_PM_SDFFRS_X1%RN_15 4.35808
R_x_PM_SDFFRS_X1%RN_r28 N_RN_M20_g x_PM_SDFFRS_X1%RN_15 21.84
R_x_PM_SDFFRS_X1%RN_r29 x_PM_SDFFRS_X1%RN_31 x_PM_SDFFRS_X1%RN_14 3.30287
R_x_PM_SDFFRS_X1%RN_r30 x_PM_SDFFRS_X1%RN_21 x_PM_SDFFRS_X1%RN_13 4.35808
R_x_PM_SDFFRS_X1%RN_r31 x_PM_SDFFRS_X1%RN_14 x_PM_SDFFRS_X1%RN_13 117
R_x_PM_SDFFRS_X1%RN_r32 x_PM_SDFFRS_X1%RN_31 x_PM_SDFFRS_X1%RN_9 0.858359
R_x_PM_SDFFRS_X1%RN_r33 N_RN_M45_g x_PM_SDFFRS_X1%RN_9 26.52
R_x_PM_SDFFRS_X1%RN_r34 x_PM_SDFFRS_X1%RN_31 x_PM_SDFFRS_X1%RN_7 3.30287
R_x_PM_SDFFRS_X1%RN_r35 x_PM_SDFFRS_X1%RN_8 x_PM_SDFFRS_X1%RN_7 155.22
R_x_PM_SDFFRS_X1%RN_r36 N_RN_M14_g N_RN_M40_g 130.26
R_x_PM_SDFFRS_X1%RN_r37 x_PM_SDFFRS_X1%RN_8 x_PM_SDFFRS_X1%RN_VSS 4.35808
R_x_PM_SDFFRS_X1%RN_r38 N_RN_M40_g x_PM_SDFFRS_X1%RN_VSS 26.52
C_x_PM_SDFFRS_X1%17_c0 VSS x_PM_SDFFRS_X1%17_18 5.9654e-17
C_x_PM_SDFFRS_X1%17_c1 VSS x_PM_SDFFRS_X1%17_15 2.26795e-16
C_x_PM_SDFFRS_X1%17_c2 VSS x_PM_SDFFRS_X1%17_14 2.01622e-17
C_x_PM_SDFFRS_X1%17_c3 VSS N_17_M23_d 3.12004e-17
C_x_PM_SDFFRS_X1%17_c4 VSS x_PM_SDFFRS_X1%17_10 4.51327e-18
C_x_PM_SDFFRS_X1%17_c5 VSS x_PM_SDFFRS_X1%17_7 3.77984e-17
C_x_PM_SDFFRS_X1%17_c6 VSS N_17_M51_g 8.89112e-17
R_x_PM_SDFFRS_X1%17_r7 x_PM_SDFFRS_X1%17_23 x_PM_SDFFRS_X1%17_18 25.0012
R_x_PM_SDFFRS_X1%17_r8 N_17_M49_d x_PM_SDFFRS_X1%17_16 0.185207
R_x_PM_SDFFRS_X1%17_r9 x_PM_SDFFRS_X1%17_18 x_PM_SDFFRS_X1%17_16 0.874
R_x_PM_SDFFRS_X1%17_r10 N_17_M49_d x_PM_SDFFRS_X1%17_14 0.0274381
R_x_PM_SDFFRS_X1%17_r11 x_PM_SDFFRS_X1%17_15 x_PM_SDFFRS_X1%17_14 4.47857
R_x_PM_SDFFRS_X1%17_r12 x_PM_SDFFRS_X1%17_15 x_PM_SDFFRS_X1%17_10 0.202958
R_x_PM_SDFFRS_X1%17_r13 N_17_M23_d x_PM_SDFFRS_X1%17_10 0.111765
R_x_PM_SDFFRS_X1%17_r14 x_PM_SDFFRS_X1%17_23 x_PM_SDFFRS_X1%17_7 18.98
R_x_PM_SDFFRS_X1%17_r15 N_17_M26_g N_17_M51_g 64.35
R_x_PM_SDFFRS_X1%17_r16 x_PM_SDFFRS_X1%17_7 x_PM_SDFFRS_X1%17_VSS 4.58872
R_x_PM_SDFFRS_X1%17_r17 N_17_M51_g x_PM_SDFFRS_X1%17_VSS 34.32
C_x_PM_SDFFRS_X1%QN_c0 VSS N_QN_M50_s 1.46517e-16
R_x_PM_SDFFRS_X1%QN_r1 N_QN_M25_s QN 0.918333
R_x_PM_SDFFRS_X1%QN_r2 QN N_QN_M50_s 0.665
C_x_PM_SDFFRS_X1%Q_c0 VSS N_Q_M51_d 9.04011e-17
R_x_PM_SDFFRS_X1%Q_r1 N_Q_M26_d Q 0.87
R_x_PM_SDFFRS_X1%Q_r2 Q N_Q_M51_d 0.69
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFRS_X2.                                                       *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFRS_X2 VSS VDD SE SI D CK SN RN QN Q
*.PININFO VSS:B VDD:B SE:I SI:I D:I CK:I SN:I RN:I QN:O Q:O
M_M25 N_VDD_M0_d N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 20 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M27 N_7_M2_d N_SE_M2_g 20 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M28 21 N_3_M3_g N_7_M2_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M29 N_VDD_M4_d N_SI_M4_g 21 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M30 N_VDD_M5_d N_CK_M5_g N_8_M5_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M31 N_10_M6_d N_8_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 22 N_10_M7_g N_11_M7_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M33 N_VDD_M8_d N_7_M8_g 22 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M34 23 N_12_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 N_11_M10_d N_8_M10_g 23 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M36 24 N_8_M11_g N_11_M10_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M37 N_VDD_M12_d N_SN_M12_g 24 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M38 N_12_M13_d N_11_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M39 N_VDD_M14_d N_RN_M14_g N_12_M13_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M40 25 N_8_M15_g N_14_M15_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M41 N_VDD_M16_d N_11_M16_g 25 VDD PMOS_VTL W=0.135000U L=0.050000U
M_M42 26 N_15_M17_g N_VDD_M16_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M43 N_14_M18_d N_10_M18_g 26 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M44 27 N_10_M19_g N_14_M18_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M45 N_VDD_M20_d N_RN_M20_g 27 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M46 N_15_M21_d N_SN_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M47 N_VDD_M22_d N_14_M22_g N_15_M21_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M48 N_17_M23_d N_RN_M23_g N_VDD_M22_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M49 N_VDD_M24_d N_15_M24_g N_17_M23_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M50 N_VDD_M25_d N_15_M25_g N_QN_M25_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M51 N_Q_M26_d N_17_M26_g N_VDD_M25_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M27_d N_SE_M27_g N_3_M27_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 28 N_SI_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_7_M29_d N_SE_M29_g 28 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 29 N_3_M30_g N_7_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M31_d N_D_M31_g 29 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M32_d N_CK_M32_g N_8_M32_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_10_M33_d N_8_M33_g N_VSS_M32_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 30 N_7_M34_g N_VSS_M34_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_11_M35_d N_8_M35_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 31 N_10_M36_g N_11_M35_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 32 N_12_M37_g 31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M38_d N_SN_M38_g 32 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 33 N_11_M39_g N_12_M39_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 N_VSS_M40_d N_RN_M40_g 33 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 34 N_11_M41_g N_VSS_M40_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 N_14_M42_d N_10_M42_g 34 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 35 N_8_M43_g N_14_M42_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M17 36 N_15_M44_g 35 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M18 N_VSS_M45_d N_RN_M45_g 36 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M19 37 N_SN_M46_g N_VSS_M45_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M20 N_15_M47_d N_14_M47_g 37 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M21 38 N_RN_M48_g N_VSS_M48_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M22 N_17_M49_d N_15_M49_g 38 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M23 N_VSS_M50_d N_15_M50_g N_QN_M50_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M24 N_Q_M51_d N_17_M51_g N_VSS_M50_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFFRS_X2%VSS_c0 VSS x_PM_SDFFRS_X2%VSS_67 2.88137e-18
C_x_PM_SDFFRS_X2%VSS_c1 VSS x_PM_SDFFRS_X2%VSS_65 3.64674e-17
C_x_PM_SDFFRS_X2%VSS_c2 VSS x_PM_SDFFRS_X2%VSS_57 4.28141e-17
C_x_PM_SDFFRS_X2%VSS_c3 VSS x_PM_SDFFRS_X2%VSS_56 8.86015e-18
C_x_PM_SDFFRS_X2%VSS_c4 VSS x_PM_SDFFRS_X2%VSS_55 8.85742e-18
C_x_PM_SDFFRS_X2%VSS_c5 VSS x_PM_SDFFRS_X2%VSS_54 4.90006e-18
C_x_PM_SDFFRS_X2%VSS_c6 VSS x_PM_SDFFRS_X2%VSS_53 8.89791e-18
C_x_PM_SDFFRS_X2%VSS_c7 VSS x_PM_SDFFRS_X2%VSS_48 3.01675e-17
C_x_PM_SDFFRS_X2%VSS_c8 VSS x_PM_SDFFRS_X2%VSS_47 8.86015e-18
C_x_PM_SDFFRS_X2%VSS_c9 VSS x_PM_SDFFRS_X2%VSS_46 3.14565e-17
C_x_PM_SDFFRS_X2%VSS_c10 VSS VSS 2.37005e-17
C_x_PM_SDFFRS_X2%VSS_c11 VSS x_PM_SDFFRS_X2%VSS_41 4.879e-17
C_x_PM_SDFFRS_X2%VSS_c12 VSS x_PM_SDFFRS_X2%VSS_38 1.11965e-16
C_x_PM_SDFFRS_X2%VSS_c13 VSS x_PM_SDFFRS_X2%VSS_36 4.42549e-17
C_x_PM_SDFFRS_X2%VSS_c14 VSS x_PM_SDFFRS_X2%VSS_35 4.97232e-17
C_x_PM_SDFFRS_X2%VSS_c15 VSS x_PM_SDFFRS_X2%VSS_32 1.03347e-16
C_x_PM_SDFFRS_X2%VSS_c16 VSS x_PM_SDFFRS_X2%VSS_31 2.29169e-17
C_x_PM_SDFFRS_X2%VSS_c17 VSS x_PM_SDFFRS_X2%VSS_28 4.83108e-17
C_x_PM_SDFFRS_X2%VSS_c18 VSS x_PM_SDFFRS_X2%VSS_27 7.14954e-17
C_x_PM_SDFFRS_X2%VSS_c19 VSS x_PM_SDFFRS_X2%VSS_24 1.01119e-16
C_x_PM_SDFFRS_X2%VSS_c20 VSS x_PM_SDFFRS_X2%VSS_23 5.90503e-17
C_x_PM_SDFFRS_X2%VSS_c21 VSS x_PM_SDFFRS_X2%VSS_20 2.87089e-17
C_x_PM_SDFFRS_X2%VSS_c22 VSS x_PM_SDFFRS_X2%VSS_18 3.91598e-17
C_x_PM_SDFFRS_X2%VSS_c23 VSS x_PM_SDFFRS_X2%VSS_17 5.87553e-17
C_x_PM_SDFFRS_X2%VSS_c24 VSS x_PM_SDFFRS_X2%VSS_14 6.50909e-17
C_x_PM_SDFFRS_X2%VSS_c25 VSS x_PM_SDFFRS_X2%VSS_13 2.63722e-17
R_x_PM_SDFFRS_X2%VSS_r26 x_PM_SDFFRS_X2%VSS_65 N_VSS_M50_d 0.285
R_x_PM_SDFFRS_X2%VSS_r27 N_VSS_M48_s x_PM_SDFFRS_X2%VSS_57 0.49963
R_x_PM_SDFFRS_X2%VSS_r28 N_VSS_M32_d x_PM_SDFFRS_X2%VSS_48 0.49963
R_x_PM_SDFFRS_X2%VSS_r29 x_PM_SDFFRS_X2%VSS_67 x_PM_SDFFRS_X2%VSS_42 0.0731438
R_x_PM_SDFFRS_X2%VSS_r30 VSS x_PM_SDFFRS_X2%VSS_42 0.480588
R_x_PM_SDFFRS_X2%VSS_r31 x_PM_SDFFRS_X2%VSS_65 x_PM_SDFFRS_X2%VSS_41 0.095
R_x_PM_SDFFRS_X2%VSS_r32 x_PM_SDFFRS_X2%VSS_67 x_PM_SDFFRS_X2%VSS_40 0.145286
R_x_PM_SDFFRS_X2%VSS_r33 x_PM_SDFFRS_X2%VSS_41 x_PM_SDFFRS_X2%VSS_40 1.81857
R_x_PM_SDFFRS_X2%VSS_r34 x_PM_SDFFRS_X2%VSS_57 x_PM_SDFFRS_X2%VSS_39 0.095
R_x_PM_SDFFRS_X2%VSS_r35 x_PM_SDFFRS_X2%VSS_67 x_PM_SDFFRS_X2%VSS_38 0.0731438
R_x_PM_SDFFRS_X2%VSS_r36 x_PM_SDFFRS_X2%VSS_39 x_PM_SDFFRS_X2%VSS_38 1.67647
R_x_PM_SDFFRS_X2%VSS_r37 x_PM_SDFFRS_X2%VSS_56 x_PM_SDFFRS_X2%VSS_37 0.132285
R_x_PM_SDFFRS_X2%VSS_r38 x_PM_SDFFRS_X2%VSS_57 x_PM_SDFFRS_X2%VSS_36 0.095
R_x_PM_SDFFRS_X2%VSS_r39 x_PM_SDFFRS_X2%VSS_37 x_PM_SDFFRS_X2%VSS_36 0.838235
R_x_PM_SDFFRS_X2%VSS_r40 x_PM_SDFFRS_X2%VSS_56 x_PM_SDFFRS_X2%VSS_35 0.0680382
R_x_PM_SDFFRS_X2%VSS_r41 x_PM_SDFFRS_X2%VSS_35 N_VSS_M45_d 0.403583
R_x_PM_SDFFRS_X2%VSS_r42 x_PM_SDFFRS_X2%VSS_55 x_PM_SDFFRS_X2%VSS_33 0.132285
R_x_PM_SDFFRS_X2%VSS_r43 x_PM_SDFFRS_X2%VSS_56 x_PM_SDFFRS_X2%VSS_32 0.132285
R_x_PM_SDFFRS_X2%VSS_r44 x_PM_SDFFRS_X2%VSS_33 x_PM_SDFFRS_X2%VSS_32 2.04529
R_x_PM_SDFFRS_X2%VSS_r45 x_PM_SDFFRS_X2%VSS_55 x_PM_SDFFRS_X2%VSS_31 0.0680382
R_x_PM_SDFFRS_X2%VSS_r46 x_PM_SDFFRS_X2%VSS_31 N_VSS_M40_d 0.403583
R_x_PM_SDFFRS_X2%VSS_r47 x_PM_SDFFRS_X2%VSS_54 x_PM_SDFFRS_X2%VSS_29 0.132285
R_x_PM_SDFFRS_X2%VSS_r48 x_PM_SDFFRS_X2%VSS_55 x_PM_SDFFRS_X2%VSS_28 0.132285
R_x_PM_SDFFRS_X2%VSS_r49 x_PM_SDFFRS_X2%VSS_29 x_PM_SDFFRS_X2%VSS_28 1.29647
R_x_PM_SDFFRS_X2%VSS_r50 x_PM_SDFFRS_X2%VSS_54 x_PM_SDFFRS_X2%VSS_27 0.0680382
R_x_PM_SDFFRS_X2%VSS_r51 x_PM_SDFFRS_X2%VSS_27 N_VSS_M38_d 0.558398
R_x_PM_SDFFRS_X2%VSS_r52 x_PM_SDFFRS_X2%VSS_53 x_PM_SDFFRS_X2%VSS_25 0.132285
R_x_PM_SDFFRS_X2%VSS_r53 x_PM_SDFFRS_X2%VSS_54 x_PM_SDFFRS_X2%VSS_24 0.132285
R_x_PM_SDFFRS_X2%VSS_r54 x_PM_SDFFRS_X2%VSS_25 x_PM_SDFFRS_X2%VSS_24 2.00059
R_x_PM_SDFFRS_X2%VSS_r55 x_PM_SDFFRS_X2%VSS_53 x_PM_SDFFRS_X2%VSS_23 0.0680382
R_x_PM_SDFFRS_X2%VSS_r56 x_PM_SDFFRS_X2%VSS_23 N_VSS_M34_s 0.558398
R_x_PM_SDFFRS_X2%VSS_r57 x_PM_SDFFRS_X2%VSS_48 x_PM_SDFFRS_X2%VSS_21 0.095
R_x_PM_SDFFRS_X2%VSS_r58 x_PM_SDFFRS_X2%VSS_53 x_PM_SDFFRS_X2%VSS_20 0.132285
R_x_PM_SDFFRS_X2%VSS_r59 x_PM_SDFFRS_X2%VSS_21 x_PM_SDFFRS_X2%VSS_20 0.536471
R_x_PM_SDFFRS_X2%VSS_r60 x_PM_SDFFRS_X2%VSS_47 x_PM_SDFFRS_X2%VSS_19 0.132285
R_x_PM_SDFFRS_X2%VSS_r61 x_PM_SDFFRS_X2%VSS_48 x_PM_SDFFRS_X2%VSS_18 0.095
R_x_PM_SDFFRS_X2%VSS_r62 x_PM_SDFFRS_X2%VSS_19 x_PM_SDFFRS_X2%VSS_18 0.625882
R_x_PM_SDFFRS_X2%VSS_r63 x_PM_SDFFRS_X2%VSS_47 x_PM_SDFFRS_X2%VSS_17 0.0680382
R_x_PM_SDFFRS_X2%VSS_r64 x_PM_SDFFRS_X2%VSS_17 N_VSS_M31_d 0.403583
R_x_PM_SDFFRS_X2%VSS_r65 x_PM_SDFFRS_X2%VSS_46 x_PM_SDFFRS_X2%VSS_15 0.132285
R_x_PM_SDFFRS_X2%VSS_r66 x_PM_SDFFRS_X2%VSS_47 x_PM_SDFFRS_X2%VSS_14 0.132285
R_x_PM_SDFFRS_X2%VSS_r67 x_PM_SDFFRS_X2%VSS_15 x_PM_SDFFRS_X2%VSS_14 1.38588
R_x_PM_SDFFRS_X2%VSS_r68 x_PM_SDFFRS_X2%VSS_46 x_PM_SDFFRS_X2%VSS_13 0.0680382
R_x_PM_SDFFRS_X2%VSS_r69 x_PM_SDFFRS_X2%VSS_13 N_VSS_M27_d 0.403583
C_x_PM_SDFFRS_X2%VDD_c0 VSS x_PM_SDFFRS_X2%VDD_79 2.29685e-17
C_x_PM_SDFFRS_X2%VDD_c1 VSS x_PM_SDFFRS_X2%VDD_78 4.01824e-17
C_x_PM_SDFFRS_X2%VDD_c2 VSS N_VDD_M24_d 3.92696e-17
C_x_PM_SDFFRS_X2%VDD_c3 VSS x_PM_SDFFRS_X2%VDD_75 8.85742e-18
C_x_PM_SDFFRS_X2%VDD_c4 VSS N_VDD_M20_d 4.78781e-17
C_x_PM_SDFFRS_X2%VDD_c5 VSS N_VDD_M16_d 4.45596e-17
C_x_PM_SDFFRS_X2%VDD_c6 VSS x_PM_SDFFRS_X2%VDD_64 8.86015e-18
C_x_PM_SDFFRS_X2%VDD_c7 VSS x_PM_SDFFRS_X2%VDD_63 8.86015e-18
C_x_PM_SDFFRS_X2%VDD_c8 VSS x_PM_SDFFRS_X2%VDD_62 4.00644e-17
C_x_PM_SDFFRS_X2%VDD_c9 VSS x_PM_SDFFRS_X2%VDD_58 5.74485e-18
C_x_PM_SDFFRS_X2%VDD_c10 VSS N_VDD_M4_d 1.88765e-17
C_x_PM_SDFFRS_X2%VDD_c11 VSS N_VDD_M0_d 3.04192e-17
C_x_PM_SDFFRS_X2%VDD_c12 VSS x_PM_SDFFRS_X2%VDD_42 2.11238e-17
C_x_PM_SDFFRS_X2%VDD_c13 VSS x_PM_SDFFRS_X2%VDD_41 3.89265e-17
C_x_PM_SDFFRS_X2%VDD_c14 VSS x_PM_SDFFRS_X2%VDD_38 3.18577e-17
C_x_PM_SDFFRS_X2%VDD_c15 VSS x_PM_SDFFRS_X2%VDD_36 7.73001e-17
C_x_PM_SDFFRS_X2%VDD_c16 VSS x_PM_SDFFRS_X2%VDD_34 5.28513e-17
C_x_PM_SDFFRS_X2%VDD_c17 VSS x_PM_SDFFRS_X2%VDD_33 3.73579e-17
C_x_PM_SDFFRS_X2%VDD_c18 VSS x_PM_SDFFRS_X2%VDD_30 4.56324e-17
C_x_PM_SDFFRS_X2%VDD_c19 VSS x_PM_SDFFRS_X2%VDD_29 3.38076e-17
C_x_PM_SDFFRS_X2%VDD_c20 VSS x_PM_SDFFRS_X2%VDD_26 7.98804e-17
C_x_PM_SDFFRS_X2%VDD_c21 VSS x_PM_SDFFRS_X2%VDD_24 6.72384e-17
C_x_PM_SDFFRS_X2%VDD_c22 VSS N_VDD_M5_d 7.21476e-17
C_x_PM_SDFFRS_X2%VDD_c23 VSS x_PM_SDFFRS_X2%VDD_18 1.88883e-17
C_x_PM_SDFFRS_X2%VDD_c24 VSS x_PM_SDFFRS_X2%VDD_16 5.23104e-17
C_x_PM_SDFFRS_X2%VDD_c25 VSS x_PM_SDFFRS_X2%VDD_12 5.22766e-17
R_x_PM_SDFFRS_X2%VDD_r26 x_PM_SDFFRS_X2%VDD_79 N_VDD_M24_d 0.276667
R_x_PM_SDFFRS_X2%VDD_r27 x_PM_SDFFRS_X2%VDD_78 N_VDD_M24_d 0.149174
R_x_PM_SDFFRS_X2%VDD_r28 x_PM_SDFFRS_X2%VDD_73 N_VDD_M20_d 0.49963
R_x_PM_SDFFRS_X2%VDD_r29 x_PM_SDFFRS_X2%VDD_68 N_VDD_M16_d 0.49963
R_x_PM_SDFFRS_X2%VDD_r30 x_PM_SDFFRS_X2%VDD_62 N_VDD_M8_d 0.142909
R_x_PM_SDFFRS_X2%VDD_r31 x_PM_SDFFRS_X2%VDD_56 N_VDD_M4_d 0.471481
R_x_PM_SDFFRS_X2%VDD_r32 x_PM_SDFFRS_X2%VDD_51 N_VDD_M0_d 0.471481
R_x_PM_SDFFRS_X2%VDD_r33 x_PM_SDFFRS_X2%VDD_78 N_VDD_M25_d 0.642842
R_x_PM_SDFFRS_X2%VDD_r34 x_PM_SDFFRS_X2%VDD_75 x_PM_SDFFRS_X2%VDD_43 0.132285
R_x_PM_SDFFRS_X2%VDD_r35 x_PM_SDFFRS_X2%VDD_79 x_PM_SDFFRS_X2%VDD_42 0.095
R_x_PM_SDFFRS_X2%VDD_r36 x_PM_SDFFRS_X2%VDD_43 x_PM_SDFFRS_X2%VDD_42 0.536471
R_x_PM_SDFFRS_X2%VDD_r37 x_PM_SDFFRS_X2%VDD_75 x_PM_SDFFRS_X2%VDD_41 0.0680382
R_x_PM_SDFFRS_X2%VDD_r38 x_PM_SDFFRS_X2%VDD_41 N_VDD_M22_d 0.403583
R_x_PM_SDFFRS_X2%VDD_r39 x_PM_SDFFRS_X2%VDD_73 x_PM_SDFFRS_X2%VDD_39 0.095
R_x_PM_SDFFRS_X2%VDD_r40 x_PM_SDFFRS_X2%VDD_75 x_PM_SDFFRS_X2%VDD_38 0.132285
R_x_PM_SDFFRS_X2%VDD_r41 x_PM_SDFFRS_X2%VDD_39 x_PM_SDFFRS_X2%VDD_38 0.625882
R_x_PM_SDFFRS_X2%VDD_r42 x_PM_SDFFRS_X2%VDD_68 x_PM_SDFFRS_X2%VDD_37 0.095
R_x_PM_SDFFRS_X2%VDD_r43 x_PM_SDFFRS_X2%VDD_73 x_PM_SDFFRS_X2%VDD_36 0.095
R_x_PM_SDFFRS_X2%VDD_r44 x_PM_SDFFRS_X2%VDD_37 x_PM_SDFFRS_X2%VDD_36 1.58706
R_x_PM_SDFFRS_X2%VDD_r45 x_PM_SDFFRS_X2%VDD_64 x_PM_SDFFRS_X2%VDD_35 0.132285
R_x_PM_SDFFRS_X2%VDD_r46 x_PM_SDFFRS_X2%VDD_68 x_PM_SDFFRS_X2%VDD_34 0.095
R_x_PM_SDFFRS_X2%VDD_r47 x_PM_SDFFRS_X2%VDD_35 x_PM_SDFFRS_X2%VDD_34 0.938824
R_x_PM_SDFFRS_X2%VDD_r48 x_PM_SDFFRS_X2%VDD_64 x_PM_SDFFRS_X2%VDD_33 0.0680382
R_x_PM_SDFFRS_X2%VDD_r49 x_PM_SDFFRS_X2%VDD_33 N_VDD_M14_d 0.403583
R_x_PM_SDFFRS_X2%VDD_r50 x_PM_SDFFRS_X2%VDD_63 x_PM_SDFFRS_X2%VDD_31 0.132285
R_x_PM_SDFFRS_X2%VDD_r51 x_PM_SDFFRS_X2%VDD_64 x_PM_SDFFRS_X2%VDD_30 0.132285
R_x_PM_SDFFRS_X2%VDD_r52 x_PM_SDFFRS_X2%VDD_31 x_PM_SDFFRS_X2%VDD_30 0.95
R_x_PM_SDFFRS_X2%VDD_r53 x_PM_SDFFRS_X2%VDD_63 x_PM_SDFFRS_X2%VDD_29 0.0680382
R_x_PM_SDFFRS_X2%VDD_r54 x_PM_SDFFRS_X2%VDD_29 N_VDD_M12_d 0.403583
R_x_PM_SDFFRS_X2%VDD_r55 x_PM_SDFFRS_X2%VDD_63 x_PM_SDFFRS_X2%VDD_26 0.132285
R_x_PM_SDFFRS_X2%VDD_r56 x_PM_SDFFRS_X2%VDD_62 x_PM_SDFFRS_X2%VDD_26 1.43059
R_x_PM_SDFFRS_X2%VDD_r57 x_PM_SDFFRS_X2%VDD_58 x_PM_SDFFRS_X2%VDD_25 0.132285
R_x_PM_SDFFRS_X2%VDD_r58 x_PM_SDFFRS_X2%VDD_24 N_VDD_M8_d 0.142909
R_x_PM_SDFFRS_X2%VDD_r59 x_PM_SDFFRS_X2%VDD_25 x_PM_SDFFRS_X2%VDD_24 1.49765
R_x_PM_SDFFRS_X2%VDD_r60 x_PM_SDFFRS_X2%VDD_58 x_PM_SDFFRS_X2%VDD_20 0.0680382
R_x_PM_SDFFRS_X2%VDD_r61 N_VDD_M5_d x_PM_SDFFRS_X2%VDD_20 0.935926
R_x_PM_SDFFRS_X2%VDD_r62 x_PM_SDFFRS_X2%VDD_56 x_PM_SDFFRS_X2%VDD_19 0.095
R_x_PM_SDFFRS_X2%VDD_r63 x_PM_SDFFRS_X2%VDD_58 x_PM_SDFFRS_X2%VDD_18 0.132285
R_x_PM_SDFFRS_X2%VDD_r64 x_PM_SDFFRS_X2%VDD_19 x_PM_SDFFRS_X2%VDD_18 0.57
R_x_PM_SDFFRS_X2%VDD_r65 x_PM_SDFFRS_X2%VDD_51 x_PM_SDFFRS_X2%VDD_17 0.095
R_x_PM_SDFFRS_X2%VDD_r66 x_PM_SDFFRS_X2%VDD_56 x_PM_SDFFRS_X2%VDD_16 0.095
R_x_PM_SDFFRS_X2%VDD_r67 x_PM_SDFFRS_X2%VDD_17 x_PM_SDFFRS_X2%VDD_16 1.38588
R_x_PM_SDFFRS_X2%VDD_r68 x_PM_SDFFRS_X2%VDD_51 x_PM_SDFFRS_X2%VDD_12 0.095
R_x_PM_SDFFRS_X2%VDD_r69 VDD x_PM_SDFFRS_X2%VDD_12 0.296176
C_x_PM_SDFFRS_X2%3_c0 VSS x_PM_SDFFRS_X2%3_28 8.55102e-18
C_x_PM_SDFFRS_X2%3_c1 VSS N_3_M0_s 5.07002e-17
C_x_PM_SDFFRS_X2%3_c2 VSS x_PM_SDFFRS_X2%3_22 2.77842e-18
C_x_PM_SDFFRS_X2%3_c3 VSS x_PM_SDFFRS_X2%3_19 1.75012e-16
C_x_PM_SDFFRS_X2%3_c4 VSS x_PM_SDFFRS_X2%3_16 5.54407e-17
C_x_PM_SDFFRS_X2%3_c5 VSS N_3_M27_s 4.15459e-17
C_x_PM_SDFFRS_X2%3_c6 VSS N_3_M3_g 6.64576e-17
C_x_PM_SDFFRS_X2%3_c7 VSS N_3_M30_g 5.19859e-17
R_x_PM_SDFFRS_X2%3_r8 x_PM_SDFFRS_X2%3_30 x_PM_SDFFRS_X2%3_28 4.7687
R_x_PM_SDFFRS_X2%3_r9 N_3_M0_s x_PM_SDFFRS_X2%3_23 0.285
R_x_PM_SDFFRS_X2%3_r10 x_PM_SDFFRS_X2%3_28 x_PM_SDFFRS_X2%3_19 25.0012
R_x_PM_SDFFRS_X2%3_r11 x_PM_SDFFRS_X2%3_22 x_PM_SDFFRS_X2%3_17 0.0604376
R_x_PM_SDFFRS_X2%3_r12 x_PM_SDFFRS_X2%3_19 x_PM_SDFFRS_X2%3_17 3.56929
R_x_PM_SDFFRS_X2%3_r13 x_PM_SDFFRS_X2%3_23 x_PM_SDFFRS_X2%3_16 0.095
R_x_PM_SDFFRS_X2%3_r14 x_PM_SDFFRS_X2%3_22 x_PM_SDFFRS_X2%3_15 0.140052
R_x_PM_SDFFRS_X2%3_r15 x_PM_SDFFRS_X2%3_16 x_PM_SDFFRS_X2%3_15 2.52429
R_x_PM_SDFFRS_X2%3_r16 x_PM_SDFFRS_X2%3_22 x_PM_SDFFRS_X2%3_11 0.140052
R_x_PM_SDFFRS_X2%3_r17 N_3_M27_s x_PM_SDFFRS_X2%3_11 1.15
R_x_PM_SDFFRS_X2%3_r18 N_3_M3_g x_PM_SDFFRS_X2%3_30 58.5
R_x_PM_SDFFRS_X2%3_r19 x_PM_SDFFRS_X2%3_VSS x_PM_SDFFRS_X2%3_28 4.7687
R_x_PM_SDFFRS_X2%3_r20 N_3_M30_g x_PM_SDFFRS_X2%3_VSS 52.26
C_x_PM_SDFFRS_X2%SE_c0 VSS x_PM_SDFFRS_X2%SE_31 3.77157e-18
C_x_PM_SDFFRS_X2%SE_c1 VSS x_PM_SDFFRS_X2%SE_25 1.65368e-17
C_x_PM_SDFFRS_X2%SE_c2 VSS x_PM_SDFFRS_X2%SE_23 8.39681e-17
C_x_PM_SDFFRS_X2%SE_c3 VSS x_PM_SDFFRS_X2%SE_22 4.91069e-18
C_x_PM_SDFFRS_X2%SE_c4 VSS x_PM_SDFFRS_X2%SE_21 6.57734e-18
C_x_PM_SDFFRS_X2%SE_c5 VSS N_SE_M2_g 6.50607e-17
C_x_PM_SDFFRS_X2%SE_c6 VSS N_SE_M29_g 5.12106e-17
C_x_PM_SDFFRS_X2%SE_c7 VSS x_PM_SDFFRS_X2%SE_11 2.77264e-17
C_x_PM_SDFFRS_X2%SE_c8 VSS N_SE_M0_g 4.59689e-17
C_x_PM_SDFFRS_X2%SE_c9 VSS N_SE_M27_g 4.96528e-17
R_x_PM_SDFFRS_X2%SE_r10 x_PM_SDFFRS_X2%SE_31 x_PM_SDFFRS_X2%SE_25 4.7687
R_x_PM_SDFFRS_X2%SE_r11 x_PM_SDFFRS_X2%SE_25 x_PM_SDFFRS_X2%SE_23 25.0012
R_x_PM_SDFFRS_X2%SE_r12 SE x_PM_SDFFRS_X2%SE_23 0.169643
R_x_PM_SDFFRS_X2%SE_r13 x_PM_SDFFRS_X2%SE_22 x_PM_SDFFRS_X2%SE_17 3.30287
R_x_PM_SDFFRS_X2%SE_r14 N_SE_M2_g x_PM_SDFFRS_X2%SE_17 59.28
R_x_PM_SDFFRS_X2%SE_r15 x_PM_SDFFRS_X2%SE_22 x_PM_SDFFRS_X2%SE_13 3.30287
R_x_PM_SDFFRS_X2%SE_r16 N_SE_M29_g x_PM_SDFFRS_X2%SE_13 55.38
R_x_PM_SDFFRS_X2%SE_r17 x_PM_SDFFRS_X2%SE_21 x_PM_SDFFRS_X2%SE_12 1.37914
R_x_PM_SDFFRS_X2%SE_r18 x_PM_SDFFRS_X2%SE_22 x_PM_SDFFRS_X2%SE_11 0.858359
R_x_PM_SDFFRS_X2%SE_r19 x_PM_SDFFRS_X2%SE_12 x_PM_SDFFRS_X2%SE_11 44.46
R_x_PM_SDFFRS_X2%SE_r20 N_SE_M0_g x_PM_SDFFRS_X2%SE_31 53.04
R_x_PM_SDFFRS_X2%SE_r21 x_PM_SDFFRS_X2%SE_21 x_PM_SDFFRS_X2%SE_5 2.73272
R_x_PM_SDFFRS_X2%SE_r22 x_PM_SDFFRS_X2%SE_25 x_PM_SDFFRS_X2%SE_5 14.3
R_x_PM_SDFFRS_X2%SE_r23 x_PM_SDFFRS_X2%SE_21 x_PM_SDFFRS_X2%SE_VSS 2.73272
R_x_PM_SDFFRS_X2%SE_r24 N_SE_M27_g x_PM_SDFFRS_X2%SE_VSS 48.36
C_x_PM_SDFFRS_X2%SI_c0 VSS x_PM_SDFFRS_X2%SI_20 9.61815e-18
C_x_PM_SDFFRS_X2%SI_c1 VSS x_PM_SDFFRS_X2%SI_18 6.25501e-17
C_x_PM_SDFFRS_X2%SI_c2 VSS x_PM_SDFFRS_X2%SI_14 5.3184e-17
C_x_PM_SDFFRS_X2%SI_c3 VSS x_PM_SDFFRS_X2%SI_12 7.06336e-18
C_x_PM_SDFFRS_X2%SI_c4 VSS x_PM_SDFFRS_X2%SI_11 2.29645e-17
C_x_PM_SDFFRS_X2%SI_c5 VSS N_SI_M4_g 6.93761e-17
C_x_PM_SDFFRS_X2%SI_c6 VSS x_PM_SDFFRS_X2%SI_6 5.10473e-18
C_x_PM_SDFFRS_X2%SI_c7 VSS x_PM_SDFFRS_X2%SI_5 9.59414e-17
C_x_PM_SDFFRS_X2%SI_c8 VSS N_SI_M28_g 3.34291e-17
R_x_PM_SDFFRS_X2%SI_r9 x_PM_SDFFRS_X2%SI_23 x_PM_SDFFRS_X2%SI_20 4.7687
R_x_PM_SDFFRS_X2%SI_r10 x_PM_SDFFRS_X2%SI_20 x_PM_SDFFRS_X2%SI_18 25.0012
R_x_PM_SDFFRS_X2%SI_r11 x_PM_SDFFRS_X2%SI_18 SI 0.291786
R_x_PM_SDFFRS_X2%SI_r12 x_PM_SDFFRS_X2%SI_14 x_PM_SDFFRS_X2%SI_13 89.7
R_x_PM_SDFFRS_X2%SI_r13 x_PM_SDFFRS_X2%SI_14 x_PM_SDFFRS_X2%SI_11 4.35808
R_x_PM_SDFFRS_X2%SI_r14 x_PM_SDFFRS_X2%SI_12 x_PM_SDFFRS_X2%SI_11 21.06
R_x_PM_SDFFRS_X2%SI_r15 x_PM_SDFFRS_X2%SI_12 x_PM_SDFFRS_X2%SI_7 4.35808
R_x_PM_SDFFRS_X2%SI_r16 N_SI_M4_g x_PM_SDFFRS_X2%SI_7 58.5
R_x_PM_SDFFRS_X2%SI_r17 x_PM_SDFFRS_X2%SI_13 x_PM_SDFFRS_X2%SI_5 4.35808
R_x_PM_SDFFRS_X2%SI_r18 x_PM_SDFFRS_X2%SI_6 x_PM_SDFFRS_X2%SI_5 113.1
R_x_PM_SDFFRS_X2%SI_r19 N_SI_M28_g x_PM_SDFFRS_X2%SI_23 21.84
R_x_PM_SDFFRS_X2%SI_r20 x_PM_SDFFRS_X2%SI_6 x_PM_SDFFRS_X2%SI_VSS 4.35808
R_x_PM_SDFFRS_X2%SI_r21 N_SI_M28_g x_PM_SDFFRS_X2%SI_VSS 33.54
C_x_PM_SDFFRS_X2%D_c0 VSS x_PM_SDFFRS_X2%D_20 1.24052e-17
C_x_PM_SDFFRS_X2%D_c1 VSS x_PM_SDFFRS_X2%D_16 7.83004e-17
C_x_PM_SDFFRS_X2%D_c2 VSS x_PM_SDFFRS_X2%D_14 1.08128e-17
C_x_PM_SDFFRS_X2%D_c3 VSS x_PM_SDFFRS_X2%D_12 8.72019e-17
C_x_PM_SDFFRS_X2%D_c4 VSS x_PM_SDFFRS_X2%D_9 1.57326e-16
C_x_PM_SDFFRS_X2%D_c5 VSS N_D_M31_g 3.86277e-17
C_x_PM_SDFFRS_X2%D_c6 VSS N_D_M1_g 4.33554e-17
R_x_PM_SDFFRS_X2%D_r7 x_PM_SDFFRS_X2%D_20 x_PM_SDFFRS_X2%D_24 2.86
R_x_PM_SDFFRS_X2%D_r8 x_PM_SDFFRS_X2%D_20 x_PM_SDFFRS_X2%D_18 25.0012
R_x_PM_SDFFRS_X2%D_r9 D x_PM_SDFFRS_X2%D_18 0.246296
R_x_PM_SDFFRS_X2%D_r10 x_PM_SDFFRS_X2%D_18 x_PM_SDFFRS_X2%D_16 0.0211111
R_x_PM_SDFFRS_X2%D_r11 x_PM_SDFFRS_X2%D_29 x_PM_SDFFRS_X2%D_14 4.7687
R_x_PM_SDFFRS_X2%D_r12 x_PM_SDFFRS_X2%D_14 x_PM_SDFFRS_X2%D_12 25.0012
R_x_PM_SDFFRS_X2%D_r13 x_PM_SDFFRS_X2%D_12 x_PM_SDFFRS_X2%D_11 1.235
R_x_PM_SDFFRS_X2%D_r14 x_PM_SDFFRS_X2%D_16 x_PM_SDFFRS_X2%D_10 0.095
R_x_PM_SDFFRS_X2%D_r15 x_PM_SDFFRS_X2%D_11 x_PM_SDFFRS_X2%D_9 0.212317
R_x_PM_SDFFRS_X2%D_r16 x_PM_SDFFRS_X2%D_10 x_PM_SDFFRS_X2%D_9 2.22571
R_x_PM_SDFFRS_X2%D_r17 N_D_M31_g x_PM_SDFFRS_X2%D_29 32.76
R_x_PM_SDFFRS_X2%D_r18 x_PM_SDFFRS_X2%D_24 x_PM_SDFFRS_X2%D_VSS 1.95
R_x_PM_SDFFRS_X2%D_r19 N_D_M1_g x_PM_SDFFRS_X2%D_VSS 35.88
C_x_PM_SDFFRS_X2%7_c0 VSS x_PM_SDFFRS_X2%7_33 4.82746e-17
C_x_PM_SDFFRS_X2%7_c1 VSS x_PM_SDFFRS_X2%7_29 2.267e-17
C_x_PM_SDFFRS_X2%7_c2 VSS x_PM_SDFFRS_X2%7_23 1.31667e-16
C_x_PM_SDFFRS_X2%7_c3 VSS x_PM_SDFFRS_X2%7_22 1.02418e-16
C_x_PM_SDFFRS_X2%7_c4 VSS x_PM_SDFFRS_X2%7_20 1.91183e-17
C_x_PM_SDFFRS_X2%7_c5 VSS x_PM_SDFFRS_X2%7_19 7.64791e-17
C_x_PM_SDFFRS_X2%7_c6 VSS x_PM_SDFFRS_X2%7_15 9.09964e-17
C_x_PM_SDFFRS_X2%7_c7 VSS x_PM_SDFFRS_X2%7_12 6.03207e-18
C_x_PM_SDFFRS_X2%7_c8 VSS x_PM_SDFFRS_X2%7_11 1.47753e-17
C_x_PM_SDFFRS_X2%7_c9 VSS N_7_M8_g 5.26772e-17
C_x_PM_SDFFRS_X2%7_c10 VSS x_PM_SDFFRS_X2%7_5 3.09661e-17
C_x_PM_SDFFRS_X2%7_c11 VSS N_7_M34_g 6.67489e-17
R_x_PM_SDFFRS_X2%7_r12 x_PM_SDFFRS_X2%7_36 x_PM_SDFFRS_X2%7_33 0.285
R_x_PM_SDFFRS_X2%7_r13 x_PM_SDFFRS_X2%7_38 x_PM_SDFFRS_X2%7_33 25.0012
R_x_PM_SDFFRS_X2%7_r14 x_PM_SDFFRS_X2%7_30 x_PM_SDFFRS_X2%7_29 0.57
R_x_PM_SDFFRS_X2%7_r15 x_PM_SDFFRS_X2%7_29 x_PM_SDFFRS_X2%7_24 0.095
R_x_PM_SDFFRS_X2%7_r16 x_PM_SDFFRS_X2%7_36 x_PM_SDFFRS_X2%7_23 0.095
R_x_PM_SDFFRS_X2%7_r17 x_PM_SDFFRS_X2%7_24 x_PM_SDFFRS_X2%7_23 3.61
R_x_PM_SDFFRS_X2%7_r18 x_PM_SDFFRS_X2%7_29 x_PM_SDFFRS_X2%7_22 0.19
R_x_PM_SDFFRS_X2%7_r19 x_PM_SDFFRS_X2%7_22 x_PM_SDFFRS_X2%7_21 2.11714
R_x_PM_SDFFRS_X2%7_r20 x_PM_SDFFRS_X2%7_20 N_7_M29_d 0.297071
R_x_PM_SDFFRS_X2%7_r21 x_PM_SDFFRS_X2%7_21 x_PM_SDFFRS_X2%7_19 0.212317
R_x_PM_SDFFRS_X2%7_r22 x_PM_SDFFRS_X2%7_20 x_PM_SDFFRS_X2%7_19 1.65571
R_x_PM_SDFFRS_X2%7_r23 x_PM_SDFFRS_X2%7_30 x_PM_SDFFRS_X2%7_15 0.095
R_x_PM_SDFFRS_X2%7_r24 N_7_M2_d x_PM_SDFFRS_X2%7_15 1.91357
R_x_PM_SDFFRS_X2%7_r25 x_PM_SDFFRS_X2%7_38 x_PM_SDFFRS_X2%7_11 9.62
R_x_PM_SDFFRS_X2%7_r26 x_PM_SDFFRS_X2%7_12 x_PM_SDFFRS_X2%7_11 2.32903
R_x_PM_SDFFRS_X2%7_r27 N_7_M8_g x_PM_SDFFRS_X2%7_7 48.36
R_x_PM_SDFFRS_X2%7_r28 x_PM_SDFFRS_X2%7_12 x_PM_SDFFRS_X2%7_6 2.32903
R_x_PM_SDFFRS_X2%7_r29 x_PM_SDFFRS_X2%7_7 x_PM_SDFFRS_X2%7_5 4.58872
R_x_PM_SDFFRS_X2%7_r30 x_PM_SDFFRS_X2%7_6 x_PM_SDFFRS_X2%7_5 16.12
R_x_PM_SDFFRS_X2%7_r31 x_PM_SDFFRS_X2%7_12 x_PM_SDFFRS_X2%7_VSS 1.81308
R_x_PM_SDFFRS_X2%7_r32 N_7_M34_g x_PM_SDFFRS_X2%7_VSS 68.64
C_x_PM_SDFFRS_X2%8_c0 VSS x_PM_SDFFRS_X2%8_70 1.11049e-17
C_x_PM_SDFFRS_X2%8_c1 VSS x_PM_SDFFRS_X2%8_64 7.41532e-18
C_x_PM_SDFFRS_X2%8_c2 VSS N_8_M32_s 5.01545e-17
C_x_PM_SDFFRS_X2%8_c3 VSS x_PM_SDFFRS_X2%8_56 1.09843e-16
C_x_PM_SDFFRS_X2%8_c4 VSS x_PM_SDFFRS_X2%8_54 3.37958e-17
C_x_PM_SDFFRS_X2%8_c5 VSS x_PM_SDFFRS_X2%8_52 1.01031e-17
C_x_PM_SDFFRS_X2%8_c6 VSS x_PM_SDFFRS_X2%8_50 8.73384e-17
C_x_PM_SDFFRS_X2%8_c7 VSS x_PM_SDFFRS_X2%8_46 6.23454e-17
C_x_PM_SDFFRS_X2%8_c8 VSS x_PM_SDFFRS_X2%8_43 9.45746e-17
C_x_PM_SDFFRS_X2%8_c9 VSS x_PM_SDFFRS_X2%8_37 1.22922e-17
C_x_PM_SDFFRS_X2%8_c10 VSS N_8_M43_g 7.5976e-17
C_x_PM_SDFFRS_X2%8_c11 VSS x_PM_SDFFRS_X2%8_32 7.35563e-18
C_x_PM_SDFFRS_X2%8_c12 VSS x_PM_SDFFRS_X2%8_31 2.70759e-17
C_x_PM_SDFFRS_X2%8_c13 VSS N_8_M15_g 5.18753e-17
C_x_PM_SDFFRS_X2%8_c14 VSS x_PM_SDFFRS_X2%8_25 1.35106e-16
C_x_PM_SDFFRS_X2%8_c15 VSS N_8_M11_g 1.96434e-17
C_x_PM_SDFFRS_X2%8_c16 VSS x_PM_SDFFRS_X2%8_20 7.38876e-18
C_x_PM_SDFFRS_X2%8_c17 VSS x_PM_SDFFRS_X2%8_19 1.47546e-17
C_x_PM_SDFFRS_X2%8_c18 VSS N_8_M10_g 1.70613e-17
C_x_PM_SDFFRS_X2%8_c19 VSS N_8_M35_g 5.10972e-17
C_x_PM_SDFFRS_X2%8_c20 VSS x_PM_SDFFRS_X2%8_10 6.76731e-18
C_x_PM_SDFFRS_X2%8_c21 VSS x_PM_SDFFRS_X2%8_9 6.6064e-17
C_x_PM_SDFFRS_X2%8_c22 VSS N_8_M6_g 3.88944e-17
C_x_PM_SDFFRS_X2%8_c23 VSS N_8_M33_g 5.83578e-17
R_x_PM_SDFFRS_X2%8_r24 x_PM_SDFFRS_X2%8_66 x_PM_SDFFRS_X2%8_64 4.7687
R_x_PM_SDFFRS_X2%8_r25 x_PM_SDFFRS_X2%8_70 x_PM_SDFFRS_X2%8_56 25.0012
R_x_PM_SDFFRS_X2%8_r26 x_PM_SDFFRS_X2%8_56 x_PM_SDFFRS_X2%8_54 2.34786
R_x_PM_SDFFRS_X2%8_r27 x_PM_SDFFRS_X2%8_68 x_PM_SDFFRS_X2%8_52 4.7687
R_x_PM_SDFFRS_X2%8_r28 x_PM_SDFFRS_X2%8_52 x_PM_SDFFRS_X2%8_50 25.0012
R_x_PM_SDFFRS_X2%8_r29 x_PM_SDFFRS_X2%8_54 x_PM_SDFFRS_X2%8_49 0.212317
R_x_PM_SDFFRS_X2%8_r30 x_PM_SDFFRS_X2%8_50 x_PM_SDFFRS_X2%8_49 1.83214
R_x_PM_SDFFRS_X2%8_r31 x_PM_SDFFRS_X2%8_64 x_PM_SDFFRS_X2%8_46 25.0012
R_x_PM_SDFFRS_X2%8_r32 N_8_M5_s x_PM_SDFFRS_X2%8_44 0.0141545
R_x_PM_SDFFRS_X2%8_r33 x_PM_SDFFRS_X2%8_46 x_PM_SDFFRS_X2%8_44 1.58786
R_x_PM_SDFFRS_X2%8_r34 N_8_M5_s x_PM_SDFFRS_X2%8_43 0.198162
R_x_PM_SDFFRS_X2%8_r35 x_PM_SDFFRS_X2%8_42 N_8_M32_s 0.29113
R_x_PM_SDFFRS_X2%8_r36 x_PM_SDFFRS_X2%8_43 x_PM_SDFFRS_X2%8_42 2.00857
R_x_PM_SDFFRS_X2%8_r37 x_PM_SDFFRS_X2%8_38 x_PM_SDFFRS_X2%8_37 11.7
R_x_PM_SDFFRS_X2%8_r38 N_8_M43_g x_PM_SDFFRS_X2%8_33 83.46
R_x_PM_SDFFRS_X2%8_r39 x_PM_SDFFRS_X2%8_33 x_PM_SDFFRS_X2%8_31 4.35808
R_x_PM_SDFFRS_X2%8_r40 x_PM_SDFFRS_X2%8_32 x_PM_SDFFRS_X2%8_31 21.84
R_x_PM_SDFFRS_X2%8_r41 N_8_M15_g x_PM_SDFFRS_X2%8_28 18.33
R_x_PM_SDFFRS_X2%8_r42 x_PM_SDFFRS_X2%8_32 x_PM_SDFFRS_X2%8_27 4.35808
R_x_PM_SDFFRS_X2%8_r43 N_8_M15_g x_PM_SDFFRS_X2%8_27 54.21
R_x_PM_SDFFRS_X2%8_r44 x_PM_SDFFRS_X2%8_38 x_PM_SDFFRS_X2%8_26 1.95
R_x_PM_SDFFRS_X2%8_r45 x_PM_SDFFRS_X2%8_28 x_PM_SDFFRS_X2%8_25 4.35808
R_x_PM_SDFFRS_X2%8_r46 x_PM_SDFFRS_X2%8_26 x_PM_SDFFRS_X2%8_25 166.14
R_x_PM_SDFFRS_X2%8_r47 x_PM_SDFFRS_X2%8_37 x_PM_SDFFRS_X2%8_21 3.9
R_x_PM_SDFFRS_X2%8_r48 N_8_M11_g x_PM_SDFFRS_X2%8_21 14.82
R_x_PM_SDFFRS_X2%8_r49 x_PM_SDFFRS_X2%8_37 x_PM_SDFFRS_X2%8_19 1.95
R_x_PM_SDFFRS_X2%8_r50 x_PM_SDFFRS_X2%8_20 x_PM_SDFFRS_X2%8_19 21.84
R_x_PM_SDFFRS_X2%8_r51 x_PM_SDFFRS_X2%8_20 x_PM_SDFFRS_X2%8_16 4.35808
R_x_PM_SDFFRS_X2%8_r52 N_8_M10_g x_PM_SDFFRS_X2%8_16 14.82
R_x_PM_SDFFRS_X2%8_r53 x_PM_SDFFRS_X2%8_15 x_PM_SDFFRS_X2%8_70 4.7687
R_x_PM_SDFFRS_X2%8_r54 N_8_M10_g x_PM_SDFFRS_X2%8_15 16.38
R_x_PM_SDFFRS_X2%8_r55 N_8_M35_g x_PM_SDFFRS_X2%8_68 42.12
R_x_PM_SDFFRS_X2%8_r56 N_8_M35_g x_PM_SDFFRS_X2%8_11 35.1
R_x_PM_SDFFRS_X2%8_r57 x_PM_SDFFRS_X2%8_11 x_PM_SDFFRS_X2%8_9 4.35808
R_x_PM_SDFFRS_X2%8_r58 x_PM_SDFFRS_X2%8_10 x_PM_SDFFRS_X2%8_9 80.34
R_x_PM_SDFFRS_X2%8_r59 N_8_M6_g x_PM_SDFFRS_X2%8_66 37.44
R_x_PM_SDFFRS_X2%8_r60 x_PM_SDFFRS_X2%8_2 x_PM_SDFFRS_X2%8_64 4.7687
R_x_PM_SDFFRS_X2%8_r61 N_8_M33_g x_PM_SDFFRS_X2%8_2 67.08
R_x_PM_SDFFRS_X2%8_r62 x_PM_SDFFRS_X2%8_10 x_PM_SDFFRS_X2%8_VSS 4.35808
R_x_PM_SDFFRS_X2%8_r63 N_8_M33_g x_PM_SDFFRS_X2%8_VSS 21.84
C_x_PM_SDFFRS_X2%CK_c0 VSS x_PM_SDFFRS_X2%CK_13 9.23645e-18
C_x_PM_SDFFRS_X2%CK_c1 VSS CK 4.97618e-17
C_x_PM_SDFFRS_X2%CK_c2 VSS N_CK_M5_g 6.81071e-17
C_x_PM_SDFFRS_X2%CK_c3 VSS N_CK_M32_g 3.02305e-17
R_x_PM_SDFFRS_X2%CK_r4 x_PM_SDFFRS_X2%CK_16 x_PM_SDFFRS_X2%CK_13 4.74714
R_x_PM_SDFFRS_X2%CK_r5 x_PM_SDFFRS_X2%CK_15 x_PM_SDFFRS_X2%CK_13 4.74714
R_x_PM_SDFFRS_X2%CK_r6 x_PM_SDFFRS_X2%CK_13 x_PM_SDFFRS_X2%CK_11 25.0012
R_x_PM_SDFFRS_X2%CK_r7 x_PM_SDFFRS_X2%CK_11 CK 0.26074
R_x_PM_SDFFRS_X2%CK_r8 N_CK_M5_g x_PM_SDFFRS_X2%CK_16 61.62
R_x_PM_SDFFRS_X2%CK_r9 N_CK_M32_g x_PM_SDFFRS_X2%CK_15 21.84
C_x_PM_SDFFRS_X2%10_c0 VSS x_PM_SDFFRS_X2%10_66 1.02598e-17
C_x_PM_SDFFRS_X2%10_c1 VSS x_PM_SDFFRS_X2%10_59 1.56374e-17
C_x_PM_SDFFRS_X2%10_c2 VSS x_PM_SDFFRS_X2%10_58 1.01452e-17
C_x_PM_SDFFRS_X2%10_c3 VSS x_PM_SDFFRS_X2%10_56 5.00553e-18
C_x_PM_SDFFRS_X2%10_c4 VSS x_PM_SDFFRS_X2%10_55 5.57354e-17
C_x_PM_SDFFRS_X2%10_c5 VSS x_PM_SDFFRS_X2%10_53 7.37677e-17
C_x_PM_SDFFRS_X2%10_c6 VSS x_PM_SDFFRS_X2%10_49 2.73177e-16
C_x_PM_SDFFRS_X2%10_c7 VSS x_PM_SDFFRS_X2%10_46 2.81746e-17
C_x_PM_SDFFRS_X2%10_c8 VSS x_PM_SDFFRS_X2%10_43 7.34801e-18
C_x_PM_SDFFRS_X2%10_c9 VSS x_PM_SDFFRS_X2%10_42 3.53616e-16
C_x_PM_SDFFRS_X2%10_c10 VSS x_PM_SDFFRS_X2%10_41 3.64741e-18
C_x_PM_SDFFRS_X2%10_c11 VSS x_PM_SDFFRS_X2%10_39 8.2142e-18
C_x_PM_SDFFRS_X2%10_c12 VSS x_PM_SDFFRS_X2%10_35 7.57855e-17
C_x_PM_SDFFRS_X2%10_c13 VSS x_PM_SDFFRS_X2%10_34 1.29124e-16
C_x_PM_SDFFRS_X2%10_c14 VSS x_PM_SDFFRS_X2%10_32 9.90356e-18
C_x_PM_SDFFRS_X2%10_c15 VSS x_PM_SDFFRS_X2%10_31 3.08809e-17
C_x_PM_SDFFRS_X2%10_c16 VSS x_PM_SDFFRS_X2%10_30 3.65142e-17
C_x_PM_SDFFRS_X2%10_c17 VSS x_PM_SDFFRS_X2%10_25 9.52162e-17
C_x_PM_SDFFRS_X2%10_c18 VSS N_10_M19_g 2.55402e-17
C_x_PM_SDFFRS_X2%10_c19 VSS x_PM_SDFFRS_X2%10_19 4.81551e-18
C_x_PM_SDFFRS_X2%10_c20 VSS x_PM_SDFFRS_X2%10_18 7.52807e-18
C_x_PM_SDFFRS_X2%10_c21 VSS x_PM_SDFFRS_X2%10_17 1.26365e-17
C_x_PM_SDFFRS_X2%10_c22 VSS N_10_M18_g 2.57553e-17
C_x_PM_SDFFRS_X2%10_c23 VSS N_10_M42_g 2.54598e-17
C_x_PM_SDFFRS_X2%10_c24 VSS N_10_M36_g 2.08941e-17
C_x_PM_SDFFRS_X2%10_c25 VSS N_10_M7_g 2.77005e-17
R_x_PM_SDFFRS_X2%10_r26 x_PM_SDFFRS_X2%10_62 x_PM_SDFFRS_X2%10_58 4.7687
R_x_PM_SDFFRS_X2%10_r27 x_PM_SDFFRS_X2%10_58 x_PM_SDFFRS_X2%10_57 25.0012
R_x_PM_SDFFRS_X2%10_r28 x_PM_SDFFRS_X2%10_55 x_PM_SDFFRS_X2%10_54 1.65571
R_x_PM_SDFFRS_X2%10_r29 x_PM_SDFFRS_X2%10_55 x_PM_SDFFRS_X2%10_53 0.212317
R_x_PM_SDFFRS_X2%10_r30 x_PM_SDFFRS_X2%10_53 x_PM_SDFFRS_X2%10_51 0.543196
R_x_PM_SDFFRS_X2%10_r31 x_PM_SDFFRS_X2%10_52 x_PM_SDFFRS_X2%10_51 25.0012
R_x_PM_SDFFRS_X2%10_r32 x_PM_SDFFRS_X2%10_59 x_PM_SDFFRS_X2%10_50 0.160909
R_x_PM_SDFFRS_X2%10_r33 x_PM_SDFFRS_X2%10_54 x_PM_SDFFRS_X2%10_49 0.212317
R_x_PM_SDFFRS_X2%10_r34 x_PM_SDFFRS_X2%10_50 x_PM_SDFFRS_X2%10_49 5.13
R_x_PM_SDFFRS_X2%10_r35 x_PM_SDFFRS_X2%10_66 x_PM_SDFFRS_X2%10_46 25.0012
R_x_PM_SDFFRS_X2%10_r36 x_PM_SDFFRS_X2%10_59 x_PM_SDFFRS_X2%10_44 0.0418175
R_x_PM_SDFFRS_X2%10_r37 x_PM_SDFFRS_X2%10_46 x_PM_SDFFRS_X2%10_44 0.583571
R_x_PM_SDFFRS_X2%10_r38 x_PM_SDFFRS_X2%10_59 x_PM_SDFFRS_X2%10_42 0.160909
R_x_PM_SDFFRS_X2%10_r39 x_PM_SDFFRS_X2%10_43 x_PM_SDFFRS_X2%10_42 7.35571
R_x_PM_SDFFRS_X2%10_r40 x_PM_SDFFRS_X2%10_43 x_PM_SDFFRS_X2%10_41 0.212317
R_x_PM_SDFFRS_X2%10_r41 x_PM_SDFFRS_X2%10_41 x_PM_SDFFRS_X2%10_40 0.298571
R_x_PM_SDFFRS_X2%10_r42 x_PM_SDFFRS_X2%10_64 x_PM_SDFFRS_X2%10_39 4.7687
R_x_PM_SDFFRS_X2%10_r43 x_PM_SDFFRS_X2%10_39 x_PM_SDFFRS_X2%10_37 25.0012
R_x_PM_SDFFRS_X2%10_r44 x_PM_SDFFRS_X2%10_56 x_PM_SDFFRS_X2%10_36 0.160909
R_x_PM_SDFFRS_X2%10_r45 x_PM_SDFFRS_X2%10_37 x_PM_SDFFRS_X2%10_36 2.13071
R_x_PM_SDFFRS_X2%10_r46 x_PM_SDFFRS_X2%10_40 x_PM_SDFFRS_X2%10_35 0.212317
R_x_PM_SDFFRS_X2%10_r47 x_PM_SDFFRS_X2%10_37 x_PM_SDFFRS_X2%10_35 0.0678571
R_x_PM_SDFFRS_X2%10_r48 x_PM_SDFFRS_X2%10_57 x_PM_SDFFRS_X2%10_34 0.04004
R_x_PM_SDFFRS_X2%10_r49 x_PM_SDFFRS_X2%10_56 x_PM_SDFFRS_X2%10_33 0.0418175
R_x_PM_SDFFRS_X2%10_r50 x_PM_SDFFRS_X2%10_34 x_PM_SDFFRS_X2%10_33 2.49714
R_x_PM_SDFFRS_X2%10_r51 x_PM_SDFFRS_X2%10_56 x_PM_SDFFRS_X2%10_31 0.160909
R_x_PM_SDFFRS_X2%10_r52 x_PM_SDFFRS_X2%10_32 x_PM_SDFFRS_X2%10_31 1.27571
R_x_PM_SDFFRS_X2%10_r53 x_PM_SDFFRS_X2%10_32 x_PM_SDFFRS_X2%10_30 0.212317
R_x_PM_SDFFRS_X2%10_r54 x_PM_SDFFRS_X2%10_30 N_10_M33_d 0.570339
R_x_PM_SDFFRS_X2%10_r55 x_PM_SDFFRS_X2%10_57 x_PM_SDFFRS_X2%10_25 0.173507
R_x_PM_SDFFRS_X2%10_r56 N_10_M6_d x_PM_SDFFRS_X2%10_25 1.24688
R_x_PM_SDFFRS_X2%10_r57 x_PM_SDFFRS_X2%10_52 x_PM_SDFFRS_X2%10_19 3.67098
R_x_PM_SDFFRS_X2%10_r58 N_10_M19_g x_PM_SDFFRS_X2%10_19 27.3
R_x_PM_SDFFRS_X2%10_r59 x_PM_SDFFRS_X2%10_52 x_PM_SDFFRS_X2%10_17 0.917744
R_x_PM_SDFFRS_X2%10_r60 x_PM_SDFFRS_X2%10_18 x_PM_SDFFRS_X2%10_17 14.56
R_x_PM_SDFFRS_X2%10_r61 x_PM_SDFFRS_X2%10_18 x_PM_SDFFRS_X2%10_13 4.58872
R_x_PM_SDFFRS_X2%10_r62 N_10_M18_g x_PM_SDFFRS_X2%10_13 27.3
R_x_PM_SDFFRS_X2%10_r63 x_PM_SDFFRS_X2%10_9 x_PM_SDFFRS_X2%10_66 4.7687
R_x_PM_SDFFRS_X2%10_r64 N_10_M42_g x_PM_SDFFRS_X2%10_9 21.84
R_x_PM_SDFFRS_X2%10_r65 N_10_M36_g x_PM_SDFFRS_X2%10_64 15.6
R_x_PM_SDFFRS_X2%10_r66 N_10_M7_g x_PM_SDFFRS_X2%10_62 21.84
C_x_PM_SDFFRS_X2%11_c0 VSS x_PM_SDFFRS_X2%11_66 1.38389e-17
C_x_PM_SDFFRS_X2%11_c1 VSS x_PM_SDFFRS_X2%11_61 9.52226e-18
C_x_PM_SDFFRS_X2%11_c2 VSS x_PM_SDFFRS_X2%11_54 1.85341e-17
C_x_PM_SDFFRS_X2%11_c3 VSS x_PM_SDFFRS_X2%11_48 1.07853e-16
C_x_PM_SDFFRS_X2%11_c4 VSS x_PM_SDFFRS_X2%11_46 6.19595e-17
C_x_PM_SDFFRS_X2%11_c5 VSS x_PM_SDFFRS_X2%11_45 2.05346e-16
C_x_PM_SDFFRS_X2%11_c6 VSS x_PM_SDFFRS_X2%11_39 9.34822e-18
C_x_PM_SDFFRS_X2%11_c7 VSS x_PM_SDFFRS_X2%11_36 1.55189e-17
C_x_PM_SDFFRS_X2%11_c8 VSS x_PM_SDFFRS_X2%11_35 2.50599e-16
C_x_PM_SDFFRS_X2%11_c9 VSS x_PM_SDFFRS_X2%11_34 1.924e-17
C_x_PM_SDFFRS_X2%11_c10 VSS x_PM_SDFFRS_X2%11_27 7.48889e-17
C_x_PM_SDFFRS_X2%11_c11 VSS N_11_M16_g 3.61413e-17
C_x_PM_SDFFRS_X2%11_c12 VSS N_11_M41_g 7.00958e-17
C_x_PM_SDFFRS_X2%11_c13 VSS N_11_M39_g 7.86697e-17
C_x_PM_SDFFRS_X2%11_c14 VSS N_11_M13_g 3.93089e-17
C_x_PM_SDFFRS_X2%11_c15 VSS x_PM_SDFFRS_X2%11_VSS 1.07404e-16
R_x_PM_SDFFRS_X2%11_r16 x_PM_SDFFRS_X2%11_56 x_PM_SDFFRS_X2%11_54 6.5
R_x_PM_SDFFRS_X2%11_r17 x_PM_SDFFRS_X2%11_66 x_PM_SDFFRS_X2%11_52 2.86
R_x_PM_SDFFRS_X2%11_r18 x_PM_SDFFRS_X2%11_52 x_PM_SDFFRS_X2%11_50 25.0012
R_x_PM_SDFFRS_X2%11_r19 x_PM_SDFFRS_X2%11_50 x_PM_SDFFRS_X2%11_48 0.302593
R_x_PM_SDFFRS_X2%11_r20 x_PM_SDFFRS_X2%11_46 N_11_M10_d 1.07667
R_x_PM_SDFFRS_X2%11_r21 x_PM_SDFFRS_X2%11_45 N_11_M10_d 0.344227
R_x_PM_SDFFRS_X2%11_r22 x_PM_SDFFRS_X2%11_61 x_PM_SDFFRS_X2%11_41 25.0012
R_x_PM_SDFFRS_X2%11_r23 x_PM_SDFFRS_X2%11_60 x_PM_SDFFRS_X2%11_39 4.7687
R_x_PM_SDFFRS_X2%11_r24 x_PM_SDFFRS_X2%11_59 x_PM_SDFFRS_X2%11_39 4.7687
R_x_PM_SDFFRS_X2%11_r25 x_PM_SDFFRS_X2%11_39 x_PM_SDFFRS_X2%11_37 25.0012
R_x_PM_SDFFRS_X2%11_r26 x_PM_SDFFRS_X2%11_41 x_PM_SDFFRS_X2%11_37 2.82286
R_x_PM_SDFFRS_X2%11_r27 x_PM_SDFFRS_X2%11_37 x_PM_SDFFRS_X2%11_36 1.31643
R_x_PM_SDFFRS_X2%11_r28 x_PM_SDFFRS_X2%11_48 x_PM_SDFFRS_X2%11_35 0.095
R_x_PM_SDFFRS_X2%11_r29 x_PM_SDFFRS_X2%11_41 x_PM_SDFFRS_X2%11_35 1.615
R_x_PM_SDFFRS_X2%11_r30 x_PM_SDFFRS_X2%11_46 x_PM_SDFFRS_X2%11_34 0.095
R_x_PM_SDFFRS_X2%11_r31 x_PM_SDFFRS_X2%11_36 x_PM_SDFFRS_X2%11_33 0.212317
R_x_PM_SDFFRS_X2%11_r32 x_PM_SDFFRS_X2%11_34 x_PM_SDFFRS_X2%11_33 1.14
R_x_PM_SDFFRS_X2%11_r33 N_11_M35_d x_PM_SDFFRS_X2%11_27 0.394074
R_x_PM_SDFFRS_X2%11_r34 x_PM_SDFFRS_X2%11_56 x_PM_SDFFRS_X2%11_27 25.0012
R_x_PM_SDFFRS_X2%11_r35 N_11_M7_s x_PM_SDFFRS_X2%11_45 4.00357
R_x_PM_SDFFRS_X2%11_r36 x_PM_SDFFRS_X2%11_66 x_PM_SDFFRS_X2%11_15 1.95
R_x_PM_SDFFRS_X2%11_r37 N_11_M16_g x_PM_SDFFRS_X2%11_15 30.81
R_x_PM_SDFFRS_X2%11_r38 x_PM_SDFFRS_X2%11_11 x_PM_SDFFRS_X2%11_61 4.7687
R_x_PM_SDFFRS_X2%11_r39 N_11_M41_g x_PM_SDFFRS_X2%11_11 85.8
R_x_PM_SDFFRS_X2%11_r40 N_11_M39_g x_PM_SDFFRS_X2%11_59 85.8
R_x_PM_SDFFRS_X2%11_r41 N_11_M39_g x_PM_SDFFRS_X2%11_7 17.94
R_x_PM_SDFFRS_X2%11_r42 N_11_M13_g x_PM_SDFFRS_X2%11_60 39.78
R_x_PM_SDFFRS_X2%11_r43 x_PM_SDFFRS_X2%11_54 x_PM_SDFFRS_X2%11_2 1.95
R_x_PM_SDFFRS_X2%11_r44 x_PM_SDFFRS_X2%11_7 x_PM_SDFFRS_X2%11_VSS 4.35808
R_x_PM_SDFFRS_X2%11_r45 x_PM_SDFFRS_X2%11_2 x_PM_SDFFRS_X2%11_VSS 131.04
C_x_PM_SDFFRS_X2%12_c0 VSS x_PM_SDFFRS_X2%12_42 1.09756e-17
C_x_PM_SDFFRS_X2%12_c1 VSS x_PM_SDFFRS_X2%12_34 4.86392e-17
C_x_PM_SDFFRS_X2%12_c2 VSS x_PM_SDFFRS_X2%12_31 1.0864e-17
C_x_PM_SDFFRS_X2%12_c3 VSS x_PM_SDFFRS_X2%12_29 8.18377e-17
C_x_PM_SDFFRS_X2%12_c4 VSS N_12_M13_d 1.79544e-17
C_x_PM_SDFFRS_X2%12_c5 VSS x_PM_SDFFRS_X2%12_23 4.12682e-17
C_x_PM_SDFFRS_X2%12_c6 VSS x_PM_SDFFRS_X2%12_20 8.34566e-18
C_x_PM_SDFFRS_X2%12_c7 VSS x_PM_SDFFRS_X2%12_17 1.3109e-16
C_x_PM_SDFFRS_X2%12_c8 VSS x_PM_SDFFRS_X2%12_14 5.78791e-17
C_x_PM_SDFFRS_X2%12_c9 VSS x_PM_SDFFRS_X2%12_12 3.60282e-17
C_x_PM_SDFFRS_X2%12_c10 VSS N_12_M37_g 2.09137e-17
C_x_PM_SDFFRS_X2%12_c11 VSS x_PM_SDFFRS_X2%12_6 5.25887e-18
C_x_PM_SDFFRS_X2%12_c12 VSS x_PM_SDFFRS_X2%12_5 2.47528e-17
C_x_PM_SDFFRS_X2%12_c13 VSS N_12_M9_g 4.19663e-17
R_x_PM_SDFFRS_X2%12_r14 x_PM_SDFFRS_X2%12_37 x_PM_SDFFRS_X2%12_34 0.302593
R_x_PM_SDFFRS_X2%12_r15 x_PM_SDFFRS_X2%12_42 x_PM_SDFFRS_X2%12_34 25.0012
R_x_PM_SDFFRS_X2%12_r16 x_PM_SDFFRS_X2%12_47 x_PM_SDFFRS_X2%12_31 4.7687
R_x_PM_SDFFRS_X2%12_r17 x_PM_SDFFRS_X2%12_31 x_PM_SDFFRS_X2%12_29 25.0012
R_x_PM_SDFFRS_X2%12_r18 x_PM_SDFFRS_X2%12_29 x_PM_SDFFRS_X2%12_28 1.24857
R_x_PM_SDFFRS_X2%12_r19 x_PM_SDFFRS_X2%12_37 x_PM_SDFFRS_X2%12_24 0.095
R_x_PM_SDFFRS_X2%12_r20 N_12_M13_d x_PM_SDFFRS_X2%12_24 0.312143
R_x_PM_SDFFRS_X2%12_r21 x_PM_SDFFRS_X2%12_28 x_PM_SDFFRS_X2%12_23 0.095
R_x_PM_SDFFRS_X2%12_r22 x_PM_SDFFRS_X2%12_41 x_PM_SDFFRS_X2%12_20 4.7687
R_x_PM_SDFFRS_X2%12_r23 x_PM_SDFFRS_X2%12_40 x_PM_SDFFRS_X2%12_20 4.7687
R_x_PM_SDFFRS_X2%12_r24 x_PM_SDFFRS_X2%12_20 x_PM_SDFFRS_X2%12_18 25.0012
R_x_PM_SDFFRS_X2%12_r25 x_PM_SDFFRS_X2%12_28 x_PM_SDFFRS_X2%12_17 0.366429
R_x_PM_SDFFRS_X2%12_r26 x_PM_SDFFRS_X2%12_18 x_PM_SDFFRS_X2%12_17 2.185
R_x_PM_SDFFRS_X2%12_r27 x_PM_SDFFRS_X2%12_23 N_12_M39_s 0.333213
R_x_PM_SDFFRS_X2%12_r28 x_PM_SDFFRS_X2%12_14 x_PM_SDFFRS_X2%12_42 4.7687
R_x_PM_SDFFRS_X2%12_r29 x_PM_SDFFRS_X2%12_14 x_PM_SDFFRS_X2%12_47 71.76
R_x_PM_SDFFRS_X2%12_r30 x_PM_SDFFRS_X2%12_12 x_PM_SDFFRS_X2%12_41 54.6
R_x_PM_SDFFRS_X2%12_r31 N_12_M37_g x_PM_SDFFRS_X2%12_40 14.82
R_x_PM_SDFFRS_X2%12_r32 x_PM_SDFFRS_X2%12_12 x_PM_SDFFRS_X2%12_5 4.35808
R_x_PM_SDFFRS_X2%12_r33 x_PM_SDFFRS_X2%12_6 x_PM_SDFFRS_X2%12_5 24.96
R_x_PM_SDFFRS_X2%12_r34 x_PM_SDFFRS_X2%12_6 x_PM_SDFFRS_X2%12_VSS 4.35808
R_x_PM_SDFFRS_X2%12_r35 N_12_M9_g x_PM_SDFFRS_X2%12_VSS 39.78
C_x_PM_SDFFRS_X2%SN_c0 VSS x_PM_SDFFRS_X2%SN_31 9.53708e-18
C_x_PM_SDFFRS_X2%SN_c1 VSS x_PM_SDFFRS_X2%SN_29 9.74629e-17
C_x_PM_SDFFRS_X2%SN_c2 VSS x_PM_SDFFRS_X2%SN_28 5.42033e-16
C_x_PM_SDFFRS_X2%SN_c3 VSS N_SN_M21_g 4.89542e-17
C_x_PM_SDFFRS_X2%SN_c4 VSS x_PM_SDFFRS_X2%SN_15 4.91039e-17
C_x_PM_SDFFRS_X2%SN_c5 VSS N_SN_M46_g 5.79339e-17
C_x_PM_SDFFRS_X2%SN_c6 VSS N_SN_M12_g 5.45974e-17
C_x_PM_SDFFRS_X2%SN_c7 VSS x_PM_SDFFRS_X2%SN_7 4.88015e-18
C_x_PM_SDFFRS_X2%SN_c8 VSS x_PM_SDFFRS_X2%SN_6 6.80686e-18
C_x_PM_SDFFRS_X2%SN_c9 VSS x_PM_SDFFRS_X2%SN_5 1.46091e-17
C_x_PM_SDFFRS_X2%SN_c10 VSS N_SN_M38_g 5.48406e-17
R_x_PM_SDFFRS_X2%SN_r11 x_PM_SDFFRS_X2%SN_35 x_PM_SDFFRS_X2%SN_31 3.38
R_x_PM_SDFFRS_X2%SN_r12 x_PM_SDFFRS_X2%SN_34 x_PM_SDFFRS_X2%SN_31 4.7687
R_x_PM_SDFFRS_X2%SN_r13 x_PM_SDFFRS_X2%SN_31 x_PM_SDFFRS_X2%SN_29 25.0012
R_x_PM_SDFFRS_X2%SN_r14 x_PM_SDFFRS_X2%SN_29 SN 0.288519
R_x_PM_SDFFRS_X2%SN_r15 x_PM_SDFFRS_X2%SN_28 SN 0.284786
R_x_PM_SDFFRS_X2%SN_r16 x_PM_SDFFRS_X2%SN_24 x_PM_SDFFRS_X2%SN_22 25.0012
R_x_PM_SDFFRS_X2%SN_r17 x_PM_SDFFRS_X2%SN_22 x_PM_SDFFRS_X2%SN_28 8.86214
R_x_PM_SDFFRS_X2%SN_r18 N_SN_M21_g x_PM_SDFFRS_X2%SN_17 38.22
R_x_PM_SDFFRS_X2%SN_r19 x_PM_SDFFRS_X2%SN_35 x_PM_SDFFRS_X2%SN_16 1.95
R_x_PM_SDFFRS_X2%SN_r20 x_PM_SDFFRS_X2%SN_17 x_PM_SDFFRS_X2%SN_15 4.35808
R_x_PM_SDFFRS_X2%SN_r21 x_PM_SDFFRS_X2%SN_16 x_PM_SDFFRS_X2%SN_15 48.36
R_x_PM_SDFFRS_X2%SN_r22 N_SN_M46_g x_PM_SDFFRS_X2%SN_34 56.16
R_x_PM_SDFFRS_X2%SN_r23 x_PM_SDFFRS_X2%SN_24 x_PM_SDFFRS_X2%SN_7 3.67098
R_x_PM_SDFFRS_X2%SN_r24 N_SN_M12_g x_PM_SDFFRS_X2%SN_7 39
R_x_PM_SDFFRS_X2%SN_r25 x_PM_SDFFRS_X2%SN_24 x_PM_SDFFRS_X2%SN_5 0.917744
R_x_PM_SDFFRS_X2%SN_r26 x_PM_SDFFRS_X2%SN_6 x_PM_SDFFRS_X2%SN_5 12.48
R_x_PM_SDFFRS_X2%SN_r27 x_PM_SDFFRS_X2%SN_6 x_PM_SDFFRS_X2%SN_VSS 4.58872
R_x_PM_SDFFRS_X2%SN_r28 N_SN_M38_g x_PM_SDFFRS_X2%SN_VSS 56.94
C_x_PM_SDFFRS_X2%14_c0 VSS x_PM_SDFFRS_X2%14_60 3.90645e-18
C_x_PM_SDFFRS_X2%14_c1 VSS x_PM_SDFFRS_X2%14_55 7.8258e-17
C_x_PM_SDFFRS_X2%14_c2 VSS x_PM_SDFFRS_X2%14_50 3.37558e-17
C_x_PM_SDFFRS_X2%14_c3 VSS x_PM_SDFFRS_X2%14_49 1.38554e-17
C_x_PM_SDFFRS_X2%14_c4 VSS N_14_M42_d 2.51949e-17
C_x_PM_SDFFRS_X2%14_c5 VSS x_PM_SDFFRS_X2%14_42 6.75705e-17
C_x_PM_SDFFRS_X2%14_c6 VSS x_PM_SDFFRS_X2%14_40 1.60559e-17
C_x_PM_SDFFRS_X2%14_c7 VSS x_PM_SDFFRS_X2%14_39 3.48291e-17
C_x_PM_SDFFRS_X2%14_c8 VSS x_PM_SDFFRS_X2%14_36 9.67575e-17
C_x_PM_SDFFRS_X2%14_c9 VSS x_PM_SDFFRS_X2%14_34 3.3993e-17
C_x_PM_SDFFRS_X2%14_c10 VSS x_PM_SDFFRS_X2%14_30 5.6193e-17
C_x_PM_SDFFRS_X2%14_c11 VSS x_PM_SDFFRS_X2%14_26 5.59412e-17
C_x_PM_SDFFRS_X2%14_c12 VSS x_PM_SDFFRS_X2%14_24 3.28756e-17
C_x_PM_SDFFRS_X2%14_c13 VSS x_PM_SDFFRS_X2%14_23 1.30438e-17
C_x_PM_SDFFRS_X2%14_c14 VSS x_PM_SDFFRS_X2%14_21 1.063e-17
C_x_PM_SDFFRS_X2%14_c15 VSS x_PM_SDFFRS_X2%14_20 6.69969e-17
C_x_PM_SDFFRS_X2%14_c16 VSS N_14_M15_s 2.83004e-17
C_x_PM_SDFFRS_X2%14_c17 VSS N_14_M22_g 4.25176e-17
C_x_PM_SDFFRS_X2%14_c18 VSS x_PM_SDFFRS_X2%14_8 1.23976e-17
C_x_PM_SDFFRS_X2%14_c19 VSS x_PM_SDFFRS_X2%14_6 7.56648e-18
C_x_PM_SDFFRS_X2%14_c20 VSS x_PM_SDFFRS_X2%14_5 4.19882e-17
C_x_PM_SDFFRS_X2%14_c21 VSS N_14_M47_g 4.36051e-17
R_x_PM_SDFFRS_X2%14_r22 N_14_M18_d x_PM_SDFFRS_X2%14_50 0.204074
R_x_PM_SDFFRS_X2%14_r23 x_PM_SDFFRS_X2%14_42 x_PM_SDFFRS_X2%14_40 1.26214
R_x_PM_SDFFRS_X2%14_r24 x_PM_SDFFRS_X2%14_40 x_PM_SDFFRS_X2%14_38 0.212317
R_x_PM_SDFFRS_X2%14_r25 x_PM_SDFFRS_X2%14_39 x_PM_SDFFRS_X2%14_38 1.11286
R_x_PM_SDFFRS_X2%14_r26 x_PM_SDFFRS_X2%14_50 x_PM_SDFFRS_X2%14_37 0.095
R_x_PM_SDFFRS_X2%14_r27 x_PM_SDFFRS_X2%14_39 x_PM_SDFFRS_X2%14_36 0.212317
R_x_PM_SDFFRS_X2%14_r28 x_PM_SDFFRS_X2%14_37 x_PM_SDFFRS_X2%14_36 1.68286
R_x_PM_SDFFRS_X2%14_r29 x_PM_SDFFRS_X2%14_49 x_PM_SDFFRS_X2%14_35 0.160909
R_x_PM_SDFFRS_X2%14_r30 x_PM_SDFFRS_X2%14_50 x_PM_SDFFRS_X2%14_34 0.095
R_x_PM_SDFFRS_X2%14_r31 x_PM_SDFFRS_X2%14_35 x_PM_SDFFRS_X2%14_34 1.73714
R_x_PM_SDFFRS_X2%14_r32 x_PM_SDFFRS_X2%14_32 x_PM_SDFFRS_X2%14_55 45.24
R_x_PM_SDFFRS_X2%14_r33 x_PM_SDFFRS_X2%14_32 x_PM_SDFFRS_X2%14_30 25.0012
R_x_PM_SDFFRS_X2%14_r34 x_PM_SDFFRS_X2%14_49 x_PM_SDFFRS_X2%14_29 0.0418175
R_x_PM_SDFFRS_X2%14_r35 x_PM_SDFFRS_X2%14_30 x_PM_SDFFRS_X2%14_29 0.936429
R_x_PM_SDFFRS_X2%14_r36 x_PM_SDFFRS_X2%14_55 x_PM_SDFFRS_X2%14_26 25.0012
R_x_PM_SDFFRS_X2%14_r37 x_PM_SDFFRS_X2%14_26 x_PM_SDFFRS_X2%14_24 0.936429
R_x_PM_SDFFRS_X2%14_r38 x_PM_SDFFRS_X2%14_24 x_PM_SDFFRS_X2%14_23 0.212317
R_x_PM_SDFFRS_X2%14_r39 x_PM_SDFFRS_X2%14_22 N_14_M42_d 0.30478
R_x_PM_SDFFRS_X2%14_r40 x_PM_SDFFRS_X2%14_23 x_PM_SDFFRS_X2%14_22 0.488571
R_x_PM_SDFFRS_X2%14_r41 x_PM_SDFFRS_X2%14_49 x_PM_SDFFRS_X2%14_20 0.160909
R_x_PM_SDFFRS_X2%14_r42 x_PM_SDFFRS_X2%14_21 x_PM_SDFFRS_X2%14_20 1.9
R_x_PM_SDFFRS_X2%14_r43 x_PM_SDFFRS_X2%14_21 x_PM_SDFFRS_X2%14_16 0.212317
R_x_PM_SDFFRS_X2%14_r44 N_14_M15_s x_PM_SDFFRS_X2%14_16 0.203571
R_x_PM_SDFFRS_X2%14_r45 N_14_M22_g x_PM_SDFFRS_X2%14_60 45.24
R_x_PM_SDFFRS_X2%14_r46 x_PM_SDFFRS_X2%14_8 x_PM_SDFFRS_X2%14_42 25.0012
R_x_PM_SDFFRS_X2%14_r47 x_PM_SDFFRS_X2%14_60 x_PM_SDFFRS_X2%14_8 4.7687
R_x_PM_SDFFRS_X2%14_r48 x_PM_SDFFRS_X2%14_8 x_PM_SDFFRS_X2%14_7 13.78
R_x_PM_SDFFRS_X2%14_r49 x_PM_SDFFRS_X2%14_7 x_PM_SDFFRS_X2%14_5 4.58872
R_x_PM_SDFFRS_X2%14_r50 x_PM_SDFFRS_X2%14_6 x_PM_SDFFRS_X2%14_5 50.7
R_x_PM_SDFFRS_X2%14_r51 x_PM_SDFFRS_X2%14_6 x_PM_SDFFRS_X2%14_VSS 4.35808
R_x_PM_SDFFRS_X2%14_r52 N_14_M47_g x_PM_SDFFRS_X2%14_VSS 39.78
C_x_PM_SDFFRS_X2%15_c0 VSS x_PM_SDFFRS_X2%15_52 1.49355e-17
C_x_PM_SDFFRS_X2%15_c1 VSS x_PM_SDFFRS_X2%15_50 1.55686e-16
C_x_PM_SDFFRS_X2%15_c2 VSS x_PM_SDFFRS_X2%15_43 1.01985e-16
C_x_PM_SDFFRS_X2%15_c3 VSS x_PM_SDFFRS_X2%15_41 9.87926e-17
C_x_PM_SDFFRS_X2%15_c4 VSS x_PM_SDFFRS_X2%15_39 1.27386e-17
C_x_PM_SDFFRS_X2%15_c5 VSS x_PM_SDFFRS_X2%15_36 1.05294e-16
C_x_PM_SDFFRS_X2%15_c6 VSS x_PM_SDFFRS_X2%15_33 3.2631e-18
C_x_PM_SDFFRS_X2%15_c7 VSS N_15_M25_g 3.7806e-17
C_x_PM_SDFFRS_X2%15_c8 VSS N_15_M50_g 2.3877e-17
C_x_PM_SDFFRS_X2%15_c9 VSS x_PM_SDFFRS_X2%15_24 5.14946e-18
C_x_PM_SDFFRS_X2%15_c10 VSS x_PM_SDFFRS_X2%15_23 1.86161e-17
C_x_PM_SDFFRS_X2%15_c11 VSS N_15_M24_g 2.6474e-17
C_x_PM_SDFFRS_X2%15_c12 VSS x_PM_SDFFRS_X2%15_18 8.0506e-18
C_x_PM_SDFFRS_X2%15_c13 VSS x_PM_SDFFRS_X2%15_17 1.54565e-17
C_x_PM_SDFFRS_X2%15_c14 VSS x_PM_SDFFRS_X2%15_16 1.52165e-17
C_x_PM_SDFFRS_X2%15_c15 VSS x_PM_SDFFRS_X2%15_13 2.16675e-17
C_x_PM_SDFFRS_X2%15_c16 VSS N_15_M49_g 2.39453e-17
C_x_PM_SDFFRS_X2%15_c17 VSS x_PM_SDFFRS_X2%15_9 4.8669e-18
C_x_PM_SDFFRS_X2%15_c18 VSS N_15_M17_g 9.58679e-17
C_x_PM_SDFFRS_X2%15_c19 VSS N_15_M44_g 1.96482e-17
R_x_PM_SDFFRS_X2%15_r20 x_PM_SDFFRS_X2%15_56 N_15_M47_d 0.0271429
R_x_PM_SDFFRS_X2%15_r21 N_15_M47_d x_PM_SDFFRS_X2%15_52 0.339286
R_x_PM_SDFFRS_X2%15_r22 x_PM_SDFFRS_X2%15_51 x_PM_SDFFRS_X2%15_50 25.0012
R_x_PM_SDFFRS_X2%15_r23 x_PM_SDFFRS_X2%15_50 x_PM_SDFFRS_X2%15_48 3.02643
R_x_PM_SDFFRS_X2%15_r24 x_PM_SDFFRS_X2%15_50 x_PM_SDFFRS_X2%15_47 0.0135714
R_x_PM_SDFFRS_X2%15_r25 x_PM_SDFFRS_X2%15_48 x_PM_SDFFRS_X2%15_43 0.212317
R_x_PM_SDFFRS_X2%15_r26 N_15_M21_d x_PM_SDFFRS_X2%15_43 1.34357
R_x_PM_SDFFRS_X2%15_r27 x_PM_SDFFRS_X2%15_52 x_PM_SDFFRS_X2%15_42 0.095
R_x_PM_SDFFRS_X2%15_r28 x_PM_SDFFRS_X2%15_47 x_PM_SDFFRS_X2%15_41 0.212317
R_x_PM_SDFFRS_X2%15_r29 x_PM_SDFFRS_X2%15_42 x_PM_SDFFRS_X2%15_41 2.03571
R_x_PM_SDFFRS_X2%15_r30 x_PM_SDFFRS_X2%15_39 x_PM_SDFFRS_X2%15_58 6.5
R_x_PM_SDFFRS_X2%15_r31 x_PM_SDFFRS_X2%15_39 x_PM_SDFFRS_X2%15_37 25.0012
R_x_PM_SDFFRS_X2%15_r32 x_PM_SDFFRS_X2%15_56 x_PM_SDFFRS_X2%15_36 0.095
R_x_PM_SDFFRS_X2%15_r33 x_PM_SDFFRS_X2%15_37 x_PM_SDFFRS_X2%15_36 3.078
R_x_PM_SDFFRS_X2%15_r34 N_15_M25_g x_PM_SDFFRS_X2%15_30 28.86
R_x_PM_SDFFRS_X2%15_r35 x_PM_SDFFRS_X2%15_33 x_PM_SDFFRS_X2%15_29 3.57286
R_x_PM_SDFFRS_X2%15_r36 N_15_M25_g x_PM_SDFFRS_X2%15_29 30.42
R_x_PM_SDFFRS_X2%15_r37 x_PM_SDFFRS_X2%15_33 x_PM_SDFFRS_X2%15_25 3.57286
R_x_PM_SDFFRS_X2%15_r38 N_15_M50_g x_PM_SDFFRS_X2%15_25 21.84
R_x_PM_SDFFRS_X2%15_r39 x_PM_SDFFRS_X2%15_30 x_PM_SDFFRS_X2%15_23 4.35808
R_x_PM_SDFFRS_X2%15_r40 x_PM_SDFFRS_X2%15_24 x_PM_SDFFRS_X2%15_23 15.6
R_x_PM_SDFFRS_X2%15_r41 x_PM_SDFFRS_X2%15_24 x_PM_SDFFRS_X2%15_19 4.35808
R_x_PM_SDFFRS_X2%15_r42 N_15_M24_g x_PM_SDFFRS_X2%15_19 18.33
R_x_PM_SDFFRS_X2%15_r43 x_PM_SDFFRS_X2%15_33 x_PM_SDFFRS_X2%15_17 0.640432
R_x_PM_SDFFRS_X2%15_r44 x_PM_SDFFRS_X2%15_18 x_PM_SDFFRS_X2%15_17 21.9818
R_x_PM_SDFFRS_X2%15_r45 x_PM_SDFFRS_X2%15_18 x_PM_SDFFRS_X2%15_16 4.35808
R_x_PM_SDFFRS_X2%15_r46 x_PM_SDFFRS_X2%15_16 x_PM_SDFFRS_X2%15_15 23.4
R_x_PM_SDFFRS_X2%15_r47 x_PM_SDFFRS_X2%15_51 x_PM_SDFFRS_X2%15_14 0.917744
R_x_PM_SDFFRS_X2%15_r48 x_PM_SDFFRS_X2%15_15 x_PM_SDFFRS_X2%15_13 4.4936
R_x_PM_SDFFRS_X2%15_r49 x_PM_SDFFRS_X2%15_14 x_PM_SDFFRS_X2%15_13 11.44
R_x_PM_SDFFRS_X2%15_r50 x_PM_SDFFRS_X2%15_51 x_PM_SDFFRS_X2%15_9 3.67098
R_x_PM_SDFFRS_X2%15_r51 N_15_M49_g x_PM_SDFFRS_X2%15_9 17.94
R_x_PM_SDFFRS_X2%15_r52 x_PM_SDFFRS_X2%15_58 x_PM_SDFFRS_X2%15_5 1.95
R_x_PM_SDFFRS_X2%15_r53 N_15_M17_g x_PM_SDFFRS_X2%15_5 115.44
R_x_PM_SDFFRS_X2%15_r54 x_PM_SDFFRS_X2%15_58 x_PM_SDFFRS_X2%15_VSS 1.95
R_x_PM_SDFFRS_X2%15_r55 N_15_M44_g x_PM_SDFFRS_X2%15_VSS 14.82
C_x_PM_SDFFRS_X2%RN_c0 VSS x_PM_SDFFRS_X2%RN_35 6.82002e-17
C_x_PM_SDFFRS_X2%RN_c1 VSS x_PM_SDFFRS_X2%RN_31 3.01228e-18
C_x_PM_SDFFRS_X2%RN_c2 VSS N_RN_M23_g 8.88962e-17
C_x_PM_SDFFRS_X2%RN_c3 VSS x_PM_SDFFRS_X2%RN_25 3.47918e-17
C_x_PM_SDFFRS_X2%RN_c4 VSS N_RN_M48_g 3.84312e-17
C_x_PM_SDFFRS_X2%RN_c5 VSS x_PM_SDFFRS_X2%RN_22 4.94397e-18
C_x_PM_SDFFRS_X2%RN_c6 VSS x_PM_SDFFRS_X2%RN_20 6.52386e-18
C_x_PM_SDFFRS_X2%RN_c7 VSS x_PM_SDFFRS_X2%RN_19 6.95882e-17
C_x_PM_SDFFRS_X2%RN_c8 VSS N_RN_M20_g 3.24321e-17
C_x_PM_SDFFRS_X2%RN_c9 VSS x_PM_SDFFRS_X2%RN_13 8.30274e-17
C_x_PM_SDFFRS_X2%RN_c10 VSS N_RN_M45_g 3.02053e-17
C_x_PM_SDFFRS_X2%RN_c11 VSS x_PM_SDFFRS_X2%RN_8 5.16355e-18
C_x_PM_SDFFRS_X2%RN_c12 VSS x_PM_SDFFRS_X2%RN_7 1.25009e-16
C_x_PM_SDFFRS_X2%RN_c13 VSS N_RN_M40_g 1.24189e-16
R_x_PM_SDFFRS_X2%RN_r14 x_PM_SDFFRS_X2%RN_37 x_PM_SDFFRS_X2%RN_35 25.0012
R_x_PM_SDFFRS_X2%RN_r15 x_PM_SDFFRS_X2%RN_35 RN 0.115357
R_x_PM_SDFFRS_X2%RN_r16 N_RN_M23_g x_PM_SDFFRS_X2%RN_28 23.01
R_x_PM_SDFFRS_X2%RN_r17 N_RN_M23_g x_PM_SDFFRS_X2%RN_27 94.77
R_x_PM_SDFFRS_X2%RN_r18 x_PM_SDFFRS_X2%RN_37 x_PM_SDFFRS_X2%RN_26 0.917744
R_x_PM_SDFFRS_X2%RN_r19 x_PM_SDFFRS_X2%RN_27 x_PM_SDFFRS_X2%RN_25 4.58872
R_x_PM_SDFFRS_X2%RN_r20 x_PM_SDFFRS_X2%RN_26 x_PM_SDFFRS_X2%RN_25 22.88
R_x_PM_SDFFRS_X2%RN_r21 x_PM_SDFFRS_X2%RN_37 x_PM_SDFFRS_X2%RN_22 3.67098
R_x_PM_SDFFRS_X2%RN_r22 N_RN_M48_g x_PM_SDFFRS_X2%RN_22 42.9
R_x_PM_SDFFRS_X2%RN_r23 N_RN_M48_g x_PM_SDFFRS_X2%RN_21 17.94
R_x_PM_SDFFRS_X2%RN_r24 x_PM_SDFFRS_X2%RN_28 x_PM_SDFFRS_X2%RN_19 4.35808
R_x_PM_SDFFRS_X2%RN_r25 x_PM_SDFFRS_X2%RN_20 x_PM_SDFFRS_X2%RN_19 85.8
R_x_PM_SDFFRS_X2%RN_r26 x_PM_SDFFRS_X2%RN_20 x_PM_SDFFRS_X2%RN_15 4.35808
R_x_PM_SDFFRS_X2%RN_r27 N_RN_M20_g x_PM_SDFFRS_X2%RN_15 21.84
R_x_PM_SDFFRS_X2%RN_r28 x_PM_SDFFRS_X2%RN_31 x_PM_SDFFRS_X2%RN_14 3.30287
R_x_PM_SDFFRS_X2%RN_r29 x_PM_SDFFRS_X2%RN_21 x_PM_SDFFRS_X2%RN_13 4.35808
R_x_PM_SDFFRS_X2%RN_r30 x_PM_SDFFRS_X2%RN_14 x_PM_SDFFRS_X2%RN_13 101.4
R_x_PM_SDFFRS_X2%RN_r31 x_PM_SDFFRS_X2%RN_31 x_PM_SDFFRS_X2%RN_9 0.858359
R_x_PM_SDFFRS_X2%RN_r32 N_RN_M45_g x_PM_SDFFRS_X2%RN_9 26.52
R_x_PM_SDFFRS_X2%RN_r33 x_PM_SDFFRS_X2%RN_31 x_PM_SDFFRS_X2%RN_7 3.30287
R_x_PM_SDFFRS_X2%RN_r34 x_PM_SDFFRS_X2%RN_8 x_PM_SDFFRS_X2%RN_7 155.22
R_x_PM_SDFFRS_X2%RN_r35 N_RN_M14_g N_RN_M40_g 130.26
R_x_PM_SDFFRS_X2%RN_r36 x_PM_SDFFRS_X2%RN_8 x_PM_SDFFRS_X2%RN_VSS 4.35808
R_x_PM_SDFFRS_X2%RN_r37 N_RN_M40_g x_PM_SDFFRS_X2%RN_VSS 26.52
C_x_PM_SDFFRS_X2%17_c0 VSS x_PM_SDFFRS_X2%17_22 7.06002e-17
C_x_PM_SDFFRS_X2%17_c1 VSS x_PM_SDFFRS_X2%17_16 2.3332e-16
C_x_PM_SDFFRS_X2%17_c2 VSS N_17_M23_d 3.14359e-17
C_x_PM_SDFFRS_X2%17_c3 VSS x_PM_SDFFRS_X2%17_11 4.57813e-18
C_x_PM_SDFFRS_X2%17_c4 VSS N_17_M51_g 9.44026e-17
C_x_PM_SDFFRS_X2%17_c5 VSS x_PM_SDFFRS_X2%17_2 9.65022e-18
C_x_PM_SDFFRS_X2%17_c6 VSS x_PM_SDFFRS_X2%17_VSS 3.71691e-17
R_x_PM_SDFFRS_X2%17_r7 x_PM_SDFFRS_X2%17_26 x_PM_SDFFRS_X2%17_22 25.0012
R_x_PM_SDFFRS_X2%17_r8 x_PM_SDFFRS_X2%17_22 x_PM_SDFFRS_X2%17_20 0.475
R_x_PM_SDFFRS_X2%17_r9 x_PM_SDFFRS_X2%17_20 N_17_M49_d 0.285
R_x_PM_SDFFRS_X2%17_r10 x_PM_SDFFRS_X2%17_20 x_PM_SDFFRS_X2%17_15 0.095
R_x_PM_SDFFRS_X2%17_r11 x_PM_SDFFRS_X2%17_16 x_PM_SDFFRS_X2%17_15 4.58714
R_x_PM_SDFFRS_X2%17_r12 x_PM_SDFFRS_X2%17_16 x_PM_SDFFRS_X2%17_11 0.202958
R_x_PM_SDFFRS_X2%17_r13 N_17_M23_d x_PM_SDFFRS_X2%17_11 0.111765
R_x_PM_SDFFRS_X2%17_r14 N_17_M26_g N_17_M51_g 60.84
R_x_PM_SDFFRS_X2%17_r15 N_17_M51_g x_PM_SDFFRS_X2%17_3 34.32
R_x_PM_SDFFRS_X2%17_r16 x_PM_SDFFRS_X2%17_2 x_PM_SDFFRS_X2%17_26 4.7687
R_x_PM_SDFFRS_X2%17_r17 x_PM_SDFFRS_X2%17_3 x_PM_SDFFRS_X2%17_VSS 4.35808
R_x_PM_SDFFRS_X2%17_r18 x_PM_SDFFRS_X2%17_2 x_PM_SDFFRS_X2%17_VSS 41.34
C_x_PM_SDFFRS_X2%QN_c0 VSS x_PM_SDFFRS_X2%QN_13 1.22637e-17
C_x_PM_SDFFRS_X2%QN_c1 VSS N_QN_M25_s 8.71257e-17
C_x_PM_SDFFRS_X2%QN_c2 VSS N_QN_M50_s 4.00616e-17
R_x_PM_SDFFRS_X2%QN_r3 N_QN_M25_s x_PM_SDFFRS_X2%QN_13 1.56071
R_x_PM_SDFFRS_X2%QN_r4 QN N_QN_M50_s 0.0738889
R_x_PM_SDFFRS_X2%QN_r5 x_PM_SDFFRS_X2%QN_13 x_PM_SDFFRS_X2%QN_3 0.20978
R_x_PM_SDFFRS_X2%QN_r6 QN x_PM_SDFFRS_X2%QN_3 0.105556
C_x_PM_SDFFRS_X2%Q_c0 VSS N_Q_M51_d 9.09447e-17
R_x_PM_SDFFRS_X2%Q_r1 N_Q_M26_d Q 0.87
R_x_PM_SDFFRS_X2%Q_r2 Q N_Q_M51_d 0.69
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X1 VSS VDD QN Q RN CK D SE SI
*.PININFO VSS:B VDD:B QN:O Q:O RN:I CK:I D:I SE:I SI:I
M_M21 N_VDD_M0_d N_5_M0_g N_QN_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M22 N_Q_M1_d N_6_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M23 N_VDD_M2_d N_6_M2_g N_5_M2_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 18 N_5_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M25 N_6_M4_d N_7_M4_g 18 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 19 N_7_M5_g N_6_M4_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M27 N_VDD_M6_d N_RN_M6_g 19 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M28 20 N_10_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M29 N_6_M8_d N_8_M8_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M30 N_VDD_M9_d N_8_M9_g N_7_M9_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M31 N_11_M10_d N_10_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 N_VDD_M11_d N_RN_M11_g N_11_M10_d VDD PMOS_VTL W=0.225000U L=0.050000U
M_M33 21 N_11_M12_g N_VDD_M11_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M34 N_10_M13_d N_8_M13_g 21 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 22 N_7_M14_g N_10_M13_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M36 N_VDD_M15_d N_12_M15_g 22 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M37 N_8_M16_d N_CK_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M38 23 N_SI_M17_g N_VDD_M17_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M39 N_12_M18_d N_15_M18_g 23 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M40 24 N_SE_M19_g N_12_M18_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M41 N_VDD_M20_d N_D_M20_g 24 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M42 N_15_M21_d N_SE_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M22_d N_5_M22_g N_QN_M22_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_Q_M23_d N_6_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_VSS_M24_d N_6_M24_g N_5_M24_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M3 25 N_5_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 26 N_RN_M26_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 N_6_M27_d N_8_M27_g 26 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 27 N_7_M28_g N_6_M27_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_VSS_M29_d N_10_M29_g 27 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_7_M30_d N_8_M30_g N_VSS_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 28 N_10_M31_g N_11_M31_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_VSS_M32_d N_RN_M32_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 29 N_11_M33_g N_VSS_M32_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_10_M34_d N_7_M34_g 29 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 30 N_8_M35_g N_10_M34_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M14 N_VSS_M36_d N_12_M36_g 30 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_8_M37_d N_CK_M37_g N_VSS_M36_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M16 31 N_D_M38_g N_VSS_M38_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_12_M39_d N_15_M39_g 31 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 32 N_SE_M40_g N_12_M39_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M19 N_VSS_M41_d N_SI_M41_g 32 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M20 N_15_M42_d N_SE_M42_g N_VSS_M41_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFFR_X1%VSS_c0 VSS x_PM_SDFFR_X1%VSS_60 2.74807e-18
C_x_PM_SDFFR_X1%VSS_c1 VSS x_PM_SDFFR_X1%VSS_59 4.6069e-18
C_x_PM_SDFFR_X1%VSS_c2 VSS x_PM_SDFFR_X1%VSS_58 2.87898e-18
C_x_PM_SDFFR_X1%VSS_c3 VSS x_PM_SDFFR_X1%VSS_53 4.32501e-17
C_x_PM_SDFFR_X1%VSS_c4 VSS x_PM_SDFFR_X1%VSS_52 2.87898e-18
C_x_PM_SDFFR_X1%VSS_c5 VSS x_PM_SDFFR_X1%VSS_51 2.87898e-18
C_x_PM_SDFFR_X1%VSS_c6 VSS x_PM_SDFFR_X1%VSS_50 3.96798e-17
C_x_PM_SDFFR_X1%VSS_c7 VSS VSS 2.96717e-17
C_x_PM_SDFFR_X1%VSS_c8 VSS N_VSS_M41_d 3.89627e-17
C_x_PM_SDFFR_X1%VSS_c9 VSS x_PM_SDFFR_X1%VSS_40 7.87374e-17
C_x_PM_SDFFR_X1%VSS_c10 VSS N_VSS_M38_s 3.87485e-17
C_x_PM_SDFFR_X1%VSS_c11 VSS x_PM_SDFFR_X1%VSS_34 3.13204e-17
C_x_PM_SDFFR_X1%VSS_c12 VSS N_VSS_M36_d 2.8022e-17
C_x_PM_SDFFR_X1%VSS_c13 VSS x_PM_SDFFR_X1%VSS_28 7.04753e-17
C_x_PM_SDFFR_X1%VSS_c14 VSS x_PM_SDFFR_X1%VSS_26 9.92414e-17
C_x_PM_SDFFR_X1%VSS_c15 VSS N_VSS_M29_d 3.04142e-17
C_x_PM_SDFFR_X1%VSS_c16 VSS x_PM_SDFFR_X1%VSS_20 1.46768e-16
C_x_PM_SDFFR_X1%VSS_c17 VSS N_VSS_M24_d 2.07559e-17
C_x_PM_SDFFR_X1%VSS_c18 VSS x_PM_SDFFR_X1%VSS_14 5.75091e-17
C_x_PM_SDFFR_X1%VSS_c19 VSS N_VSS_M22_d 2.89186e-17
R_x_PM_SDFFR_X1%VSS_r20 N_VSS_M32_d x_PM_SDFFR_X1%VSS_53 0.471481
R_x_PM_SDFFR_X1%VSS_r21 x_PM_SDFFR_X1%VSS_60 x_PM_SDFFR_X1%VSS_46 0.0731438
R_x_PM_SDFFR_X1%VSS_r22 VSS x_PM_SDFFR_X1%VSS_46 0.670588
R_x_PM_SDFFR_X1%VSS_r23 x_PM_SDFFR_X1%VSS_60 x_PM_SDFFR_X1%VSS_42 0.145286
R_x_PM_SDFFR_X1%VSS_r24 N_VSS_M41_d x_PM_SDFFR_X1%VSS_42 0.909286
R_x_PM_SDFFR_X1%VSS_r25 x_PM_SDFFR_X1%VSS_59 x_PM_SDFFR_X1%VSS_41 0.0731438
R_x_PM_SDFFR_X1%VSS_r26 x_PM_SDFFR_X1%VSS_60 x_PM_SDFFR_X1%VSS_40 0.0731438
R_x_PM_SDFFR_X1%VSS_r27 x_PM_SDFFR_X1%VSS_41 x_PM_SDFFR_X1%VSS_40 1.53118
R_x_PM_SDFFR_X1%VSS_r28 x_PM_SDFFR_X1%VSS_59 x_PM_SDFFR_X1%VSS_36 0.145286
R_x_PM_SDFFR_X1%VSS_r29 N_VSS_M38_s x_PM_SDFFR_X1%VSS_36 0.909286
R_x_PM_SDFFR_X1%VSS_r30 x_PM_SDFFR_X1%VSS_58 x_PM_SDFFR_X1%VSS_35 0.0731438
R_x_PM_SDFFR_X1%VSS_r31 x_PM_SDFFR_X1%VSS_59 x_PM_SDFFR_X1%VSS_34 0.0731438
R_x_PM_SDFFR_X1%VSS_r32 x_PM_SDFFR_X1%VSS_35 x_PM_SDFFR_X1%VSS_34 0.771176
R_x_PM_SDFFR_X1%VSS_r33 x_PM_SDFFR_X1%VSS_58 x_PM_SDFFR_X1%VSS_30 0.145286
R_x_PM_SDFFR_X1%VSS_r34 N_VSS_M36_d x_PM_SDFFR_X1%VSS_30 0.447857
R_x_PM_SDFFR_X1%VSS_r35 x_PM_SDFFR_X1%VSS_53 x_PM_SDFFR_X1%VSS_29 0.095
R_x_PM_SDFFR_X1%VSS_r36 x_PM_SDFFR_X1%VSS_58 x_PM_SDFFR_X1%VSS_28 0.0731438
R_x_PM_SDFFR_X1%VSS_r37 x_PM_SDFFR_X1%VSS_29 x_PM_SDFFR_X1%VSS_28 1.49765
R_x_PM_SDFFR_X1%VSS_r38 x_PM_SDFFR_X1%VSS_52 x_PM_SDFFR_X1%VSS_27 0.0731438
R_x_PM_SDFFR_X1%VSS_r39 x_PM_SDFFR_X1%VSS_53 x_PM_SDFFR_X1%VSS_26 0.095
R_x_PM_SDFFR_X1%VSS_r40 x_PM_SDFFR_X1%VSS_27 x_PM_SDFFR_X1%VSS_26 1.81059
R_x_PM_SDFFR_X1%VSS_r41 x_PM_SDFFR_X1%VSS_52 x_PM_SDFFR_X1%VSS_22 0.145286
R_x_PM_SDFFR_X1%VSS_r42 N_VSS_M29_d x_PM_SDFFR_X1%VSS_22 0.447857
R_x_PM_SDFFR_X1%VSS_r43 x_PM_SDFFR_X1%VSS_51 x_PM_SDFFR_X1%VSS_21 0.0731438
R_x_PM_SDFFR_X1%VSS_r44 x_PM_SDFFR_X1%VSS_52 x_PM_SDFFR_X1%VSS_20 0.0731438
R_x_PM_SDFFR_X1%VSS_r45 x_PM_SDFFR_X1%VSS_21 x_PM_SDFFR_X1%VSS_20 1.95588
R_x_PM_SDFFR_X1%VSS_r46 x_PM_SDFFR_X1%VSS_51 x_PM_SDFFR_X1%VSS_16 0.145286
R_x_PM_SDFFR_X1%VSS_r47 N_VSS_M24_d x_PM_SDFFR_X1%VSS_16 0.447857
R_x_PM_SDFFR_X1%VSS_r48 x_PM_SDFFR_X1%VSS_50 x_PM_SDFFR_X1%VSS_15 0.0731438
R_x_PM_SDFFR_X1%VSS_r49 x_PM_SDFFR_X1%VSS_51 x_PM_SDFFR_X1%VSS_14 0.0731438
R_x_PM_SDFFR_X1%VSS_r50 x_PM_SDFFR_X1%VSS_15 x_PM_SDFFR_X1%VSS_14 1.02824
R_x_PM_SDFFR_X1%VSS_r51 x_PM_SDFFR_X1%VSS_50 x_PM_SDFFR_X1%VSS_10 0.145286
R_x_PM_SDFFR_X1%VSS_r52 N_VSS_M22_d x_PM_SDFFR_X1%VSS_10 0.637857
C_x_PM_SDFFR_X1%VDD_c0 VSS x_PM_SDFFR_X1%VDD_65 3.37819e-17
C_x_PM_SDFFR_X1%VDD_c1 VSS x_PM_SDFFR_X1%VDD_64 2.77058e-18
C_x_PM_SDFFR_X1%VDD_c2 VSS x_PM_SDFFR_X1%VDD_63 2.96617e-18
C_x_PM_SDFFR_X1%VDD_c3 VSS x_PM_SDFFR_X1%VDD_62 2.92048e-18
C_x_PM_SDFFR_X1%VDD_c4 VSS x_PM_SDFFR_X1%VDD_61 2.96617e-18
C_x_PM_SDFFR_X1%VDD_c5 VSS x_PM_SDFFR_X1%VDD_60 3.65559e-17
C_x_PM_SDFFR_X1%VDD_c6 VSS x_PM_SDFFR_X1%VDD_56 2.92629e-18
C_x_PM_SDFFR_X1%VDD_c7 VSS x_PM_SDFFR_X1%VDD_55 2.99782e-18
C_x_PM_SDFFR_X1%VDD_c8 VSS N_VDD_M20_d 3.65096e-17
C_x_PM_SDFFR_X1%VDD_c9 VSS x_PM_SDFFR_X1%VDD_47 6.11268e-17
C_x_PM_SDFFR_X1%VDD_c10 VSS N_VDD_M17_s 3.22991e-17
C_x_PM_SDFFR_X1%VDD_c11 VSS x_PM_SDFFR_X1%VDD_41 2.03632e-17
C_x_PM_SDFFR_X1%VDD_c12 VSS N_VDD_M15_d 4.47727e-17
C_x_PM_SDFFR_X1%VDD_c13 VSS x_PM_SDFFR_X1%VDD_35 1.062e-16
C_x_PM_SDFFR_X1%VDD_c14 VSS N_VDD_M11_d 2.85851e-17
C_x_PM_SDFFR_X1%VDD_c15 VSS x_PM_SDFFR_X1%VDD_29 2.1432e-17
C_x_PM_SDFFR_X1%VDD_c16 VSS N_VDD_M9_d 4.4399e-17
C_x_PM_SDFFR_X1%VDD_c17 VSS x_PM_SDFFR_X1%VDD_23 8.91296e-17
C_x_PM_SDFFR_X1%VDD_c18 VSS x_PM_SDFFR_X1%VDD_21 9.89431e-17
C_x_PM_SDFFR_X1%VDD_c19 VSS x_PM_SDFFR_X1%VDD_20 4.06974e-17
C_x_PM_SDFFR_X1%VDD_c20 VSS x_PM_SDFFR_X1%VDD_17 3.8635e-17
C_x_PM_SDFFR_X1%VDD_c21 VSS N_VDD_M0_d 4.44165e-17
C_x_PM_SDFFR_X1%VDD_c22 VSS x_PM_SDFFR_X1%VDD_9 2.20836e-17
R_x_PM_SDFFR_X1%VDD_r23 x_PM_SDFFR_X1%VDD_60 N_VDD_M6_d 0.137322
R_x_PM_SDFFR_X1%VDD_r24 x_PM_SDFFR_X1%VDD_65 x_PM_SDFFR_X1%VDD_49 0.145286
R_x_PM_SDFFR_X1%VDD_r25 N_VDD_M20_d x_PM_SDFFR_X1%VDD_49 0.230714
R_x_PM_SDFFR_X1%VDD_r26 x_PM_SDFFR_X1%VDD_64 x_PM_SDFFR_X1%VDD_48 0.0731438
R_x_PM_SDFFR_X1%VDD_r27 x_PM_SDFFR_X1%VDD_65 x_PM_SDFFR_X1%VDD_47 0.0731438
R_x_PM_SDFFR_X1%VDD_r28 x_PM_SDFFR_X1%VDD_48 x_PM_SDFFR_X1%VDD_47 1.54235
R_x_PM_SDFFR_X1%VDD_r29 x_PM_SDFFR_X1%VDD_64 x_PM_SDFFR_X1%VDD_43 0.145286
R_x_PM_SDFFR_X1%VDD_r30 N_VDD_M17_s x_PM_SDFFR_X1%VDD_43 0.230714
R_x_PM_SDFFR_X1%VDD_r31 x_PM_SDFFR_X1%VDD_63 x_PM_SDFFR_X1%VDD_42 0.0731438
R_x_PM_SDFFR_X1%VDD_r32 x_PM_SDFFR_X1%VDD_64 x_PM_SDFFR_X1%VDD_41 0.0731438
R_x_PM_SDFFR_X1%VDD_r33 x_PM_SDFFR_X1%VDD_42 x_PM_SDFFR_X1%VDD_41 0.715294
R_x_PM_SDFFR_X1%VDD_r34 x_PM_SDFFR_X1%VDD_63 x_PM_SDFFR_X1%VDD_37 0.145286
R_x_PM_SDFFR_X1%VDD_r35 N_VDD_M15_d x_PM_SDFFR_X1%VDD_37 1.37071
R_x_PM_SDFFR_X1%VDD_r36 x_PM_SDFFR_X1%VDD_62 x_PM_SDFFR_X1%VDD_36 0.0731438
R_x_PM_SDFFR_X1%VDD_r37 x_PM_SDFFR_X1%VDD_63 x_PM_SDFFR_X1%VDD_35 0.0731438
R_x_PM_SDFFR_X1%VDD_r38 x_PM_SDFFR_X1%VDD_36 x_PM_SDFFR_X1%VDD_35 1.57588
R_x_PM_SDFFR_X1%VDD_r39 x_PM_SDFFR_X1%VDD_62 x_PM_SDFFR_X1%VDD_31 0.145286
R_x_PM_SDFFR_X1%VDD_r40 N_VDD_M11_d x_PM_SDFFR_X1%VDD_31 0.637857
R_x_PM_SDFFR_X1%VDD_r41 x_PM_SDFFR_X1%VDD_61 x_PM_SDFFR_X1%VDD_30 0.0731438
R_x_PM_SDFFR_X1%VDD_r42 x_PM_SDFFR_X1%VDD_62 x_PM_SDFFR_X1%VDD_29 0.0731438
R_x_PM_SDFFR_X1%VDD_r43 x_PM_SDFFR_X1%VDD_30 x_PM_SDFFR_X1%VDD_29 0.692941
R_x_PM_SDFFR_X1%VDD_r44 x_PM_SDFFR_X1%VDD_61 x_PM_SDFFR_X1%VDD_25 0.145286
R_x_PM_SDFFR_X1%VDD_r45 N_VDD_M9_d x_PM_SDFFR_X1%VDD_25 1.37071
R_x_PM_SDFFR_X1%VDD_r46 x_PM_SDFFR_X1%VDD_61 x_PM_SDFFR_X1%VDD_23 0.0731438
R_x_PM_SDFFR_X1%VDD_r47 x_PM_SDFFR_X1%VDD_60 x_PM_SDFFR_X1%VDD_23 1.44176
R_x_PM_SDFFR_X1%VDD_r48 x_PM_SDFFR_X1%VDD_56 x_PM_SDFFR_X1%VDD_22 0.0731438
R_x_PM_SDFFR_X1%VDD_r49 x_PM_SDFFR_X1%VDD_21 N_VDD_M6_d 0.137322
R_x_PM_SDFFR_X1%VDD_r50 x_PM_SDFFR_X1%VDD_22 x_PM_SDFFR_X1%VDD_21 1.52
R_x_PM_SDFFR_X1%VDD_r51 x_PM_SDFFR_X1%VDD_56 x_PM_SDFFR_X1%VDD_20 0.145286
R_x_PM_SDFFR_X1%VDD_r52 x_PM_SDFFR_X1%VDD_20 N_VDD_M2_d 0.543196
R_x_PM_SDFFR_X1%VDD_r53 x_PM_SDFFR_X1%VDD_55 x_PM_SDFFR_X1%VDD_18 0.0731438
R_x_PM_SDFFR_X1%VDD_r54 x_PM_SDFFR_X1%VDD_56 x_PM_SDFFR_X1%VDD_17 0.0731438
R_x_PM_SDFFR_X1%VDD_r55 x_PM_SDFFR_X1%VDD_18 x_PM_SDFFR_X1%VDD_17 0.972353
R_x_PM_SDFFR_X1%VDD_r56 x_PM_SDFFR_X1%VDD_55 x_PM_SDFFR_X1%VDD_13 0.145286
R_x_PM_SDFFR_X1%VDD_r57 N_VDD_M0_d x_PM_SDFFR_X1%VDD_13 2.02214
R_x_PM_SDFFR_X1%VDD_r58 x_PM_SDFFR_X1%VDD_55 x_PM_SDFFR_X1%VDD_9 0.0731438
R_x_PM_SDFFR_X1%VDD_r59 VDD x_PM_SDFFR_X1%VDD_9 0.257059
C_x_PM_SDFFR_X1%QN_c0 VSS N_QN_M22_s 9.86773e-17
R_x_PM_SDFFR_X1%QN_r1 N_QN_M0_s QN 1.86437
R_x_PM_SDFFR_X1%QN_r2 QN N_QN_M22_s 1.29437
C_x_PM_SDFFR_X1%Q_c0 VSS x_PM_SDFFR_X1%Q_13 1.11315e-17
C_x_PM_SDFFR_X1%Q_c1 VSS N_Q_M1_d 1.17012e-16
C_x_PM_SDFFR_X1%Q_c2 VSS N_Q_M23_d 8.02416e-17
R_x_PM_SDFFR_X1%Q_r3 N_Q_M1_d x_PM_SDFFR_X1%Q_13 2.51071
R_x_PM_SDFFR_X1%Q_r4 Q N_Q_M23_d 0.559444
R_x_PM_SDFFR_X1%Q_r5 x_PM_SDFFR_X1%Q_13 x_PM_SDFFR_X1%Q_3 0.20978
R_x_PM_SDFFR_X1%Q_r6 Q x_PM_SDFFR_X1%Q_3 0.105556
C_x_PM_SDFFR_X1%5_c0 VSS N_5_M24_s 1.34072e-16
C_x_PM_SDFFR_X1%5_c1 VSS x_PM_SDFFR_X1%5_25 1.42406e-16
C_x_PM_SDFFR_X1%5_c2 VSS x_PM_SDFFR_X1%5_23 2.53806e-17
C_x_PM_SDFFR_X1%5_c3 VSS x_PM_SDFFR_X1%5_20 6.38128e-18
C_x_PM_SDFFR_X1%5_c4 VSS x_PM_SDFFR_X1%5_19 6.66112e-17
C_x_PM_SDFFR_X1%5_c5 VSS x_PM_SDFFR_X1%5_18 6.80144e-18
C_x_PM_SDFFR_X1%5_c6 VSS N_5_M25_g 5.85533e-17
C_x_PM_SDFFR_X1%5_c7 VSS N_5_M3_g 6.5446e-17
C_x_PM_SDFFR_X1%5_c8 VSS N_5_M0_g 3.66849e-17
C_x_PM_SDFFR_X1%5_c9 VSS N_5_M22_g 6.50744e-17
R_x_PM_SDFFR_X1%5_r10 N_5_M24_s x_PM_SDFFR_X1%5_34 1.28929
R_x_PM_SDFFR_X1%5_r11 N_5_M2_s x_PM_SDFFR_X1%5_25 2.63286
R_x_PM_SDFFR_X1%5_r12 x_PM_SDFFR_X1%5_36 x_PM_SDFFR_X1%5_25 25.0012
R_x_PM_SDFFR_X1%5_r13 x_PM_SDFFR_X1%5_23 x_PM_SDFFR_X1%5_34 0.38
R_x_PM_SDFFR_X1%5_r14 x_PM_SDFFR_X1%5_25 x_PM_SDFFR_X1%5_23 0.0678571
R_x_PM_SDFFR_X1%5_r15 x_PM_SDFFR_X1%5_36 x_PM_SDFFR_X1%5_19 26.78
R_x_PM_SDFFR_X1%5_r16 x_PM_SDFFR_X1%5_20 x_PM_SDFFR_X1%5_19 0.043368
R_x_PM_SDFFR_X1%5_r17 x_PM_SDFFR_X1%5_36 x_PM_SDFFR_X1%5_17 40.3
R_x_PM_SDFFR_X1%5_r18 x_PM_SDFFR_X1%5_18 x_PM_SDFFR_X1%5_17 0.043368
R_x_PM_SDFFR_X1%5_r19 x_PM_SDFFR_X1%5_20 x_PM_SDFFR_X1%5_13 4.56151
R_x_PM_SDFFR_X1%5_r20 N_5_M25_g x_PM_SDFFR_X1%5_13 73.32
R_x_PM_SDFFR_X1%5_r21 x_PM_SDFFR_X1%5_20 x_PM_SDFFR_X1%5_9 4.56151
R_x_PM_SDFFR_X1%5_r22 N_5_M3_g x_PM_SDFFR_X1%5_9 70.98
R_x_PM_SDFFR_X1%5_r23 x_PM_SDFFR_X1%5_18 x_PM_SDFFR_X1%5_5 4.56151
R_x_PM_SDFFR_X1%5_r24 N_5_M0_g x_PM_SDFFR_X1%5_5 30.03
R_x_PM_SDFFR_X1%5_r25 x_PM_SDFFR_X1%5_18 x_PM_SDFFR_X1%5_VSS 4.56151
R_x_PM_SDFFR_X1%5_r26 N_5_M22_g x_PM_SDFFR_X1%5_VSS 67.86
C_x_PM_SDFFR_X1%6_c0 VSS x_PM_SDFFR_X1%6_51 1.99023e-17
C_x_PM_SDFFR_X1%6_c1 VSS x_PM_SDFFR_X1%6_47 2.11269e-17
C_x_PM_SDFFR_X1%6_c2 VSS x_PM_SDFFR_X1%6_45 4.25193e-17
C_x_PM_SDFFR_X1%6_c3 VSS N_6_M8_d 2.79505e-16
C_x_PM_SDFFR_X1%6_c4 VSS x_PM_SDFFR_X1%6_39 1.95189e-17
C_x_PM_SDFFR_X1%6_c5 VSS x_PM_SDFFR_X1%6_35 2.73962e-17
C_x_PM_SDFFR_X1%6_c6 VSS x_PM_SDFFR_X1%6_34 1.26274e-17
C_x_PM_SDFFR_X1%6_c7 VSS x_PM_SDFFR_X1%6_32 1.37147e-16
C_x_PM_SDFFR_X1%6_c8 VSS x_PM_SDFFR_X1%6_29 2.29699e-17
C_x_PM_SDFFR_X1%6_c9 VSS x_PM_SDFFR_X1%6_27 1.00135e-17
C_x_PM_SDFFR_X1%6_c10 VSS x_PM_SDFFR_X1%6_25 8.42676e-17
C_x_PM_SDFFR_X1%6_c11 VSS N_6_M27_d 1.16798e-16
C_x_PM_SDFFR_X1%6_c12 VSS N_6_M24_g 4.30047e-17
C_x_PM_SDFFR_X1%6_c13 VSS N_6_M2_g 2.37077e-17
C_x_PM_SDFFR_X1%6_c14 VSS x_PM_SDFFR_X1%6_12 6.6787e-18
C_x_PM_SDFFR_X1%6_c15 VSS x_PM_SDFFR_X1%6_11 2.94974e-17
C_x_PM_SDFFR_X1%6_c16 VSS x_PM_SDFFR_X1%6_10 6.93133e-18
C_x_PM_SDFFR_X1%6_c17 VSS x_PM_SDFFR_X1%6_9 3.74857e-17
C_x_PM_SDFFR_X1%6_c18 VSS N_6_M1_g 2.95851e-17
C_x_PM_SDFFR_X1%6_c19 VSS N_6_M23_g 4.04296e-17
R_x_PM_SDFFR_X1%6_r20 x_PM_SDFFR_X1%6_55 x_PM_SDFFR_X1%6_54 4.00759
R_x_PM_SDFFR_X1%6_r21 x_PM_SDFFR_X1%6_54 x_PM_SDFFR_X1%6_47 5.38571
R_x_PM_SDFFR_X1%6_r22 x_PM_SDFFR_X1%6_47 x_PM_SDFFR_X1%6_45 25.0012
R_x_PM_SDFFR_X1%6_r23 x_PM_SDFFR_X1%6_49 x_PM_SDFFR_X1%6_45 0.137222
R_x_PM_SDFFR_X1%6_r24 x_PM_SDFFR_X1%6_48 x_PM_SDFFR_X1%6_45 0.30478
R_x_PM_SDFFR_X1%6_r25 N_6_M8_d N_6_M4_d 4.39714
R_x_PM_SDFFR_X1%6_r26 N_6_M4_d x_PM_SDFFR_X1%6_39 0.529286
R_x_PM_SDFFR_X1%6_r27 x_PM_SDFFR_X1%6_39 x_PM_SDFFR_X1%6_34 0.212317
R_x_PM_SDFFR_X1%6_r28 x_PM_SDFFR_X1%6_51 x_PM_SDFFR_X1%6_33 0.160909
R_x_PM_SDFFR_X1%6_r29 x_PM_SDFFR_X1%6_34 x_PM_SDFFR_X1%6_33 0.515714
R_x_PM_SDFFR_X1%6_r30 x_PM_SDFFR_X1%6_51 x_PM_SDFFR_X1%6_32 0.160909
R_x_PM_SDFFR_X1%6_r31 x_PM_SDFFR_X1%6_35 x_PM_SDFFR_X1%6_31 0.212317
R_x_PM_SDFFR_X1%6_r32 x_PM_SDFFR_X1%6_32 x_PM_SDFFR_X1%6_31 4.12571
R_x_PM_SDFFR_X1%6_r33 x_PM_SDFFR_X1%6_49 x_PM_SDFFR_X1%6_30 0.095
R_x_PM_SDFFR_X1%6_r34 x_PM_SDFFR_X1%6_51 x_PM_SDFFR_X1%6_29 0.0418175
R_x_PM_SDFFR_X1%6_r35 x_PM_SDFFR_X1%6_30 x_PM_SDFFR_X1%6_29 1.11286
R_x_PM_SDFFR_X1%6_r36 x_PM_SDFFR_X1%6_27 x_PM_SDFFR_X1%6_56 3.9
R_x_PM_SDFFR_X1%6_r37 x_PM_SDFFR_X1%6_27 x_PM_SDFFR_X1%6_25 25.0012
R_x_PM_SDFFR_X1%6_r38 x_PM_SDFFR_X1%6_25 x_PM_SDFFR_X1%6_48 2.32071
R_x_PM_SDFFR_X1%6_r39 N_6_M27_d x_PM_SDFFR_X1%6_35 1.69643
R_x_PM_SDFFR_X1%6_r40 x_PM_SDFFR_X1%6_56 x_PM_SDFFR_X1%6_17 1.95
R_x_PM_SDFFR_X1%6_r41 N_6_M24_g x_PM_SDFFR_X1%6_17 28.86
R_x_PM_SDFFR_X1%6_r42 N_6_M2_g x_PM_SDFFR_X1%6_55 14.82
R_x_PM_SDFFR_X1%6_r43 x_PM_SDFFR_X1%6_54 x_PM_SDFFR_X1%6_11 1.95
R_x_PM_SDFFR_X1%6_r44 x_PM_SDFFR_X1%6_12 x_PM_SDFFR_X1%6_11 41.34
R_x_PM_SDFFR_X1%6_r45 x_PM_SDFFR_X1%6_56 x_PM_SDFFR_X1%6_9 2.6
R_x_PM_SDFFR_X1%6_r46 x_PM_SDFFR_X1%6_10 x_PM_SDFFR_X1%6_9 30.16
R_x_PM_SDFFR_X1%6_r47 x_PM_SDFFR_X1%6_12 x_PM_SDFFR_X1%6_5 4.35808
R_x_PM_SDFFR_X1%6_r48 N_6_M1_g x_PM_SDFFR_X1%6_5 18.33
R_x_PM_SDFFR_X1%6_r49 x_PM_SDFFR_X1%6_10 x_PM_SDFFR_X1%6_VSS 4.58872
R_x_PM_SDFFR_X1%6_r50 N_6_M23_g x_PM_SDFFR_X1%6_VSS 37.44
C_x_PM_SDFFR_X1%7_c0 VSS x_PM_SDFFR_X1%7_52 5.07537e-17
C_x_PM_SDFFR_X1%7_c1 VSS x_PM_SDFFR_X1%7_50 2.32278e-17
C_x_PM_SDFFR_X1%7_c2 VSS x_PM_SDFFR_X1%7_48 2.83431e-16
C_x_PM_SDFFR_X1%7_c3 VSS N_7_M30_d 1.72584e-17
C_x_PM_SDFFR_X1%7_c4 VSS N_7_M9_s 2.51766e-16
C_x_PM_SDFFR_X1%7_c5 VSS x_PM_SDFFR_X1%7_37 4.68481e-17
C_x_PM_SDFFR_X1%7_c6 VSS x_PM_SDFFR_X1%7_36 9.23312e-18
C_x_PM_SDFFR_X1%7_c7 VSS x_PM_SDFFR_X1%7_33 5.95535e-17
C_x_PM_SDFFR_X1%7_c8 VSS x_PM_SDFFR_X1%7_32 1.45395e-16
C_x_PM_SDFFR_X1%7_c9 VSS x_PM_SDFFR_X1%7_31 1.74289e-16
C_x_PM_SDFFR_X1%7_c10 VSS x_PM_SDFFR_X1%7_27 1.23524e-17
C_x_PM_SDFFR_X1%7_c11 VSS x_PM_SDFFR_X1%7_25 4.83687e-18
C_x_PM_SDFFR_X1%7_c12 VSS x_PM_SDFFR_X1%7_24 1.7166e-17
C_x_PM_SDFFR_X1%7_c13 VSS x_PM_SDFFR_X1%7_23 8.86366e-18
C_x_PM_SDFFR_X1%7_c14 VSS N_7_M14_g 7.34435e-17
C_x_PM_SDFFR_X1%7_c15 VSS x_PM_SDFFR_X1%7_18 1.02276e-17
C_x_PM_SDFFR_X1%7_c16 VSS x_PM_SDFFR_X1%7_17 2.94922e-17
C_x_PM_SDFFR_X1%7_c17 VSS N_7_M34_g 3.0382e-17
C_x_PM_SDFFR_X1%7_c18 VSS N_7_M28_g 2.34755e-17
C_x_PM_SDFFR_X1%7_c19 VSS N_7_M5_g 2.8303e-17
C_x_PM_SDFFR_X1%7_c20 VSS N_7_M4_g 1.99667e-17
R_x_PM_SDFFR_X1%7_r21 x_PM_SDFFR_X1%7_55 x_PM_SDFFR_X1%7_52 0.176429
R_x_PM_SDFFR_X1%7_r22 x_PM_SDFFR_X1%7_50 x_PM_SDFFR_X1%7_49 0.115915
R_x_PM_SDFFR_X1%7_r23 x_PM_SDFFR_X1%7_55 x_PM_SDFFR_X1%7_48 0.095
R_x_PM_SDFFR_X1%7_r24 x_PM_SDFFR_X1%7_49 x_PM_SDFFR_X1%7_48 5.04857
R_x_PM_SDFFR_X1%7_r25 x_PM_SDFFR_X1%7_50 x_PM_SDFFR_X1%7_44 0.0855182
R_x_PM_SDFFR_X1%7_r26 N_7_M30_d x_PM_SDFFR_X1%7_44 0.149286
R_x_PM_SDFFR_X1%7_r27 x_PM_SDFFR_X1%7_40 x_PM_SDFFR_X1%7_38 25.0012
R_x_PM_SDFFR_X1%7_r28 N_7_M9_s x_PM_SDFFR_X1%7_38 4.88571
R_x_PM_SDFFR_X1%7_r29 x_PM_SDFFR_X1%7_38 x_PM_SDFFR_X1%7_37 0.149286
R_x_PM_SDFFR_X1%7_r30 x_PM_SDFFR_X1%7_60 x_PM_SDFFR_X1%7_36 4.7687
R_x_PM_SDFFR_X1%7_r31 x_PM_SDFFR_X1%7_36 x_PM_SDFFR_X1%7_34 25.0012
R_x_PM_SDFFR_X1%7_r32 x_PM_SDFFR_X1%7_34 x_PM_SDFFR_X1%7_33 0.809259
R_x_PM_SDFFR_X1%7_r33 x_PM_SDFFR_X1%7_50 x_PM_SDFFR_X1%7_32 0.115915
R_x_PM_SDFFR_X1%7_r34 x_PM_SDFFR_X1%7_34 x_PM_SDFFR_X1%7_32 1.18926
R_x_PM_SDFFR_X1%7_r35 x_PM_SDFFR_X1%7_37 x_PM_SDFFR_X1%7_31 0.212317
R_x_PM_SDFFR_X1%7_r36 x_PM_SDFFR_X1%7_33 x_PM_SDFFR_X1%7_30 0.241334
R_x_PM_SDFFR_X1%7_r37 x_PM_SDFFR_X1%7_31 x_PM_SDFFR_X1%7_30 3.12143
R_x_PM_SDFFR_X1%7_r38 x_PM_SDFFR_X1%7_25 x_PM_SDFFR_X1%7_52 25.0012
R_x_PM_SDFFR_X1%7_r39 x_PM_SDFFR_X1%7_25 x_PM_SDFFR_X1%7_27 10.66
R_x_PM_SDFFR_X1%7_r40 x_PM_SDFFR_X1%7_40 x_PM_SDFFR_X1%7_24 0.78
R_x_PM_SDFFR_X1%7_r41 x_PM_SDFFR_X1%7_40 x_PM_SDFFR_X1%7_23 13.78
R_x_PM_SDFFR_X1%7_r42 N_7_M14_g x_PM_SDFFR_X1%7_19 70.2
R_x_PM_SDFFR_X1%7_r43 x_PM_SDFFR_X1%7_27 x_PM_SDFFR_X1%7_18 4.58872
R_x_PM_SDFFR_X1%7_r44 x_PM_SDFFR_X1%7_19 x_PM_SDFFR_X1%7_17 4.35808
R_x_PM_SDFFR_X1%7_r45 x_PM_SDFFR_X1%7_18 x_PM_SDFFR_X1%7_17 27.3
R_x_PM_SDFFR_X1%7_r46 x_PM_SDFFR_X1%7_13 x_PM_SDFFR_X1%7_25 4.5205
R_x_PM_SDFFR_X1%7_r47 N_7_M34_g x_PM_SDFFR_X1%7_13 30.42
R_x_PM_SDFFR_X1%7_r48 N_7_M28_g x_PM_SDFFR_X1%7_60 18.72
R_x_PM_SDFFR_X1%7_r49 x_PM_SDFFR_X1%7_24 x_PM_SDFFR_X1%7_5 4.58872
R_x_PM_SDFFR_X1%7_r50 N_7_M5_g x_PM_SDFFR_X1%7_5 21.84
R_x_PM_SDFFR_X1%7_r51 x_PM_SDFFR_X1%7_23 x_PM_SDFFR_X1%7_VSS 4.58872
R_x_PM_SDFFR_X1%7_r52 N_7_M4_g x_PM_SDFFR_X1%7_VSS 14.82
C_x_PM_SDFFR_X1%8_c0 VSS x_PM_SDFFR_X1%8_81 1.31306e-17
C_x_PM_SDFFR_X1%8_c1 VSS x_PM_SDFFR_X1%8_69 2.01758e-17
C_x_PM_SDFFR_X1%8_c2 VSS x_PM_SDFFR_X1%8_68 1.43313e-17
C_x_PM_SDFFR_X1%8_c3 VSS N_8_M16_d 1.47591e-17
C_x_PM_SDFFR_X1%8_c4 VSS x_PM_SDFFR_X1%8_58 5.29718e-17
C_x_PM_SDFFR_X1%8_c5 VSS x_PM_SDFFR_X1%8_57 2.34325e-17
C_x_PM_SDFFR_X1%8_c6 VSS x_PM_SDFFR_X1%8_56 9.38713e-17
C_x_PM_SDFFR_X1%8_c7 VSS x_PM_SDFFR_X1%8_55 4.67142e-17
C_x_PM_SDFFR_X1%8_c8 VSS x_PM_SDFFR_X1%8_53 1.07477e-16
C_x_PM_SDFFR_X1%8_c9 VSS x_PM_SDFFR_X1%8_51 1.56452e-17
C_x_PM_SDFFR_X1%8_c10 VSS x_PM_SDFFR_X1%8_49 1.92214e-17
C_x_PM_SDFFR_X1%8_c11 VSS x_PM_SDFFR_X1%8_46 2.31817e-17
C_x_PM_SDFFR_X1%8_c12 VSS x_PM_SDFFR_X1%8_45 9.12844e-17
C_x_PM_SDFFR_X1%8_c13 VSS x_PM_SDFFR_X1%8_42 9.31015e-17
C_x_PM_SDFFR_X1%8_c14 VSS x_PM_SDFFR_X1%8_39 9.23563e-18
C_x_PM_SDFFR_X1%8_c15 VSS x_PM_SDFFR_X1%8_36 7.94177e-18
C_x_PM_SDFFR_X1%8_c16 VSS x_PM_SDFFR_X1%8_33 2.62785e-17
C_x_PM_SDFFR_X1%8_c17 VSS x_PM_SDFFR_X1%8_32 5.2117e-16
C_x_PM_SDFFR_X1%8_c18 VSS x_PM_SDFFR_X1%8_30 9.38907e-18
C_x_PM_SDFFR_X1%8_c19 VSS x_PM_SDFFR_X1%8_28 4.97933e-17
C_x_PM_SDFFR_X1%8_c20 VSS N_8_M37_d 1.80707e-17
C_x_PM_SDFFR_X1%8_c21 VSS N_8_M35_g 2.90748e-17
C_x_PM_SDFFR_X1%8_c22 VSS N_8_M13_g 1.90424e-17
C_x_PM_SDFFR_X1%8_c23 VSS N_8_M9_g 5.36214e-17
C_x_PM_SDFFR_X1%8_c24 VSS N_8_M8_g 6.93263e-17
C_x_PM_SDFFR_X1%8_c25 VSS N_8_M30_g 6.7717e-17
C_x_PM_SDFFR_X1%8_c26 VSS N_8_M27_g 5.24425e-17
R_x_PM_SDFFR_X1%8_r27 N_8_M16_d x_PM_SDFFR_X1%8_64 0.149286
R_x_PM_SDFFR_X1%8_r28 x_PM_SDFFR_X1%8_69 x_PM_SDFFR_X1%8_59 0.0418175
R_x_PM_SDFFR_X1%8_r29 x_PM_SDFFR_X1%8_64 x_PM_SDFFR_X1%8_58 0.212317
R_x_PM_SDFFR_X1%8_r30 x_PM_SDFFR_X1%8_59 x_PM_SDFFR_X1%8_58 1.95429
R_x_PM_SDFFR_X1%8_r31 x_PM_SDFFR_X1%8_60 x_PM_SDFFR_X1%8_56 0.212317
R_x_PM_SDFFR_X1%8_r32 x_PM_SDFFR_X1%8_57 x_PM_SDFFR_X1%8_56 1.81857
R_x_PM_SDFFR_X1%8_r33 x_PM_SDFFR_X1%8_69 x_PM_SDFFR_X1%8_54 0.160909
R_x_PM_SDFFR_X1%8_r34 x_PM_SDFFR_X1%8_55 x_PM_SDFFR_X1%8_54 1.35714
R_x_PM_SDFFR_X1%8_r35 x_PM_SDFFR_X1%8_69 x_PM_SDFFR_X1%8_53 0.160909
R_x_PM_SDFFR_X1%8_r36 x_PM_SDFFR_X1%8_53 x_PM_SDFFR_X1%8_68 2.14429
R_x_PM_SDFFR_X1%8_r37 x_PM_SDFFR_X1%8_51 x_PM_SDFFR_X1%8_83 5.46
R_x_PM_SDFFR_X1%8_r38 x_PM_SDFFR_X1%8_51 x_PM_SDFFR_X1%8_49 25.0012
R_x_PM_SDFFR_X1%8_r39 x_PM_SDFFR_X1%8_68 x_PM_SDFFR_X1%8_48 0.196927
R_x_PM_SDFFR_X1%8_r40 x_PM_SDFFR_X1%8_49 x_PM_SDFFR_X1%8_48 0.130625
R_x_PM_SDFFR_X1%8_r41 x_PM_SDFFR_X1%8_57 x_PM_SDFFR_X1%8_47 0.213547
R_x_PM_SDFFR_X1%8_r42 x_PM_SDFFR_X1%8_49 x_PM_SDFFR_X1%8_47 0.130625
R_x_PM_SDFFR_X1%8_r43 x_PM_SDFFR_X1%8_55 x_PM_SDFFR_X1%8_45 0.212317
R_x_PM_SDFFR_X1%8_r44 x_PM_SDFFR_X1%8_46 x_PM_SDFFR_X1%8_45 1.08571
R_x_PM_SDFFR_X1%8_r45 x_PM_SDFFR_X1%8_81 x_PM_SDFFR_X1%8_44 3.9
R_x_PM_SDFFR_X1%8_r46 x_PM_SDFFR_X1%8_44 x_PM_SDFFR_X1%8_42 25.0012
R_x_PM_SDFFR_X1%8_r47 x_PM_SDFFR_X1%8_46 x_PM_SDFFR_X1%8_41 0.212317
R_x_PM_SDFFR_X1%8_r48 x_PM_SDFFR_X1%8_42 x_PM_SDFFR_X1%8_41 1.39786
R_x_PM_SDFFR_X1%8_r49 x_PM_SDFFR_X1%8_42 x_PM_SDFFR_X1%8_40 0.963571
R_x_PM_SDFFR_X1%8_r50 x_PM_SDFFR_X1%8_78 x_PM_SDFFR_X1%8_39 4.7687
R_x_PM_SDFFR_X1%8_r51 x_PM_SDFFR_X1%8_39 x_PM_SDFFR_X1%8_37 25.0012
R_x_PM_SDFFR_X1%8_r52 x_PM_SDFFR_X1%8_75 x_PM_SDFFR_X1%8_36 4.7687
R_x_PM_SDFFR_X1%8_r53 x_PM_SDFFR_X1%8_74 x_PM_SDFFR_X1%8_36 4.7687
R_x_PM_SDFFR_X1%8_r54 x_PM_SDFFR_X1%8_36 x_PM_SDFFR_X1%8_34 25.0012
R_x_PM_SDFFR_X1%8_r55 x_PM_SDFFR_X1%8_37 x_PM_SDFFR_X1%8_34 1.84571
R_x_PM_SDFFR_X1%8_r56 x_PM_SDFFR_X1%8_34 x_PM_SDFFR_X1%8_33 2.89071
R_x_PM_SDFFR_X1%8_r57 x_PM_SDFFR_X1%8_40 x_PM_SDFFR_X1%8_32 0.212317
R_x_PM_SDFFR_X1%8_r58 x_PM_SDFFR_X1%8_37 x_PM_SDFFR_X1%8_32 3.86786
R_x_PM_SDFFR_X1%8_r59 x_PM_SDFFR_X1%8_71 x_PM_SDFFR_X1%8_30 4.7687
R_x_PM_SDFFR_X1%8_r60 x_PM_SDFFR_X1%8_30 x_PM_SDFFR_X1%8_28 25.0012
R_x_PM_SDFFR_X1%8_r61 x_PM_SDFFR_X1%8_33 x_PM_SDFFR_X1%8_27 0.212317
R_x_PM_SDFFR_X1%8_r62 x_PM_SDFFR_X1%8_28 x_PM_SDFFR_X1%8_27 0.583571
R_x_PM_SDFFR_X1%8_r63 N_8_M37_d x_PM_SDFFR_X1%8_60 0.149286
R_x_PM_SDFFR_X1%8_r64 x_PM_SDFFR_X1%8_83 x_PM_SDFFR_X1%8_21 1.95
R_x_PM_SDFFR_X1%8_r65 N_8_M35_g x_PM_SDFFR_X1%8_21 21.84
R_x_PM_SDFFR_X1%8_r66 x_PM_SDFFR_X1%8_81 x_PM_SDFFR_X1%8_17 1.95
R_x_PM_SDFFR_X1%8_r67 N_8_M13_g x_PM_SDFFR_X1%8_17 14.82
R_x_PM_SDFFR_X1%8_r68 N_8_M9_g x_PM_SDFFR_X1%8_78 54.6
R_x_PM_SDFFR_X1%8_r69 N_8_M8_g x_PM_SDFFR_X1%8_75 74.1
R_x_PM_SDFFR_X1%8_r70 N_8_M30_g x_PM_SDFFR_X1%8_74 70.2
R_x_PM_SDFFR_X1%8_r71 N_8_M27_g x_PM_SDFFR_X1%8_71 55.38
C_x_PM_SDFFR_X1%RN_c0 VSS x_PM_SDFFR_X1%RN_30 6.60352e-17
C_x_PM_SDFFR_X1%RN_c1 VSS x_PM_SDFFR_X1%RN_22 9.39384e-18
C_x_PM_SDFFR_X1%RN_c2 VSS x_PM_SDFFR_X1%RN_20 2.96908e-16
C_x_PM_SDFFR_X1%RN_c3 VSS N_RN_M11_g 4.74475e-17
C_x_PM_SDFFR_X1%RN_c4 VSS N_RN_M32_g 8.49892e-17
C_x_PM_SDFFR_X1%RN_c5 VSS N_RN_M6_g 4.99874e-17
C_x_PM_SDFFR_X1%RN_c6 VSS x_PM_SDFFR_X1%RN_7 4.66661e-18
C_x_PM_SDFFR_X1%RN_c7 VSS x_PM_SDFFR_X1%RN_6 7.74262e-18
C_x_PM_SDFFR_X1%RN_c8 VSS x_PM_SDFFR_X1%RN_5 3.64221e-17
C_x_PM_SDFFR_X1%RN_c9 VSS N_RN_M26_g 8.59584e-17
R_x_PM_SDFFR_X1%RN_r10 x_PM_SDFFR_X1%RN_30 RN 0.284786
R_x_PM_SDFFR_X1%RN_r11 x_PM_SDFFR_X1%RN_26 x_PM_SDFFR_X1%RN_24 25.0012
R_x_PM_SDFFR_X1%RN_r12 RN x_PM_SDFFR_X1%RN_24 0.00703704
R_x_PM_SDFFR_X1%RN_r13 x_PM_SDFFR_X1%RN_33 x_PM_SDFFR_X1%RN_22 4.7687
R_x_PM_SDFFR_X1%RN_r14 x_PM_SDFFR_X1%RN_32 x_PM_SDFFR_X1%RN_22 4.7687
R_x_PM_SDFFR_X1%RN_r15 x_PM_SDFFR_X1%RN_22 x_PM_SDFFR_X1%RN_20 25.0012
R_x_PM_SDFFR_X1%RN_r16 x_PM_SDFFR_X1%RN_20 x_PM_SDFFR_X1%RN_30 5.87643
R_x_PM_SDFFR_X1%RN_r17 N_RN_M11_g x_PM_SDFFR_X1%RN_33 37.83
R_x_PM_SDFFR_X1%RN_r18 N_RN_M32_g x_PM_SDFFR_X1%RN_32 98.28
R_x_PM_SDFFR_X1%RN_r19 x_PM_SDFFR_X1%RN_26 x_PM_SDFFR_X1%RN_7 4.03807
R_x_PM_SDFFR_X1%RN_r20 N_RN_M6_g x_PM_SDFFR_X1%RN_7 47.58
R_x_PM_SDFFR_X1%RN_r21 x_PM_SDFFR_X1%RN_26 x_PM_SDFFR_X1%RN_5 0.550646
R_x_PM_SDFFR_X1%RN_r22 x_PM_SDFFR_X1%RN_6 x_PM_SDFFR_X1%RN_5 31.72
R_x_PM_SDFFR_X1%RN_r23 x_PM_SDFFR_X1%RN_6 x_PM_SDFFR_X1%RN_VSS 4.58872
R_x_PM_SDFFR_X1%RN_r24 N_RN_M26_g x_PM_SDFFR_X1%RN_VSS 103.74
C_x_PM_SDFFR_X1%10_c0 VSS x_PM_SDFFR_X1%10_38 2.9547e-17
C_x_PM_SDFFR_X1%10_c1 VSS x_PM_SDFFR_X1%10_37 4.92595e-18
C_x_PM_SDFFR_X1%10_c2 VSS N_10_M13_d 1.81175e-16
C_x_PM_SDFFR_X1%10_c3 VSS x_PM_SDFFR_X1%10_32 6.68292e-17
C_x_PM_SDFFR_X1%10_c4 VSS x_PM_SDFFR_X1%10_26 7.93728e-18
C_x_PM_SDFFR_X1%10_c5 VSS x_PM_SDFFR_X1%10_22 8.37934e-18
C_x_PM_SDFFR_X1%10_c6 VSS x_PM_SDFFR_X1%10_19 4.59021e-16
C_x_PM_SDFFR_X1%10_c7 VSS N_10_M34_d 2.39776e-17
C_x_PM_SDFFR_X1%10_c8 VSS N_10_M10_g 6.04885e-17
C_x_PM_SDFFR_X1%10_c9 VSS N_10_M31_g 5.31843e-17
C_x_PM_SDFFR_X1%10_c10 VSS N_10_M7_g 8.58509e-17
C_x_PM_SDFFR_X1%10_c11 VSS N_10_M29_g 5.00602e-17
R_x_PM_SDFFR_X1%10_r12 x_PM_SDFFR_X1%10_38 x_PM_SDFFR_X1%10_33 0.160909
R_x_PM_SDFFR_X1%10_r13 N_10_M13_d x_PM_SDFFR_X1%10_33 2.375
R_x_PM_SDFFR_X1%10_r14 x_PM_SDFFR_X1%10_38 x_PM_SDFFR_X1%10_32 0.160909
R_x_PM_SDFFR_X1%10_r15 x_PM_SDFFR_X1%10_32 x_PM_SDFFR_X1%10_37 1.27571
R_x_PM_SDFFR_X1%10_r16 x_PM_SDFFR_X1%10_37 x_PM_SDFFR_X1%10_27 0.196927
R_x_PM_SDFFR_X1%10_r17 x_PM_SDFFR_X1%10_44 x_PM_SDFFR_X1%10_26 4.7687
R_x_PM_SDFFR_X1%10_r18 x_PM_SDFFR_X1%10_43 x_PM_SDFFR_X1%10_26 4.7687
R_x_PM_SDFFR_X1%10_r19 x_PM_SDFFR_X1%10_26 x_PM_SDFFR_X1%10_24 25.0012
R_x_PM_SDFFR_X1%10_r20 x_PM_SDFFR_X1%10_41 x_PM_SDFFR_X1%10_22 4.7687
R_x_PM_SDFFR_X1%10_r21 x_PM_SDFFR_X1%10_40 x_PM_SDFFR_X1%10_22 4.7687
R_x_PM_SDFFR_X1%10_r22 x_PM_SDFFR_X1%10_22 x_PM_SDFFR_X1%10_20 25.0012
R_x_PM_SDFFR_X1%10_r23 x_PM_SDFFR_X1%10_24 x_PM_SDFFR_X1%10_20 3.90857
R_x_PM_SDFFR_X1%10_r24 x_PM_SDFFR_X1%10_38 x_PM_SDFFR_X1%10_19 0.0418175
R_x_PM_SDFFR_X1%10_r25 x_PM_SDFFR_X1%10_24 x_PM_SDFFR_X1%10_19 3.515
R_x_PM_SDFFR_X1%10_r26 N_10_M34_d x_PM_SDFFR_X1%10_27 0.130625
R_x_PM_SDFFR_X1%10_r27 N_10_M10_g x_PM_SDFFR_X1%10_44 69.42
R_x_PM_SDFFR_X1%10_r28 N_10_M31_g x_PM_SDFFR_X1%10_43 56.16
R_x_PM_SDFFR_X1%10_r29 N_10_M7_g x_PM_SDFFR_X1%10_41 95.16
R_x_PM_SDFFR_X1%10_r30 N_10_M29_g x_PM_SDFFR_X1%10_40 56.16
C_x_PM_SDFFR_X1%11_c0 VSS x_PM_SDFFR_X1%11_37 6.24106e-18
C_x_PM_SDFFR_X1%11_c1 VSS x_PM_SDFFR_X1%11_35 5.3207e-18
C_x_PM_SDFFR_X1%11_c2 VSS N_11_M31_s 7.22824e-17
C_x_PM_SDFFR_X1%11_c3 VSS x_PM_SDFFR_X1%11_26 4.1124e-17
C_x_PM_SDFFR_X1%11_c4 VSS x_PM_SDFFR_X1%11_23 6.71452e-18
C_x_PM_SDFFR_X1%11_c5 VSS x_PM_SDFFR_X1%11_22 3.89045e-17
C_x_PM_SDFFR_X1%11_c6 VSS x_PM_SDFFR_X1%11_18 2.45789e-17
C_x_PM_SDFFR_X1%11_c7 VSS x_PM_SDFFR_X1%11_15 1.27428e-16
C_x_PM_SDFFR_X1%11_c8 VSS N_11_M12_g 2.27672e-17
C_x_PM_SDFFR_X1%11_c9 VSS x_PM_SDFFR_X1%11_6 8.09029e-17
C_x_PM_SDFFR_X1%11_c10 VSS N_11_M33_g 2.12922e-17
R_x_PM_SDFFR_X1%11_r11 x_PM_SDFFR_X1%11_38 x_PM_SDFFR_X1%11_37 4.77878
R_x_PM_SDFFR_X1%11_r12 x_PM_SDFFR_X1%11_32 N_11_M31_s 0.344815
R_x_PM_SDFFR_X1%11_r13 x_PM_SDFFR_X1%11_37 x_PM_SDFFR_X1%11_26 25.0012
R_x_PM_SDFFR_X1%11_r14 x_PM_SDFFR_X1%11_26 x_PM_SDFFR_X1%11_24 0.637857
R_x_PM_SDFFR_X1%11_r15 x_PM_SDFFR_X1%11_24 x_PM_SDFFR_X1%11_22 0.212317
R_x_PM_SDFFR_X1%11_r16 x_PM_SDFFR_X1%11_23 x_PM_SDFFR_X1%11_22 0.977143
R_x_PM_SDFFR_X1%11_r17 x_PM_SDFFR_X1%11_23 x_PM_SDFFR_X1%11_18 0.202958
R_x_PM_SDFFR_X1%11_r18 N_11_M10_d x_PM_SDFFR_X1%11_18 0.111765
R_x_PM_SDFFR_X1%11_r19 x_PM_SDFFR_X1%11_35 x_PM_SDFFR_X1%11_15 25.0012
R_x_PM_SDFFR_X1%11_r20 x_PM_SDFFR_X1%11_32 x_PM_SDFFR_X1%11_13 0.095
R_x_PM_SDFFR_X1%11_r21 x_PM_SDFFR_X1%11_15 x_PM_SDFFR_X1%11_13 2.26643
R_x_PM_SDFFR_X1%11_r22 N_11_M12_g x_PM_SDFFR_X1%11_38 21.84
R_x_PM_SDFFR_X1%11_r23 x_PM_SDFFR_X1%11_37 x_PM_SDFFR_X1%11_6 0.65
R_x_PM_SDFFR_X1%11_r24 x_PM_SDFFR_X1%11_35 x_PM_SDFFR_X1%11_5 0.65
R_x_PM_SDFFR_X1%11_r25 x_PM_SDFFR_X1%11_6 x_PM_SDFFR_X1%11_5 48.1
R_x_PM_SDFFR_X1%11_r26 x_PM_SDFFR_X1%11_VSS x_PM_SDFFR_X1%11_35 4.77878
R_x_PM_SDFFR_X1%11_r27 N_11_M33_g x_PM_SDFFR_X1%11_VSS 14.82
C_x_PM_SDFFR_X1%12_c0 VSS x_PM_SDFFR_X1%12_35 1.31043e-17
C_x_PM_SDFFR_X1%12_c1 VSS x_PM_SDFFR_X1%12_33 8.34486e-18
C_x_PM_SDFFR_X1%12_c2 VSS x_PM_SDFFR_X1%12_29 4.92842e-17
C_x_PM_SDFFR_X1%12_c3 VSS N_12_M18_d 1.97809e-17
C_x_PM_SDFFR_X1%12_c4 VSS x_PM_SDFFR_X1%12_21 1.58782e-17
C_x_PM_SDFFR_X1%12_c5 VSS x_PM_SDFFR_X1%12_20 8.18029e-18
C_x_PM_SDFFR_X1%12_c6 VSS x_PM_SDFFR_X1%12_18 2.24317e-17
C_x_PM_SDFFR_X1%12_c7 VSS x_PM_SDFFR_X1%12_17 8.80889e-17
C_x_PM_SDFFR_X1%12_c8 VSS x_PM_SDFFR_X1%12_15 4.50659e-17
C_x_PM_SDFFR_X1%12_c9 VSS x_PM_SDFFR_X1%12_14 8.67374e-17
C_x_PM_SDFFR_X1%12_c10 VSS x_PM_SDFFR_X1%12_11 8.14201e-17
C_x_PM_SDFFR_X1%12_c11 VSS N_12_M39_d 5.37736e-17
C_x_PM_SDFFR_X1%12_c12 VSS N_12_M15_g 6.25366e-17
C_x_PM_SDFFR_X1%12_c13 VSS N_12_M36_g 4.3703e-17
R_x_PM_SDFFR_X1%12_r14 x_PM_SDFFR_X1%12_38 x_PM_SDFFR_X1%12_33 4.7687
R_x_PM_SDFFR_X1%12_r15 x_PM_SDFFR_X1%12_37 x_PM_SDFFR_X1%12_33 4.7687
R_x_PM_SDFFR_X1%12_r16 x_PM_SDFFR_X1%12_33 x_PM_SDFFR_X1%12_31 25.0012
R_x_PM_SDFFR_X1%12_r17 x_PM_SDFFR_X1%12_31 x_PM_SDFFR_X1%12_29 0.176429
R_x_PM_SDFFR_X1%12_r18 N_12_M18_d x_PM_SDFFR_X1%12_25 0.420714
R_x_PM_SDFFR_X1%12_r19 x_PM_SDFFR_X1%12_21 x_PM_SDFFR_X1%12_19 0.212317
R_x_PM_SDFFR_X1%12_r20 x_PM_SDFFR_X1%12_20 x_PM_SDFFR_X1%12_19 0.407143
R_x_PM_SDFFR_X1%12_r21 x_PM_SDFFR_X1%12_25 x_PM_SDFFR_X1%12_17 0.212317
R_x_PM_SDFFR_X1%12_r22 x_PM_SDFFR_X1%12_18 x_PM_SDFFR_X1%12_17 1.79143
R_x_PM_SDFFR_X1%12_r23 x_PM_SDFFR_X1%12_35 x_PM_SDFFR_X1%12_16 0.160909
R_x_PM_SDFFR_X1%12_r24 x_PM_SDFFR_X1%12_20 x_PM_SDFFR_X1%12_15 0.212317
R_x_PM_SDFFR_X1%12_r25 x_PM_SDFFR_X1%12_16 x_PM_SDFFR_X1%12_15 0.624286
R_x_PM_SDFFR_X1%12_r26 x_PM_SDFFR_X1%12_18 x_PM_SDFFR_X1%12_14 0.212317
R_x_PM_SDFFR_X1%12_r27 x_PM_SDFFR_X1%12_35 x_PM_SDFFR_X1%12_13 0.0418175
R_x_PM_SDFFR_X1%12_r28 x_PM_SDFFR_X1%12_14 x_PM_SDFFR_X1%12_13 2.30714
R_x_PM_SDFFR_X1%12_r29 x_PM_SDFFR_X1%12_29 x_PM_SDFFR_X1%12_12 0.095
R_x_PM_SDFFR_X1%12_r30 x_PM_SDFFR_X1%12_35 x_PM_SDFFR_X1%12_11 0.160909
R_x_PM_SDFFR_X1%12_r31 x_PM_SDFFR_X1%12_12 x_PM_SDFFR_X1%12_11 2.17143
R_x_PM_SDFFR_X1%12_r32 N_12_M39_d x_PM_SDFFR_X1%12_21 0.990714
R_x_PM_SDFFR_X1%12_r33 N_12_M15_g x_PM_SDFFR_X1%12_38 73.32
R_x_PM_SDFFR_X1%12_r34 N_12_M36_g x_PM_SDFFR_X1%12_37 38.22
C_x_PM_SDFFR_X1%CK_c0 VSS x_PM_SDFFR_X1%CK_14 9.3904e-18
C_x_PM_SDFFR_X1%CK_c1 VSS x_PM_SDFFR_X1%CK_12 3.21953e-17
C_x_PM_SDFFR_X1%CK_c2 VSS N_CK_M16_g 6.63059e-17
C_x_PM_SDFFR_X1%CK_c3 VSS N_CK_M37_g 5.82024e-17
R_x_PM_SDFFR_X1%CK_r4 x_PM_SDFFR_X1%CK_18 x_PM_SDFFR_X1%CK_14 4.7687
R_x_PM_SDFFR_X1%CK_r5 x_PM_SDFFR_X1%CK_17 x_PM_SDFFR_X1%CK_14 4.7687
R_x_PM_SDFFR_X1%CK_r6 x_PM_SDFFR_X1%CK_14 x_PM_SDFFR_X1%CK_12 25.0012
R_x_PM_SDFFR_X1%CK_r7 x_PM_SDFFR_X1%CK_12 CK 0.149286
R_x_PM_SDFFR_X1%CK_r8 N_CK_M16_g x_PM_SDFFR_X1%CK_18 60.84
R_x_PM_SDFFR_X1%CK_r9 N_CK_M37_g x_PM_SDFFR_X1%CK_17 57.72
C_x_PM_SDFFR_X1%D_c0 VSS x_PM_SDFFR_X1%D_22 1.16901e-17
C_x_PM_SDFFR_X1%D_c1 VSS x_PM_SDFFR_X1%D_20 2.37724e-17
C_x_PM_SDFFR_X1%D_c2 VSS D 8.2074e-18
C_x_PM_SDFFR_X1%D_c3 VSS x_PM_SDFFR_X1%D_15 4.08351e-17
C_x_PM_SDFFR_X1%D_c4 VSS x_PM_SDFFR_X1%D_14 1.00227e-16
C_x_PM_SDFFR_X1%D_c5 VSS x_PM_SDFFR_X1%D_12 1.14343e-17
C_x_PM_SDFFR_X1%D_c6 VSS x_PM_SDFFR_X1%D_10 7.62062e-17
C_x_PM_SDFFR_X1%D_c7 VSS N_D_M20_g 3.81037e-17
C_x_PM_SDFFR_X1%D_c8 VSS N_D_M38_g 4.37773e-17
R_x_PM_SDFFR_X1%D_r9 x_PM_SDFFR_X1%D_31 x_PM_SDFFR_X1%D_22 4.7687
R_x_PM_SDFFR_X1%D_r10 x_PM_SDFFR_X1%D_22 x_PM_SDFFR_X1%D_20 25.0012
R_x_PM_SDFFR_X1%D_r11 x_PM_SDFFR_X1%D_20 D 0.1235
R_x_PM_SDFFR_X1%D_r12 D x_PM_SDFFR_X1%D_16 0.171
R_x_PM_SDFFR_X1%D_r13 x_PM_SDFFR_X1%D_16 x_PM_SDFFR_X1%D_14 0.221031
R_x_PM_SDFFR_X1%D_r14 x_PM_SDFFR_X1%D_15 x_PM_SDFFR_X1%D_14 2.36143
R_x_PM_SDFFR_X1%D_r15 x_PM_SDFFR_X1%D_27 x_PM_SDFFR_X1%D_12 4.7687
R_x_PM_SDFFR_X1%D_r16 x_PM_SDFFR_X1%D_12 x_PM_SDFFR_X1%D_10 25.0012
R_x_PM_SDFFR_X1%D_r17 x_PM_SDFFR_X1%D_15 x_PM_SDFFR_X1%D_9 0.212645
R_x_PM_SDFFR_X1%D_r18 x_PM_SDFFR_X1%D_10 x_PM_SDFFR_X1%D_9 1.00067
R_x_PM_SDFFR_X1%D_r19 N_D_M20_g x_PM_SDFFR_X1%D_31 30.42
R_x_PM_SDFFR_X1%D_r20 N_D_M38_g x_PM_SDFFR_X1%D_27 39.78
C_x_PM_SDFFR_X1%15_c0 VSS x_PM_SDFFR_X1%15_26 2.1849e-18
C_x_PM_SDFFR_X1%15_c1 VSS N_15_M21_d 6.15509e-17
C_x_PM_SDFFR_X1%15_c2 VSS x_PM_SDFFR_X1%15_17 3.49367e-17
C_x_PM_SDFFR_X1%15_c3 VSS x_PM_SDFFR_X1%15_16 9.26904e-17
C_x_PM_SDFFR_X1%15_c4 VSS x_PM_SDFFR_X1%15_14 8.5082e-18
C_x_PM_SDFFR_X1%15_c5 VSS x_PM_SDFFR_X1%15_12 8.97168e-18
C_x_PM_SDFFR_X1%15_c6 VSS N_15_M42_d 1.32619e-17
C_x_PM_SDFFR_X1%15_c7 VSS N_15_M18_g 9.05509e-17
C_x_PM_SDFFR_X1%15_c8 VSS N_15_M39_g 3.24143e-17
R_x_PM_SDFFR_X1%15_r9 x_PM_SDFFR_X1%15_26 x_PM_SDFFR_X1%15_22 0.160909
R_x_PM_SDFFR_X1%15_r10 N_15_M21_d x_PM_SDFFR_X1%15_22 3.37929
R_x_PM_SDFFR_X1%15_r11 x_PM_SDFFR_X1%15_26 x_PM_SDFFR_X1%15_18 0.160909
R_x_PM_SDFFR_X1%15_r12 x_PM_SDFFR_X1%15_26 x_PM_SDFFR_X1%15_16 0.0418175
R_x_PM_SDFFR_X1%15_r13 x_PM_SDFFR_X1%15_17 x_PM_SDFFR_X1%15_16 3.14857
R_x_PM_SDFFR_X1%15_r14 x_PM_SDFFR_X1%15_29 x_PM_SDFFR_X1%15_14 4.7687
R_x_PM_SDFFR_X1%15_r15 x_PM_SDFFR_X1%15_28 x_PM_SDFFR_X1%15_14 4.7687
R_x_PM_SDFFR_X1%15_r16 x_PM_SDFFR_X1%15_14 x_PM_SDFFR_X1%15_12 25.0012
R_x_PM_SDFFR_X1%15_r17 x_PM_SDFFR_X1%15_17 x_PM_SDFFR_X1%15_11 0.212317
R_x_PM_SDFFR_X1%15_r18 x_PM_SDFFR_X1%15_12 x_PM_SDFFR_X1%15_11 0.149286
R_x_PM_SDFFR_X1%15_r19 N_15_M42_d x_PM_SDFFR_X1%15_18 0.149286
R_x_PM_SDFFR_X1%15_r20 N_15_M18_g x_PM_SDFFR_X1%15_29 102.18
R_x_PM_SDFFR_X1%15_r21 N_15_M39_g x_PM_SDFFR_X1%15_28 21.84
C_x_PM_SDFFR_X1%SE_c0 VSS x_PM_SDFFR_X1%SE_28 9.51363e-18
C_x_PM_SDFFR_X1%SE_c1 VSS x_PM_SDFFR_X1%SE_26 4.18534e-17
C_x_PM_SDFFR_X1%SE_c2 VSS x_PM_SDFFR_X1%SE_22 4.45005e-18
C_x_PM_SDFFR_X1%SE_c3 VSS x_PM_SDFFR_X1%SE_21 4.51267e-18
C_x_PM_SDFFR_X1%SE_c4 VSS N_SE_M21_g 5.98016e-17
C_x_PM_SDFFR_X1%SE_c5 VSS N_SE_M42_g 7.27985e-17
C_x_PM_SDFFR_X1%SE_c6 VSS x_PM_SDFFR_X1%SE_11 3.16268e-17
C_x_PM_SDFFR_X1%SE_c7 VSS N_SE_M19_g 5.66426e-17
C_x_PM_SDFFR_X1%SE_c8 VSS x_PM_SDFFR_X1%SE_6 1.08215e-17
C_x_PM_SDFFR_X1%SE_c9 VSS N_SE_M40_g 4.69403e-17
R_x_PM_SDFFR_X1%SE_r10 x_PM_SDFFR_X1%SE_32 x_PM_SDFFR_X1%SE_28 4.7687
R_x_PM_SDFFR_X1%SE_r11 x_PM_SDFFR_X1%SE_31 x_PM_SDFFR_X1%SE_28 4.7687
R_x_PM_SDFFR_X1%SE_r12 x_PM_SDFFR_X1%SE_28 x_PM_SDFFR_X1%SE_26 25.0012
R_x_PM_SDFFR_X1%SE_r13 x_PM_SDFFR_X1%SE_26 SE 0.0882143
R_x_PM_SDFFR_X1%SE_r14 x_PM_SDFFR_X1%SE_22 x_PM_SDFFR_X1%SE_17 3.30287
R_x_PM_SDFFR_X1%SE_r15 N_SE_M21_g x_PM_SDFFR_X1%SE_17 53.82
R_x_PM_SDFFR_X1%SE_r16 x_PM_SDFFR_X1%SE_22 x_PM_SDFFR_X1%SE_13 3.30287
R_x_PM_SDFFR_X1%SE_r17 N_SE_M42_g x_PM_SDFFR_X1%SE_13 74.1
R_x_PM_SDFFR_X1%SE_r18 x_PM_SDFFR_X1%SE_21 x_PM_SDFFR_X1%SE_12 0.858359
R_x_PM_SDFFR_X1%SE_r19 x_PM_SDFFR_X1%SE_22 x_PM_SDFFR_X1%SE_11 0.858359
R_x_PM_SDFFR_X1%SE_r20 x_PM_SDFFR_X1%SE_12 x_PM_SDFFR_X1%SE_11 51.48
R_x_PM_SDFFR_X1%SE_r21 x_PM_SDFFR_X1%SE_21 x_PM_SDFFR_X1%SE_7 3.30287
R_x_PM_SDFFR_X1%SE_r22 N_SE_M19_g x_PM_SDFFR_X1%SE_7 53.82
R_x_PM_SDFFR_X1%SE_r23 x_PM_SDFFR_X1%SE_21 x_PM_SDFFR_X1%SE_6 3.30287
R_x_PM_SDFFR_X1%SE_r24 x_PM_SDFFR_X1%SE_6 x_PM_SDFFR_X1%SE_32 17.94
R_x_PM_SDFFR_X1%SE_r25 N_SE_M40_g x_PM_SDFFR_X1%SE_31 44.46
C_x_PM_SDFFR_X1%SI_c0 VSS x_PM_SDFFR_X1%SI_17 1.07402e-17
C_x_PM_SDFFR_X1%SI_c1 VSS x_PM_SDFFR_X1%SI_15 5.78479e-17
C_x_PM_SDFFR_X1%SI_c2 VSS N_SI_M41_g 4.8184e-17
C_x_PM_SDFFR_X1%SI_c3 VSS N_SI_M17_g 7.34178e-17
C_x_PM_SDFFR_X1%SI_c4 VSS x_PM_SDFFR_X1%SI_6 5.03648e-18
C_x_PM_SDFFR_X1%SI_c5 VSS x_PM_SDFFR_X1%SI_5 2.64809e-17
C_x_PM_SDFFR_X1%SI_c6 VSS x_PM_SDFFR_X1%SI_4 6.09128e-18
C_x_PM_SDFFR_X1%SI_c7 VSS x_PM_SDFFR_X1%SI_3 9.49597e-17
C_x_PM_SDFFR_X1%SI_c8 VSS x_PM_SDFFR_X1%SI_2 6.05101e-17
R_x_PM_SDFFR_X1%SI_r9 x_PM_SDFFR_X1%SI_23 x_PM_SDFFR_X1%SI_17 4.7687
R_x_PM_SDFFR_X1%SI_r10 x_PM_SDFFR_X1%SI_17 x_PM_SDFFR_X1%SI_15 25.0012
R_x_PM_SDFFR_X1%SI_r11 SI x_PM_SDFFR_X1%SI_15 0.1615
R_x_PM_SDFFR_X1%SI_r12 N_SI_M41_g x_PM_SDFFR_X1%SI_23 38.22
R_x_PM_SDFFR_X1%SI_r13 N_SI_M41_g x_PM_SDFFR_X1%SI_11 33.54
R_x_PM_SDFFR_X1%SI_r14 N_SI_M17_g x_PM_SDFFR_X1%SI_7 64.74
R_x_PM_SDFFR_X1%SI_r15 x_PM_SDFFR_X1%SI_7 x_PM_SDFFR_X1%SI_5 4.35808
R_x_PM_SDFFR_X1%SI_r16 x_PM_SDFFR_X1%SI_6 x_PM_SDFFR_X1%SI_5 24.18
R_x_PM_SDFFR_X1%SI_r17 x_PM_SDFFR_X1%SI_11 x_PM_SDFFR_X1%SI_3 4.35808
R_x_PM_SDFFR_X1%SI_r18 x_PM_SDFFR_X1%SI_4 x_PM_SDFFR_X1%SI_3 113.1
R_x_PM_SDFFR_X1%SI_r19 x_PM_SDFFR_X1%SI_6 x_PM_SDFFR_X1%SI_2 4.35808
R_x_PM_SDFFR_X1%SI_r20 x_PM_SDFFR_X1%SI_4 x_PM_SDFFR_X1%SI_VSS 4.35808
R_x_PM_SDFFR_X1%SI_r21 x_PM_SDFFR_X1%SI_2 x_PM_SDFFR_X1%SI_VSS 96.72
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFR_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFR_X2 VSS VDD QN Q RN CK D SE SI
*.PININFO VSS:B VDD:B QN:O Q:O RN:I CK:I D:I SE:I SI:I
M_M21 N_VDD_M0_d N_5_M0_g N_QN_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 N_Q_M1_d N_6_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 N_VDD_M2_d N_6_M2_g N_5_M2_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 18 N_5_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M25 N_6_M4_d N_7_M4_g 18 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M26 19 N_7_M5_g N_6_M4_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M27 N_VDD_M6_d N_RN_M6_g 19 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M28 20 N_10_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M29 N_6_M8_d N_8_M8_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M30 N_VDD_M9_d N_8_M9_g N_7_M9_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M31 N_11_M10_d N_10_M10_g N_VDD_M9_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 N_VDD_M11_d N_RN_M11_g N_11_M10_d VDD PMOS_VTL W=0.225000U L=0.050000U
M_M33 21 N_11_M12_g N_VDD_M11_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M34 N_10_M13_d N_8_M13_g 21 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 22 N_7_M14_g N_10_M13_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M36 N_VDD_M15_d N_12_M15_g 22 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M37 N_8_M16_d N_CK_M16_g N_VDD_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M38 23 N_SI_M17_g N_VDD_M17_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M39 N_12_M18_d N_15_M18_g 23 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M40 24 N_SE_M19_g N_12_M18_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M41 N_VDD_M20_d N_D_M20_g 24 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M42 N_15_M21_d N_SE_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M22_d N_5_M22_g N_QN_M22_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_Q_M23_d N_6_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_VSS_M24_d N_6_M24_g N_5_M24_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M3 25 N_5_M25_g N_VSS_M24_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 26 N_RN_M26_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 N_6_M27_d N_8_M27_g 26 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 27 N_7_M28_g N_6_M27_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_VSS_M29_d N_10_M29_g 27 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M8 N_7_M30_d N_8_M30_g N_VSS_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 28 N_10_M31_g N_11_M31_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_VSS_M32_d N_RN_M32_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 29 N_11_M33_g N_VSS_M32_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_10_M34_d N_7_M34_g 29 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 30 N_8_M35_g N_10_M34_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M14 N_VSS_M36_d N_12_M36_g 30 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_8_M37_d N_CK_M37_g N_VSS_M36_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M16 31 N_D_M38_g N_VSS_M38_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_12_M39_d N_15_M39_g 31 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 32 N_SE_M40_g N_12_M39_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M19 N_VSS_M41_d N_SI_M41_g 32 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M20 N_15_M42_d N_SE_M42_g N_VSS_M41_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFFR_X2%VSS_c0 VSS x_PM_SDFFR_X2%VSS_55 2.74807e-18
C_x_PM_SDFFR_X2%VSS_c1 VSS x_PM_SDFFR_X2%VSS_54 4.6069e-18
C_x_PM_SDFFR_X2%VSS_c2 VSS x_PM_SDFFR_X2%VSS_53 2.64443e-18
C_x_PM_SDFFR_X2%VSS_c3 VSS x_PM_SDFFR_X2%VSS_51 1.06989e-16
C_x_PM_SDFFR_X2%VSS_c4 VSS x_PM_SDFFR_X2%VSS_48 2.77004e-18
C_x_PM_SDFFR_X2%VSS_c5 VSS x_PM_SDFFR_X2%VSS_47 2.77004e-18
C_x_PM_SDFFR_X2%VSS_c6 VSS x_PM_SDFFR_X2%VSS_46 3.65944e-17
C_x_PM_SDFFR_X2%VSS_c7 VSS VSS 3.001e-17
C_x_PM_SDFFR_X2%VSS_c8 VSS N_VSS_M41_d 3.89379e-17
C_x_PM_SDFFR_X2%VSS_c9 VSS x_PM_SDFFR_X2%VSS_36 7.80415e-17
C_x_PM_SDFFR_X2%VSS_c10 VSS N_VSS_M38_s 3.94445e-17
C_x_PM_SDFFR_X2%VSS_c11 VSS x_PM_SDFFR_X2%VSS_30 4.55172e-17
C_x_PM_SDFFR_X2%VSS_c12 VSS N_VSS_M36_d 2.49511e-17
C_x_PM_SDFFR_X2%VSS_c13 VSS x_PM_SDFFR_X2%VSS_25 3.13536e-17
C_x_PM_SDFFR_X2%VSS_c14 VSS x_PM_SDFFR_X2%VSS_24 8.3419e-17
C_x_PM_SDFFR_X2%VSS_c15 VSS x_PM_SDFFR_X2%VSS_21 3.08779e-17
C_x_PM_SDFFR_X2%VSS_c16 VSS x_PM_SDFFR_X2%VSS_18 9.34322e-17
C_x_PM_SDFFR_X2%VSS_c17 VSS x_PM_SDFFR_X2%VSS_17 3.09265e-17
C_x_PM_SDFFR_X2%VSS_c18 VSS x_PM_SDFFR_X2%VSS_14 5.40789e-17
C_x_PM_SDFFR_X2%VSS_c19 VSS N_VSS_M22_d 1.53648e-17
R_x_PM_SDFFR_X2%VSS_r20 x_PM_SDFFR_X2%VSS_51 N_VSS_M32_d 0.140674
R_x_PM_SDFFR_X2%VSS_r21 x_PM_SDFFR_X2%VSS_55 x_PM_SDFFR_X2%VSS_42 0.0731438
R_x_PM_SDFFR_X2%VSS_r22 VSS x_PM_SDFFR_X2%VSS_42 0.681765
R_x_PM_SDFFR_X2%VSS_r23 x_PM_SDFFR_X2%VSS_55 x_PM_SDFFR_X2%VSS_38 0.145286
R_x_PM_SDFFR_X2%VSS_r24 N_VSS_M41_d x_PM_SDFFR_X2%VSS_38 0.909286
R_x_PM_SDFFR_X2%VSS_r25 x_PM_SDFFR_X2%VSS_54 x_PM_SDFFR_X2%VSS_37 0.0731438
R_x_PM_SDFFR_X2%VSS_r26 x_PM_SDFFR_X2%VSS_55 x_PM_SDFFR_X2%VSS_36 0.0731438
R_x_PM_SDFFR_X2%VSS_r27 x_PM_SDFFR_X2%VSS_37 x_PM_SDFFR_X2%VSS_36 1.52
R_x_PM_SDFFR_X2%VSS_r28 x_PM_SDFFR_X2%VSS_54 x_PM_SDFFR_X2%VSS_32 0.145286
R_x_PM_SDFFR_X2%VSS_r29 N_VSS_M38_s x_PM_SDFFR_X2%VSS_32 0.909286
R_x_PM_SDFFR_X2%VSS_r30 x_PM_SDFFR_X2%VSS_53 x_PM_SDFFR_X2%VSS_31 0.0731438
R_x_PM_SDFFR_X2%VSS_r31 x_PM_SDFFR_X2%VSS_54 x_PM_SDFFR_X2%VSS_30 0.0731438
R_x_PM_SDFFR_X2%VSS_r32 x_PM_SDFFR_X2%VSS_31 x_PM_SDFFR_X2%VSS_30 0.815882
R_x_PM_SDFFR_X2%VSS_r33 x_PM_SDFFR_X2%VSS_53 x_PM_SDFFR_X2%VSS_26 0.145286
R_x_PM_SDFFR_X2%VSS_r34 N_VSS_M36_d x_PM_SDFFR_X2%VSS_26 0.230714
R_x_PM_SDFFR_X2%VSS_r35 x_PM_SDFFR_X2%VSS_25 N_VSS_M32_d 0.140674
R_x_PM_SDFFR_X2%VSS_r36 x_PM_SDFFR_X2%VSS_53 x_PM_SDFFR_X2%VSS_24 0.0731438
R_x_PM_SDFFR_X2%VSS_r37 x_PM_SDFFR_X2%VSS_25 x_PM_SDFFR_X2%VSS_24 1.49765
R_x_PM_SDFFR_X2%VSS_r38 x_PM_SDFFR_X2%VSS_48 x_PM_SDFFR_X2%VSS_23 0.0731438
R_x_PM_SDFFR_X2%VSS_r39 x_PM_SDFFR_X2%VSS_23 x_PM_SDFFR_X2%VSS_51 1.76588
R_x_PM_SDFFR_X2%VSS_r40 x_PM_SDFFR_X2%VSS_48 x_PM_SDFFR_X2%VSS_21 0.145286
R_x_PM_SDFFR_X2%VSS_r41 x_PM_SDFFR_X2%VSS_21 N_VSS_M29_d 0.543196
R_x_PM_SDFFR_X2%VSS_r42 x_PM_SDFFR_X2%VSS_47 x_PM_SDFFR_X2%VSS_19 0.0731438
R_x_PM_SDFFR_X2%VSS_r43 x_PM_SDFFR_X2%VSS_48 x_PM_SDFFR_X2%VSS_18 0.0731438
R_x_PM_SDFFR_X2%VSS_r44 x_PM_SDFFR_X2%VSS_19 x_PM_SDFFR_X2%VSS_18 1.94471
R_x_PM_SDFFR_X2%VSS_r45 x_PM_SDFFR_X2%VSS_47 x_PM_SDFFR_X2%VSS_17 0.145286
R_x_PM_SDFFR_X2%VSS_r46 x_PM_SDFFR_X2%VSS_17 N_VSS_M24_d 0.543196
R_x_PM_SDFFR_X2%VSS_r47 x_PM_SDFFR_X2%VSS_46 x_PM_SDFFR_X2%VSS_15 0.0731438
R_x_PM_SDFFR_X2%VSS_r48 x_PM_SDFFR_X2%VSS_47 x_PM_SDFFR_X2%VSS_14 0.0731438
R_x_PM_SDFFR_X2%VSS_r49 x_PM_SDFFR_X2%VSS_15 x_PM_SDFFR_X2%VSS_14 1.03941
R_x_PM_SDFFR_X2%VSS_r50 x_PM_SDFFR_X2%VSS_46 x_PM_SDFFR_X2%VSS_10 0.145286
R_x_PM_SDFFR_X2%VSS_r51 N_VSS_M22_d x_PM_SDFFR_X2%VSS_10 0.230714
C_x_PM_SDFFR_X2%VDD_c0 VSS x_PM_SDFFR_X2%VDD_67 3.40635e-17
C_x_PM_SDFFR_X2%VDD_c1 VSS x_PM_SDFFR_X2%VDD_66 2.77058e-18
C_x_PM_SDFFR_X2%VDD_c2 VSS x_PM_SDFFR_X2%VDD_65 2.96617e-18
C_x_PM_SDFFR_X2%VDD_c3 VSS x_PM_SDFFR_X2%VDD_64 5.6044e-18
C_x_PM_SDFFR_X2%VDD_c4 VSS x_PM_SDFFR_X2%VDD_63 2.96617e-18
C_x_PM_SDFFR_X2%VDD_c5 VSS x_PM_SDFFR_X2%VDD_62 3.65531e-17
C_x_PM_SDFFR_X2%VDD_c6 VSS x_PM_SDFFR_X2%VDD_58 2.92048e-18
C_x_PM_SDFFR_X2%VDD_c7 VSS x_PM_SDFFR_X2%VDD_57 2.97192e-18
C_x_PM_SDFFR_X2%VDD_c8 VSS N_VDD_M20_d 1.35366e-17
C_x_PM_SDFFR_X2%VDD_c9 VSS x_PM_SDFFR_X2%VDD_49 6.61029e-17
C_x_PM_SDFFR_X2%VDD_c10 VSS N_VDD_M17_s 3.32304e-17
C_x_PM_SDFFR_X2%VDD_c11 VSS x_PM_SDFFR_X2%VDD_43 1.95274e-17
C_x_PM_SDFFR_X2%VDD_c12 VSS N_VDD_M15_d 3.55824e-17
C_x_PM_SDFFR_X2%VDD_c13 VSS x_PM_SDFFR_X2%VDD_37 1.07226e-16
C_x_PM_SDFFR_X2%VDD_c14 VSS N_VDD_M11_d 3.35594e-17
C_x_PM_SDFFR_X2%VDD_c15 VSS x_PM_SDFFR_X2%VDD_31 1.87009e-17
C_x_PM_SDFFR_X2%VDD_c16 VSS N_VDD_M9_d 4.40146e-17
C_x_PM_SDFFR_X2%VDD_c17 VSS x_PM_SDFFR_X2%VDD_25 8.91514e-17
C_x_PM_SDFFR_X2%VDD_c18 VSS x_PM_SDFFR_X2%VDD_23 9.89319e-17
C_x_PM_SDFFR_X2%VDD_c19 VSS N_VDD_M2_d 2.58698e-17
C_x_PM_SDFFR_X2%VDD_c20 VSS x_PM_SDFFR_X2%VDD_17 4.10152e-17
C_x_PM_SDFFR_X2%VDD_c21 VSS N_VDD_M0_d 3.15411e-17
C_x_PM_SDFFR_X2%VDD_c22 VSS x_PM_SDFFR_X2%VDD_9 2.22159e-17
R_x_PM_SDFFR_X2%VDD_r23 x_PM_SDFFR_X2%VDD_62 N_VDD_M6_d 0.137322
R_x_PM_SDFFR_X2%VDD_r24 x_PM_SDFFR_X2%VDD_67 x_PM_SDFFR_X2%VDD_51 0.145286
R_x_PM_SDFFR_X2%VDD_r25 N_VDD_M20_d x_PM_SDFFR_X2%VDD_51 0.230714
R_x_PM_SDFFR_X2%VDD_r26 x_PM_SDFFR_X2%VDD_66 x_PM_SDFFR_X2%VDD_50 0.0731438
R_x_PM_SDFFR_X2%VDD_r27 x_PM_SDFFR_X2%VDD_67 x_PM_SDFFR_X2%VDD_49 0.0731438
R_x_PM_SDFFR_X2%VDD_r28 x_PM_SDFFR_X2%VDD_50 x_PM_SDFFR_X2%VDD_49 1.54235
R_x_PM_SDFFR_X2%VDD_r29 x_PM_SDFFR_X2%VDD_66 x_PM_SDFFR_X2%VDD_45 0.145286
R_x_PM_SDFFR_X2%VDD_r30 N_VDD_M17_s x_PM_SDFFR_X2%VDD_45 0.230714
R_x_PM_SDFFR_X2%VDD_r31 x_PM_SDFFR_X2%VDD_65 x_PM_SDFFR_X2%VDD_44 0.0731438
R_x_PM_SDFFR_X2%VDD_r32 x_PM_SDFFR_X2%VDD_66 x_PM_SDFFR_X2%VDD_43 0.0731438
R_x_PM_SDFFR_X2%VDD_r33 x_PM_SDFFR_X2%VDD_44 x_PM_SDFFR_X2%VDD_43 0.704118
R_x_PM_SDFFR_X2%VDD_r34 x_PM_SDFFR_X2%VDD_65 x_PM_SDFFR_X2%VDD_39 0.145286
R_x_PM_SDFFR_X2%VDD_r35 N_VDD_M15_d x_PM_SDFFR_X2%VDD_39 1.37071
R_x_PM_SDFFR_X2%VDD_r36 x_PM_SDFFR_X2%VDD_64 x_PM_SDFFR_X2%VDD_38 0.132285
R_x_PM_SDFFR_X2%VDD_r37 x_PM_SDFFR_X2%VDD_65 x_PM_SDFFR_X2%VDD_37 0.0731438
R_x_PM_SDFFR_X2%VDD_r38 x_PM_SDFFR_X2%VDD_38 x_PM_SDFFR_X2%VDD_37 1.49765
R_x_PM_SDFFR_X2%VDD_r39 x_PM_SDFFR_X2%VDD_64 x_PM_SDFFR_X2%VDD_33 0.0680382
R_x_PM_SDFFR_X2%VDD_r40 N_VDD_M11_d x_PM_SDFFR_X2%VDD_33 0.330741
R_x_PM_SDFFR_X2%VDD_r41 x_PM_SDFFR_X2%VDD_63 x_PM_SDFFR_X2%VDD_32 0.0731438
R_x_PM_SDFFR_X2%VDD_r42 x_PM_SDFFR_X2%VDD_64 x_PM_SDFFR_X2%VDD_31 0.132285
R_x_PM_SDFFR_X2%VDD_r43 x_PM_SDFFR_X2%VDD_32 x_PM_SDFFR_X2%VDD_31 0.625882
R_x_PM_SDFFR_X2%VDD_r44 x_PM_SDFFR_X2%VDD_63 x_PM_SDFFR_X2%VDD_27 0.145286
R_x_PM_SDFFR_X2%VDD_r45 N_VDD_M9_d x_PM_SDFFR_X2%VDD_27 1.37071
R_x_PM_SDFFR_X2%VDD_r46 x_PM_SDFFR_X2%VDD_63 x_PM_SDFFR_X2%VDD_25 0.0731438
R_x_PM_SDFFR_X2%VDD_r47 x_PM_SDFFR_X2%VDD_62 x_PM_SDFFR_X2%VDD_25 1.44176
R_x_PM_SDFFR_X2%VDD_r48 x_PM_SDFFR_X2%VDD_58 x_PM_SDFFR_X2%VDD_24 0.0731438
R_x_PM_SDFFR_X2%VDD_r49 x_PM_SDFFR_X2%VDD_23 N_VDD_M6_d 0.137322
R_x_PM_SDFFR_X2%VDD_r50 x_PM_SDFFR_X2%VDD_24 x_PM_SDFFR_X2%VDD_23 1.50882
R_x_PM_SDFFR_X2%VDD_r51 x_PM_SDFFR_X2%VDD_58 x_PM_SDFFR_X2%VDD_19 0.145286
R_x_PM_SDFFR_X2%VDD_r52 N_VDD_M2_d x_PM_SDFFR_X2%VDD_19 0.637857
R_x_PM_SDFFR_X2%VDD_r53 x_PM_SDFFR_X2%VDD_57 x_PM_SDFFR_X2%VDD_18 0.0731438
R_x_PM_SDFFR_X2%VDD_r54 x_PM_SDFFR_X2%VDD_58 x_PM_SDFFR_X2%VDD_17 0.0731438
R_x_PM_SDFFR_X2%VDD_r55 x_PM_SDFFR_X2%VDD_18 x_PM_SDFFR_X2%VDD_17 0.983529
R_x_PM_SDFFR_X2%VDD_r56 x_PM_SDFFR_X2%VDD_57 x_PM_SDFFR_X2%VDD_13 0.145286
R_x_PM_SDFFR_X2%VDD_r57 N_VDD_M0_d x_PM_SDFFR_X2%VDD_13 1.47929
R_x_PM_SDFFR_X2%VDD_r58 x_PM_SDFFR_X2%VDD_57 x_PM_SDFFR_X2%VDD_9 0.0731438
R_x_PM_SDFFR_X2%VDD_r59 VDD x_PM_SDFFR_X2%VDD_9 0.257059
C_x_PM_SDFFR_X2%QN_c0 VSS N_QN_M22_s 7.99119e-17
R_x_PM_SDFFR_X2%QN_r1 N_QN_M0_s QN 1.69813
R_x_PM_SDFFR_X2%QN_r2 QN N_QN_M22_s 1.22312
C_x_PM_SDFFR_X2%Q_c0 VSS x_PM_SDFFR_X2%Q_13 1.29734e-17
C_x_PM_SDFFR_X2%Q_c1 VSS N_Q_M1_d 1.08824e-16
C_x_PM_SDFFR_X2%Q_c2 VSS N_Q_M23_d 5.47211e-17
R_x_PM_SDFFR_X2%Q_r3 N_Q_M1_d x_PM_SDFFR_X2%Q_13 2.32071
R_x_PM_SDFFR_X2%Q_r4 Q N_Q_M23_d 0.496111
R_x_PM_SDFFR_X2%Q_r5 x_PM_SDFFR_X2%Q_13 x_PM_SDFFR_X2%Q_3 0.20978
R_x_PM_SDFFR_X2%Q_r6 Q x_PM_SDFFR_X2%Q_3 0.105556
C_x_PM_SDFFR_X2%5_c0 VSS x_PM_SDFFR_X2%5_32 2.50991e-17
C_x_PM_SDFFR_X2%5_c1 VSS N_5_M24_s 8.259e-17
C_x_PM_SDFFR_X2%5_c2 VSS N_5_M2_s 1.42983e-16
C_x_PM_SDFFR_X2%5_c3 VSS x_PM_SDFFR_X2%5_20 6.09423e-18
C_x_PM_SDFFR_X2%5_c4 VSS x_PM_SDFFR_X2%5_19 7.93562e-17
C_x_PM_SDFFR_X2%5_c5 VSS x_PM_SDFFR_X2%5_18 6.80144e-18
C_x_PM_SDFFR_X2%5_c6 VSS N_5_M25_g 4.86996e-17
C_x_PM_SDFFR_X2%5_c7 VSS N_5_M3_g 6.88172e-17
C_x_PM_SDFFR_X2%5_c8 VSS N_5_M0_g 5.39086e-17
C_x_PM_SDFFR_X2%5_c9 VSS N_5_M22_g 6.10431e-17
R_x_PM_SDFFR_X2%5_r10 x_PM_SDFFR_X2%5_35 x_PM_SDFFR_X2%5_32 0.0303351
R_x_PM_SDFFR_X2%5_r11 x_PM_SDFFR_X2%5_34 x_PM_SDFFR_X2%5_32 0.30478
R_x_PM_SDFFR_X2%5_r12 x_PM_SDFFR_X2%5_36 x_PM_SDFFR_X2%5_32 25.0012
R_x_PM_SDFFR_X2%5_r13 N_5_M24_s x_PM_SDFFR_X2%5_34 1.12643
R_x_PM_SDFFR_X2%5_r14 N_5_M2_s x_PM_SDFFR_X2%5_35 3.16214
R_x_PM_SDFFR_X2%5_r15 x_PM_SDFFR_X2%5_36 x_PM_SDFFR_X2%5_19 26.26
R_x_PM_SDFFR_X2%5_r16 x_PM_SDFFR_X2%5_20 x_PM_SDFFR_X2%5_19 0.043368
R_x_PM_SDFFR_X2%5_r17 x_PM_SDFFR_X2%5_36 x_PM_SDFFR_X2%5_17 40.82
R_x_PM_SDFFR_X2%5_r18 x_PM_SDFFR_X2%5_18 x_PM_SDFFR_X2%5_17 0.043368
R_x_PM_SDFFR_X2%5_r19 x_PM_SDFFR_X2%5_20 x_PM_SDFFR_X2%5_13 4.56151
R_x_PM_SDFFR_X2%5_r20 N_5_M25_g x_PM_SDFFR_X2%5_13 52.26
R_x_PM_SDFFR_X2%5_r21 x_PM_SDFFR_X2%5_20 x_PM_SDFFR_X2%5_9 4.56151
R_x_PM_SDFFR_X2%5_r22 N_5_M3_g x_PM_SDFFR_X2%5_9 86.58
R_x_PM_SDFFR_X2%5_r23 x_PM_SDFFR_X2%5_18 x_PM_SDFFR_X2%5_5 4.56151
R_x_PM_SDFFR_X2%5_r24 N_5_M0_g x_PM_SDFFR_X2%5_5 48.36
R_x_PM_SDFFR_X2%5_r25 x_PM_SDFFR_X2%5_18 x_PM_SDFFR_X2%5_VSS 4.56151
R_x_PM_SDFFR_X2%5_r26 N_5_M22_g x_PM_SDFFR_X2%5_VSS 59.28
C_x_PM_SDFFR_X2%6_c0 VSS x_PM_SDFFR_X2%6_52 3.20993e-17
C_x_PM_SDFFR_X2%6_c1 VSS x_PM_SDFFR_X2%6_50 1.62681e-17
C_x_PM_SDFFR_X2%6_c2 VSS x_PM_SDFFR_X2%6_49 1.15085e-17
C_x_PM_SDFFR_X2%6_c3 VSS N_6_M8_d 2.87261e-16
C_x_PM_SDFFR_X2%6_c4 VSS x_PM_SDFFR_X2%6_41 1.94872e-17
C_x_PM_SDFFR_X2%6_c5 VSS x_PM_SDFFR_X2%6_37 1.83173e-17
C_x_PM_SDFFR_X2%6_c6 VSS x_PM_SDFFR_X2%6_36 1.29016e-16
C_x_PM_SDFFR_X2%6_c7 VSS x_PM_SDFFR_X2%6_34 1.01127e-17
C_x_PM_SDFFR_X2%6_c8 VSS x_PM_SDFFR_X2%6_31 2.07647e-17
C_x_PM_SDFFR_X2%6_c9 VSS x_PM_SDFFR_X2%6_30 4.11174e-17
C_x_PM_SDFFR_X2%6_c10 VSS x_PM_SDFFR_X2%6_29 2.04774e-17
C_x_PM_SDFFR_X2%6_c11 VSS x_PM_SDFFR_X2%6_27 1.52359e-17
C_x_PM_SDFFR_X2%6_c12 VSS x_PM_SDFFR_X2%6_25 1.62085e-17
C_x_PM_SDFFR_X2%6_c13 VSS x_PM_SDFFR_X2%6_24 6.62792e-18
C_x_PM_SDFFR_X2%6_c14 VSS N_6_M27_d 7.34137e-17
C_x_PM_SDFFR_X2%6_c15 VSS N_6_M24_g 4.30425e-17
C_x_PM_SDFFR_X2%6_c16 VSS N_6_M2_g 5.85746e-17
C_x_PM_SDFFR_X2%6_c17 VSS x_PM_SDFFR_X2%6_12 6.3055e-18
C_x_PM_SDFFR_X2%6_c18 VSS x_PM_SDFFR_X2%6_10 7.74665e-18
C_x_PM_SDFFR_X2%6_c19 VSS x_PM_SDFFR_X2%6_9 4.16017e-17
C_x_PM_SDFFR_X2%6_c20 VSS N_6_M1_g 4.22571e-17
C_x_PM_SDFFR_X2%6_c21 VSS N_6_M23_g 4.39674e-17
R_x_PM_SDFFR_X2%6_r22 x_PM_SDFFR_X2%6_52 x_PM_SDFFR_X2%6_51 3.4687
R_x_PM_SDFFR_X2%6_r23 x_PM_SDFFR_X2%6_49 x_PM_SDFFR_X2%6_55 3.9
R_x_PM_SDFFR_X2%6_r24 x_PM_SDFFR_X2%6_49 x_PM_SDFFR_X2%6_48 25.0012
R_x_PM_SDFFR_X2%6_r25 N_6_M8_d N_6_M4_d 4.39714
R_x_PM_SDFFR_X2%6_r26 N_6_M4_d x_PM_SDFFR_X2%6_41 0.665
R_x_PM_SDFFR_X2%6_r27 x_PM_SDFFR_X2%6_41 x_PM_SDFFR_X2%6_36 0.212317
R_x_PM_SDFFR_X2%6_r28 x_PM_SDFFR_X2%6_50 x_PM_SDFFR_X2%6_35 0.160909
R_x_PM_SDFFR_X2%6_r29 x_PM_SDFFR_X2%6_36 x_PM_SDFFR_X2%6_35 3.77286
R_x_PM_SDFFR_X2%6_r30 x_PM_SDFFR_X2%6_50 x_PM_SDFFR_X2%6_34 0.160909
R_x_PM_SDFFR_X2%6_r31 x_PM_SDFFR_X2%6_37 x_PM_SDFFR_X2%6_33 0.212317
R_x_PM_SDFFR_X2%6_r32 x_PM_SDFFR_X2%6_34 x_PM_SDFFR_X2%6_33 0.597143
R_x_PM_SDFFR_X2%6_r33 x_PM_SDFFR_X2%6_48 x_PM_SDFFR_X2%6_32 0.198162
R_x_PM_SDFFR_X2%6_r34 x_PM_SDFFR_X2%6_50 x_PM_SDFFR_X2%6_31 0.0418175
R_x_PM_SDFFR_X2%6_r35 x_PM_SDFFR_X2%6_32 x_PM_SDFFR_X2%6_31 0.977143
R_x_PM_SDFFR_X2%6_r36 x_PM_SDFFR_X2%6_48 x_PM_SDFFR_X2%6_29 0.0141545
R_x_PM_SDFFR_X2%6_r37 x_PM_SDFFR_X2%6_30 x_PM_SDFFR_X2%6_29 1.24857
R_x_PM_SDFFR_X2%6_r38 x_PM_SDFFR_X2%6_27 x_PM_SDFFR_X2%6_51 5.46
R_x_PM_SDFFR_X2%6_r39 x_PM_SDFFR_X2%6_27 x_PM_SDFFR_X2%6_25 25.0012
R_x_PM_SDFFR_X2%6_r40 x_PM_SDFFR_X2%6_30 x_PM_SDFFR_X2%6_24 0.196927
R_x_PM_SDFFR_X2%6_r41 x_PM_SDFFR_X2%6_25 x_PM_SDFFR_X2%6_24 0.130625
R_x_PM_SDFFR_X2%6_r42 N_6_M27_d x_PM_SDFFR_X2%6_37 1.83214
R_x_PM_SDFFR_X2%6_r43 x_PM_SDFFR_X2%6_55 x_PM_SDFFR_X2%6_17 1.95
R_x_PM_SDFFR_X2%6_r44 N_6_M24_g x_PM_SDFFR_X2%6_17 28.86
R_x_PM_SDFFR_X2%6_r45 x_PM_SDFFR_X2%6_51 x_PM_SDFFR_X2%6_13 1.95
R_x_PM_SDFFR_X2%6_r46 N_6_M2_g x_PM_SDFFR_X2%6_13 63.18
R_x_PM_SDFFR_X2%6_r47 x_PM_SDFFR_X2%6_12 x_PM_SDFFR_X2%6_52 41.34
R_x_PM_SDFFR_X2%6_r48 x_PM_SDFFR_X2%6_55 x_PM_SDFFR_X2%6_9 2.6
R_x_PM_SDFFR_X2%6_r49 x_PM_SDFFR_X2%6_10 x_PM_SDFFR_X2%6_9 30.16
R_x_PM_SDFFR_X2%6_r50 x_PM_SDFFR_X2%6_12 x_PM_SDFFR_X2%6_5 4.35808
R_x_PM_SDFFR_X2%6_r51 N_6_M1_g x_PM_SDFFR_X2%6_5 28.86
R_x_PM_SDFFR_X2%6_r52 x_PM_SDFFR_X2%6_10 x_PM_SDFFR_X2%6_VSS 4.58872
R_x_PM_SDFFR_X2%6_r53 N_6_M23_g x_PM_SDFFR_X2%6_VSS 35.88
C_x_PM_SDFFR_X2%7_c0 VSS x_PM_SDFFR_X2%7_52 4.75736e-17
C_x_PM_SDFFR_X2%7_c1 VSS x_PM_SDFFR_X2%7_50 1.1193e-17
C_x_PM_SDFFR_X2%7_c2 VSS x_PM_SDFFR_X2%7_48 2.36436e-16
C_x_PM_SDFFR_X2%7_c3 VSS N_7_M30_d 3.70113e-17
C_x_PM_SDFFR_X2%7_c4 VSS N_7_M9_s 2.56374e-16
C_x_PM_SDFFR_X2%7_c5 VSS x_PM_SDFFR_X2%7_37 4.40899e-17
C_x_PM_SDFFR_X2%7_c6 VSS x_PM_SDFFR_X2%7_36 9.32489e-18
C_x_PM_SDFFR_X2%7_c7 VSS x_PM_SDFFR_X2%7_33 3.56617e-17
C_x_PM_SDFFR_X2%7_c8 VSS x_PM_SDFFR_X2%7_32 1.12102e-16
C_x_PM_SDFFR_X2%7_c9 VSS x_PM_SDFFR_X2%7_31 1.70935e-16
C_x_PM_SDFFR_X2%7_c10 VSS x_PM_SDFFR_X2%7_27 9.59912e-18
C_x_PM_SDFFR_X2%7_c11 VSS x_PM_SDFFR_X2%7_25 4.64334e-18
C_x_PM_SDFFR_X2%7_c12 VSS x_PM_SDFFR_X2%7_24 1.71046e-17
C_x_PM_SDFFR_X2%7_c13 VSS x_PM_SDFFR_X2%7_23 7.31395e-18
C_x_PM_SDFFR_X2%7_c14 VSS N_7_M14_g 7.91394e-17
C_x_PM_SDFFR_X2%7_c15 VSS x_PM_SDFFR_X2%7_18 7.33808e-18
C_x_PM_SDFFR_X2%7_c16 VSS x_PM_SDFFR_X2%7_17 2.99849e-17
C_x_PM_SDFFR_X2%7_c17 VSS N_7_M34_g 3.25661e-17
C_x_PM_SDFFR_X2%7_c18 VSS N_7_M28_g 2.71112e-17
C_x_PM_SDFFR_X2%7_c19 VSS N_7_M5_g 2.7897e-17
C_x_PM_SDFFR_X2%7_c20 VSS N_7_M4_g 2.14646e-17
R_x_PM_SDFFR_X2%7_r21 x_PM_SDFFR_X2%7_55 x_PM_SDFFR_X2%7_52 0.176429
R_x_PM_SDFFR_X2%7_r22 x_PM_SDFFR_X2%7_50 x_PM_SDFFR_X2%7_49 0.160909
R_x_PM_SDFFR_X2%7_r23 x_PM_SDFFR_X2%7_55 x_PM_SDFFR_X2%7_48 0.095
R_x_PM_SDFFR_X2%7_r24 x_PM_SDFFR_X2%7_49 x_PM_SDFFR_X2%7_48 4.94
R_x_PM_SDFFR_X2%7_r25 x_PM_SDFFR_X2%7_50 x_PM_SDFFR_X2%7_44 0.0418175
R_x_PM_SDFFR_X2%7_r26 N_7_M30_d x_PM_SDFFR_X2%7_44 0.827857
R_x_PM_SDFFR_X2%7_r27 x_PM_SDFFR_X2%7_40 x_PM_SDFFR_X2%7_38 25.0012
R_x_PM_SDFFR_X2%7_r28 N_7_M9_s x_PM_SDFFR_X2%7_38 4.88571
R_x_PM_SDFFR_X2%7_r29 x_PM_SDFFR_X2%7_38 x_PM_SDFFR_X2%7_37 0.285
R_x_PM_SDFFR_X2%7_r30 x_PM_SDFFR_X2%7_60 x_PM_SDFFR_X2%7_36 4.7687
R_x_PM_SDFFR_X2%7_r31 x_PM_SDFFR_X2%7_36 x_PM_SDFFR_X2%7_34 25.0012
R_x_PM_SDFFR_X2%7_r32 x_PM_SDFFR_X2%7_34 x_PM_SDFFR_X2%7_33 1.69643
R_x_PM_SDFFR_X2%7_r33 x_PM_SDFFR_X2%7_50 x_PM_SDFFR_X2%7_32 0.160909
R_x_PM_SDFFR_X2%7_r34 x_PM_SDFFR_X2%7_34 x_PM_SDFFR_X2%7_32 2.29357
R_x_PM_SDFFR_X2%7_r35 x_PM_SDFFR_X2%7_37 x_PM_SDFFR_X2%7_31 0.212317
R_x_PM_SDFFR_X2%7_r36 x_PM_SDFFR_X2%7_33 x_PM_SDFFR_X2%7_30 0.212317
R_x_PM_SDFFR_X2%7_r37 x_PM_SDFFR_X2%7_31 x_PM_SDFFR_X2%7_30 3.01286
R_x_PM_SDFFR_X2%7_r38 x_PM_SDFFR_X2%7_25 x_PM_SDFFR_X2%7_52 25.0012
R_x_PM_SDFFR_X2%7_r39 x_PM_SDFFR_X2%7_25 x_PM_SDFFR_X2%7_27 8.58
R_x_PM_SDFFR_X2%7_r40 x_PM_SDFFR_X2%7_40 x_PM_SDFFR_X2%7_24 0.78
R_x_PM_SDFFR_X2%7_r41 x_PM_SDFFR_X2%7_40 x_PM_SDFFR_X2%7_23 13.78
R_x_PM_SDFFR_X2%7_r42 N_7_M14_g x_PM_SDFFR_X2%7_19 76.44
R_x_PM_SDFFR_X2%7_r43 x_PM_SDFFR_X2%7_27 x_PM_SDFFR_X2%7_18 4.58872
R_x_PM_SDFFR_X2%7_r44 x_PM_SDFFR_X2%7_19 x_PM_SDFFR_X2%7_17 4.35808
R_x_PM_SDFFR_X2%7_r45 x_PM_SDFFR_X2%7_18 x_PM_SDFFR_X2%7_17 30.42
R_x_PM_SDFFR_X2%7_r46 x_PM_SDFFR_X2%7_13 x_PM_SDFFR_X2%7_25 4.5205
R_x_PM_SDFFR_X2%7_r47 N_7_M34_g x_PM_SDFFR_X2%7_13 33.54
R_x_PM_SDFFR_X2%7_r48 N_7_M28_g x_PM_SDFFR_X2%7_60 24.18
R_x_PM_SDFFR_X2%7_r49 x_PM_SDFFR_X2%7_24 x_PM_SDFFR_X2%7_5 4.58872
R_x_PM_SDFFR_X2%7_r50 N_7_M5_g x_PM_SDFFR_X2%7_5 21.84
R_x_PM_SDFFR_X2%7_r51 x_PM_SDFFR_X2%7_23 x_PM_SDFFR_X2%7_VSS 4.58872
R_x_PM_SDFFR_X2%7_r52 N_7_M4_g x_PM_SDFFR_X2%7_VSS 17.16
C_x_PM_SDFFR_X2%8_c0 VSS x_PM_SDFFR_X2%8_76 1.52774e-17
C_x_PM_SDFFR_X2%8_c1 VSS x_PM_SDFFR_X2%8_64 2.48653e-17
C_x_PM_SDFFR_X2%8_c2 VSS N_8_M16_d 6.38077e-17
C_x_PM_SDFFR_X2%8_c3 VSS x_PM_SDFFR_X2%8_55 2.39648e-17
C_x_PM_SDFFR_X2%8_c4 VSS x_PM_SDFFR_X2%8_54 1.00105e-16
C_x_PM_SDFFR_X2%8_c5 VSS x_PM_SDFFR_X2%8_53 4.98546e-17
C_x_PM_SDFFR_X2%8_c6 VSS x_PM_SDFFR_X2%8_51 1.61637e-17
C_x_PM_SDFFR_X2%8_c7 VSS x_PM_SDFFR_X2%8_49 1.4761e-16
C_x_PM_SDFFR_X2%8_c8 VSS x_PM_SDFFR_X2%8_46 2.57177e-17
C_x_PM_SDFFR_X2%8_c9 VSS x_PM_SDFFR_X2%8_45 9.82237e-17
C_x_PM_SDFFR_X2%8_c10 VSS x_PM_SDFFR_X2%8_42 1.015e-16
C_x_PM_SDFFR_X2%8_c11 VSS x_PM_SDFFR_X2%8_39 9.55461e-18
C_x_PM_SDFFR_X2%8_c12 VSS x_PM_SDFFR_X2%8_36 7.94069e-18
C_x_PM_SDFFR_X2%8_c13 VSS x_PM_SDFFR_X2%8_33 2.59555e-17
C_x_PM_SDFFR_X2%8_c14 VSS x_PM_SDFFR_X2%8_32 5.08473e-16
C_x_PM_SDFFR_X2%8_c15 VSS x_PM_SDFFR_X2%8_30 9.4527e-18
C_x_PM_SDFFR_X2%8_c16 VSS x_PM_SDFFR_X2%8_28 4.53003e-17
C_x_PM_SDFFR_X2%8_c17 VSS N_8_M37_d 2.1672e-17
C_x_PM_SDFFR_X2%8_c18 VSS N_8_M35_g 2.97668e-17
C_x_PM_SDFFR_X2%8_c19 VSS N_8_M13_g 3.19479e-17
C_x_PM_SDFFR_X2%8_c20 VSS N_8_M9_g 5.36076e-17
C_x_PM_SDFFR_X2%8_c21 VSS N_8_M8_g 6.97764e-17
C_x_PM_SDFFR_X2%8_c22 VSS N_8_M30_g 7.32044e-17
C_x_PM_SDFFR_X2%8_c23 VSS N_8_M27_g 4.82896e-17
R_x_PM_SDFFR_X2%8_r24 x_PM_SDFFR_X2%8_64 x_PM_SDFFR_X2%8_56 0.0418175
R_x_PM_SDFFR_X2%8_r25 N_8_M16_d x_PM_SDFFR_X2%8_56 2.185
R_x_PM_SDFFR_X2%8_r26 x_PM_SDFFR_X2%8_60 x_PM_SDFFR_X2%8_54 0.212317
R_x_PM_SDFFR_X2%8_r27 x_PM_SDFFR_X2%8_55 x_PM_SDFFR_X2%8_54 1.87286
R_x_PM_SDFFR_X2%8_r28 x_PM_SDFFR_X2%8_64 x_PM_SDFFR_X2%8_52 0.160909
R_x_PM_SDFFR_X2%8_r29 x_PM_SDFFR_X2%8_53 x_PM_SDFFR_X2%8_52 1.52
R_x_PM_SDFFR_X2%8_r30 x_PM_SDFFR_X2%8_51 x_PM_SDFFR_X2%8_78 5.46
R_x_PM_SDFFR_X2%8_r31 x_PM_SDFFR_X2%8_51 x_PM_SDFFR_X2%8_49 25.0012
R_x_PM_SDFFR_X2%8_r32 x_PM_SDFFR_X2%8_64 x_PM_SDFFR_X2%8_48 0.160909
R_x_PM_SDFFR_X2%8_r33 x_PM_SDFFR_X2%8_49 x_PM_SDFFR_X2%8_48 2.565
R_x_PM_SDFFR_X2%8_r34 x_PM_SDFFR_X2%8_55 x_PM_SDFFR_X2%8_47 0.212317
R_x_PM_SDFFR_X2%8_r35 x_PM_SDFFR_X2%8_49 x_PM_SDFFR_X2%8_47 0.149286
R_x_PM_SDFFR_X2%8_r36 x_PM_SDFFR_X2%8_53 x_PM_SDFFR_X2%8_45 0.212317
R_x_PM_SDFFR_X2%8_r37 x_PM_SDFFR_X2%8_46 x_PM_SDFFR_X2%8_45 1.22143
R_x_PM_SDFFR_X2%8_r38 x_PM_SDFFR_X2%8_76 x_PM_SDFFR_X2%8_44 7.02
R_x_PM_SDFFR_X2%8_r39 x_PM_SDFFR_X2%8_44 x_PM_SDFFR_X2%8_42 25.0012
R_x_PM_SDFFR_X2%8_r40 x_PM_SDFFR_X2%8_46 x_PM_SDFFR_X2%8_41 0.212317
R_x_PM_SDFFR_X2%8_r41 x_PM_SDFFR_X2%8_42 x_PM_SDFFR_X2%8_41 2.04929
R_x_PM_SDFFR_X2%8_r42 x_PM_SDFFR_X2%8_42 x_PM_SDFFR_X2%8_40 0.312143
R_x_PM_SDFFR_X2%8_r43 x_PM_SDFFR_X2%8_73 x_PM_SDFFR_X2%8_39 4.7687
R_x_PM_SDFFR_X2%8_r44 x_PM_SDFFR_X2%8_39 x_PM_SDFFR_X2%8_37 25.0012
R_x_PM_SDFFR_X2%8_r45 x_PM_SDFFR_X2%8_70 x_PM_SDFFR_X2%8_36 4.7687
R_x_PM_SDFFR_X2%8_r46 x_PM_SDFFR_X2%8_69 x_PM_SDFFR_X2%8_36 4.7687
R_x_PM_SDFFR_X2%8_r47 x_PM_SDFFR_X2%8_36 x_PM_SDFFR_X2%8_34 25.0012
R_x_PM_SDFFR_X2%8_r48 x_PM_SDFFR_X2%8_37 x_PM_SDFFR_X2%8_34 1.98143
R_x_PM_SDFFR_X2%8_r49 x_PM_SDFFR_X2%8_34 x_PM_SDFFR_X2%8_33 3.02643
R_x_PM_SDFFR_X2%8_r50 x_PM_SDFFR_X2%8_40 x_PM_SDFFR_X2%8_32 0.212317
R_x_PM_SDFFR_X2%8_r51 x_PM_SDFFR_X2%8_37 x_PM_SDFFR_X2%8_32 3.56929
R_x_PM_SDFFR_X2%8_r52 x_PM_SDFFR_X2%8_66 x_PM_SDFFR_X2%8_30 4.7687
R_x_PM_SDFFR_X2%8_r53 x_PM_SDFFR_X2%8_30 x_PM_SDFFR_X2%8_28 25.0012
R_x_PM_SDFFR_X2%8_r54 x_PM_SDFFR_X2%8_33 x_PM_SDFFR_X2%8_27 0.212317
R_x_PM_SDFFR_X2%8_r55 x_PM_SDFFR_X2%8_28 x_PM_SDFFR_X2%8_27 0.475
R_x_PM_SDFFR_X2%8_r56 N_8_M37_d x_PM_SDFFR_X2%8_60 0.149286
R_x_PM_SDFFR_X2%8_r57 x_PM_SDFFR_X2%8_78 x_PM_SDFFR_X2%8_21 1.95
R_x_PM_SDFFR_X2%8_r58 N_8_M35_g x_PM_SDFFR_X2%8_21 21.84
R_x_PM_SDFFR_X2%8_r59 x_PM_SDFFR_X2%8_76 x_PM_SDFFR_X2%8_17 1.95
R_x_PM_SDFFR_X2%8_r60 N_8_M13_g x_PM_SDFFR_X2%8_17 33.54
R_x_PM_SDFFR_X2%8_r61 N_8_M9_g x_PM_SDFFR_X2%8_73 54.6
R_x_PM_SDFFR_X2%8_r62 N_8_M8_g x_PM_SDFFR_X2%8_70 74.1
R_x_PM_SDFFR_X2%8_r63 N_8_M30_g x_PM_SDFFR_X2%8_69 76.44
R_x_PM_SDFFR_X2%8_r64 N_8_M27_g x_PM_SDFFR_X2%8_66 50.7
C_x_PM_SDFFR_X2%RN_c0 VSS x_PM_SDFFR_X2%RN_34 1.26854e-17
C_x_PM_SDFFR_X2%RN_c1 VSS x_PM_SDFFR_X2%RN_30 6.44176e-17
C_x_PM_SDFFR_X2%RN_c2 VSS x_PM_SDFFR_X2%RN_20 2.83351e-16
C_x_PM_SDFFR_X2%RN_c3 VSS N_RN_M11_g 4.67636e-17
C_x_PM_SDFFR_X2%RN_c4 VSS N_RN_M32_g 9.04834e-17
C_x_PM_SDFFR_X2%RN_c5 VSS N_RN_M6_g 4.99189e-17
C_x_PM_SDFFR_X2%RN_c6 VSS x_PM_SDFFR_X2%RN_7 4.66661e-18
C_x_PM_SDFFR_X2%RN_c7 VSS x_PM_SDFFR_X2%RN_6 8.39507e-18
C_x_PM_SDFFR_X2%RN_c8 VSS x_PM_SDFFR_X2%RN_5 3.61123e-17
C_x_PM_SDFFR_X2%RN_c9 VSS N_RN_M26_g 8.14054e-17
R_x_PM_SDFFR_X2%RN_r10 x_PM_SDFFR_X2%RN_30 RN 0.284786
R_x_PM_SDFFR_X2%RN_r11 x_PM_SDFFR_X2%RN_26 x_PM_SDFFR_X2%RN_24 25.0012
R_x_PM_SDFFR_X2%RN_r12 RN x_PM_SDFFR_X2%RN_24 0.00703704
R_x_PM_SDFFR_X2%RN_r13 x_PM_SDFFR_X2%RN_34 x_PM_SDFFR_X2%RN_22 3.38
R_x_PM_SDFFR_X2%RN_r14 x_PM_SDFFR_X2%RN_22 x_PM_SDFFR_X2%RN_31 1.3
R_x_PM_SDFFR_X2%RN_r15 x_PM_SDFFR_X2%RN_22 x_PM_SDFFR_X2%RN_20 25.0012
R_x_PM_SDFFR_X2%RN_r16 x_PM_SDFFR_X2%RN_20 x_PM_SDFFR_X2%RN_30 5.76786
R_x_PM_SDFFR_X2%RN_r17 x_PM_SDFFR_X2%RN_34 x_PM_SDFFR_X2%RN_15 1.95
R_x_PM_SDFFR_X2%RN_r18 N_RN_M11_g x_PM_SDFFR_X2%RN_15 37.83
R_x_PM_SDFFR_X2%RN_r19 x_PM_SDFFR_X2%RN_31 x_PM_SDFFR_X2%RN_11 1.95
R_x_PM_SDFFR_X2%RN_r20 N_RN_M32_g x_PM_SDFFR_X2%RN_11 104.52
R_x_PM_SDFFR_X2%RN_r21 x_PM_SDFFR_X2%RN_26 x_PM_SDFFR_X2%RN_7 4.03807
R_x_PM_SDFFR_X2%RN_r22 N_RN_M6_g x_PM_SDFFR_X2%RN_7 47.58
R_x_PM_SDFFR_X2%RN_r23 x_PM_SDFFR_X2%RN_26 x_PM_SDFFR_X2%RN_5 0.550646
R_x_PM_SDFFR_X2%RN_r24 x_PM_SDFFR_X2%RN_6 x_PM_SDFFR_X2%RN_5 31.72
R_x_PM_SDFFR_X2%RN_r25 x_PM_SDFFR_X2%RN_6 x_PM_SDFFR_X2%RN_VSS 4.58872
R_x_PM_SDFFR_X2%RN_r26 N_RN_M26_g x_PM_SDFFR_X2%RN_VSS 95.94
C_x_PM_SDFFR_X2%10_c0 VSS x_PM_SDFFR_X2%10_47 1.08026e-17
C_x_PM_SDFFR_X2%10_c1 VSS N_10_M13_d 7.51171e-17
C_x_PM_SDFFR_X2%10_c2 VSS x_PM_SDFFR_X2%10_36 2.5361e-17
C_x_PM_SDFFR_X2%10_c3 VSS x_PM_SDFFR_X2%10_35 7.4651e-18
C_x_PM_SDFFR_X2%10_c4 VSS x_PM_SDFFR_X2%10_34 1.11103e-16
C_x_PM_SDFFR_X2%10_c5 VSS x_PM_SDFFR_X2%10_32 7.49293e-17
C_x_PM_SDFFR_X2%10_c6 VSS x_PM_SDFFR_X2%10_22 8.40009e-18
C_x_PM_SDFFR_X2%10_c7 VSS x_PM_SDFFR_X2%10_19 4.02455e-16
C_x_PM_SDFFR_X2%10_c8 VSS N_10_M34_d 3.10385e-17
C_x_PM_SDFFR_X2%10_c9 VSS N_10_M10_g 6.16609e-17
C_x_PM_SDFFR_X2%10_c10 VSS N_10_M31_g 5.76304e-17
C_x_PM_SDFFR_X2%10_c11 VSS N_10_M7_g 8.57339e-17
C_x_PM_SDFFR_X2%10_c12 VSS N_10_M29_g 4.40529e-17
R_x_PM_SDFFR_X2%10_r13 x_PM_SDFFR_X2%10_34 N_10_M13_d 0.297071
R_x_PM_SDFFR_X2%10_r14 x_PM_SDFFR_X2%10_36 x_PM_SDFFR_X2%10_33 0.160909
R_x_PM_SDFFR_X2%10_r15 x_PM_SDFFR_X2%10_34 x_PM_SDFFR_X2%10_33 2.00857
R_x_PM_SDFFR_X2%10_r16 x_PM_SDFFR_X2%10_36 x_PM_SDFFR_X2%10_32 0.160909
R_x_PM_SDFFR_X2%10_r17 x_PM_SDFFR_X2%10_32 x_PM_SDFFR_X2%10_35 1.38429
R_x_PM_SDFFR_X2%10_r18 x_PM_SDFFR_X2%10_35 x_PM_SDFFR_X2%10_27 0.196927
R_x_PM_SDFFR_X2%10_r19 x_PM_SDFFR_X2%10_47 x_PM_SDFFR_X2%10_26 3.38
R_x_PM_SDFFR_X2%10_r20 x_PM_SDFFR_X2%10_26 x_PM_SDFFR_X2%10_44 1.3
R_x_PM_SDFFR_X2%10_r21 x_PM_SDFFR_X2%10_26 x_PM_SDFFR_X2%10_24 25.0012
R_x_PM_SDFFR_X2%10_r22 x_PM_SDFFR_X2%10_43 x_PM_SDFFR_X2%10_22 4.7687
R_x_PM_SDFFR_X2%10_r23 x_PM_SDFFR_X2%10_42 x_PM_SDFFR_X2%10_22 4.7687
R_x_PM_SDFFR_X2%10_r24 x_PM_SDFFR_X2%10_22 x_PM_SDFFR_X2%10_20 25.0012
R_x_PM_SDFFR_X2%10_r25 x_PM_SDFFR_X2%10_24 x_PM_SDFFR_X2%10_20 3.8
R_x_PM_SDFFR_X2%10_r26 x_PM_SDFFR_X2%10_36 x_PM_SDFFR_X2%10_19 0.0418175
R_x_PM_SDFFR_X2%10_r27 x_PM_SDFFR_X2%10_24 x_PM_SDFFR_X2%10_19 3.515
R_x_PM_SDFFR_X2%10_r28 N_10_M34_d x_PM_SDFFR_X2%10_27 0.130625
R_x_PM_SDFFR_X2%10_r29 x_PM_SDFFR_X2%10_47 x_PM_SDFFR_X2%10_13 1.95
R_x_PM_SDFFR_X2%10_r30 N_10_M10_g x_PM_SDFFR_X2%10_13 69.42
R_x_PM_SDFFR_X2%10_r31 x_PM_SDFFR_X2%10_44 x_PM_SDFFR_X2%10_9 1.95
R_x_PM_SDFFR_X2%10_r32 N_10_M31_g x_PM_SDFFR_X2%10_9 62.4
R_x_PM_SDFFR_X2%10_r33 N_10_M7_g x_PM_SDFFR_X2%10_43 95.16
R_x_PM_SDFFR_X2%10_r34 N_10_M29_g x_PM_SDFFR_X2%10_42 48.36
C_x_PM_SDFFR_X2%11_c0 VSS x_PM_SDFFR_X2%11_34 1.24421e-17
C_x_PM_SDFFR_X2%11_c1 VSS x_PM_SDFFR_X2%11_32 7.74982e-17
C_x_PM_SDFFR_X2%11_c2 VSS N_11_M31_s 7.09856e-17
C_x_PM_SDFFR_X2%11_c3 VSS x_PM_SDFFR_X2%11_24 3.15652e-17
C_x_PM_SDFFR_X2%11_c4 VSS x_PM_SDFFR_X2%11_18 6.92429e-17
C_x_PM_SDFFR_X2%11_c5 VSS x_PM_SDFFR_X2%11_15 1.30116e-16
C_x_PM_SDFFR_X2%11_c6 VSS x_PM_SDFFR_X2%11_9 3.93801e-18
C_x_PM_SDFFR_X2%11_c7 VSS N_11_M12_g 1.84011e-17
C_x_PM_SDFFR_X2%11_c8 VSS N_11_M33_g 2.36317e-17
R_x_PM_SDFFR_X2%11_r9 x_PM_SDFFR_X2%11_36 x_PM_SDFFR_X2%11_34 5.00559
R_x_PM_SDFFR_X2%11_r10 x_PM_SDFFR_X2%11_32 x_PM_SDFFR_X2%11_34 3.45391
R_x_PM_SDFFR_X2%11_r11 x_PM_SDFFR_X2%11_30 N_11_M31_s 0.288519
R_x_PM_SDFFR_X2%11_r12 x_PM_SDFFR_X2%11_34 x_PM_SDFFR_X2%11_24 25.0012
R_x_PM_SDFFR_X2%11_r13 x_PM_SDFFR_X2%11_24 x_PM_SDFFR_X2%11_22 0.475
R_x_PM_SDFFR_X2%11_r14 x_PM_SDFFR_X2%11_22 x_PM_SDFFR_X2%11_18 0.212317
R_x_PM_SDFFR_X2%11_r15 N_11_M10_d x_PM_SDFFR_X2%11_18 1.28929
R_x_PM_SDFFR_X2%11_r16 x_PM_SDFFR_X2%11_30 x_PM_SDFFR_X2%11_13 0.095
R_x_PM_SDFFR_X2%11_r17 x_PM_SDFFR_X2%11_15 x_PM_SDFFR_X2%11_13 2.375
R_x_PM_SDFFR_X2%11_r18 x_PM_SDFFR_X2%11_9 x_PM_SDFFR_X2%11_15 25.0012
R_x_PM_SDFFR_X2%11_r19 x_PM_SDFFR_X2%11_9 x_PM_SDFFR_X2%11_32 62.14
R_x_PM_SDFFR_X2%11_r20 N_11_M12_g x_PM_SDFFR_X2%11_36 14.82
R_x_PM_SDFFR_X2%11_r21 x_PM_SDFFR_X2%11_VSS x_PM_SDFFR_X2%11_9 4.7687
R_x_PM_SDFFR_X2%11_r22 N_11_M33_g x_PM_SDFFR_X2%11_VSS 17.94
C_x_PM_SDFFR_X2%12_c0 VSS x_PM_SDFFR_X2%12_36 1.17038e-17
C_x_PM_SDFFR_X2%12_c1 VSS x_PM_SDFFR_X2%12_32 1.01892e-17
C_x_PM_SDFFR_X2%12_c2 VSS N_12_M18_d 1.96453e-17
C_x_PM_SDFFR_X2%12_c3 VSS x_PM_SDFFR_X2%12_24 1.58073e-17
C_x_PM_SDFFR_X2%12_c4 VSS x_PM_SDFFR_X2%12_23 8.36132e-18
C_x_PM_SDFFR_X2%12_c5 VSS x_PM_SDFFR_X2%12_21 1.6056e-17
C_x_PM_SDFFR_X2%12_c6 VSS x_PM_SDFFR_X2%12_20 8.83514e-17
C_x_PM_SDFFR_X2%12_c7 VSS x_PM_SDFFR_X2%12_18 4.81604e-17
C_x_PM_SDFFR_X2%12_c8 VSS x_PM_SDFFR_X2%12_17 9.60712e-17
C_x_PM_SDFFR_X2%12_c9 VSS x_PM_SDFFR_X2%12_11 1.11385e-16
C_x_PM_SDFFR_X2%12_c10 VSS N_12_M39_d 5.26604e-17
C_x_PM_SDFFR_X2%12_c11 VSS N_12_M15_g 7.06571e-17
C_x_PM_SDFFR_X2%12_c12 VSS N_12_M36_g 4.14271e-17
R_x_PM_SDFFR_X2%12_r13 N_12_M18_d x_PM_SDFFR_X2%12_28 0.420714
R_x_PM_SDFFR_X2%12_r14 x_PM_SDFFR_X2%12_24 x_PM_SDFFR_X2%12_22 0.212317
R_x_PM_SDFFR_X2%12_r15 x_PM_SDFFR_X2%12_23 x_PM_SDFFR_X2%12_22 0.407143
R_x_PM_SDFFR_X2%12_r16 x_PM_SDFFR_X2%12_28 x_PM_SDFFR_X2%12_20 0.212317
R_x_PM_SDFFR_X2%12_r17 x_PM_SDFFR_X2%12_21 x_PM_SDFFR_X2%12_20 1.79143
R_x_PM_SDFFR_X2%12_r18 x_PM_SDFFR_X2%12_32 x_PM_SDFFR_X2%12_19 0.160909
R_x_PM_SDFFR_X2%12_r19 x_PM_SDFFR_X2%12_23 x_PM_SDFFR_X2%12_18 0.212317
R_x_PM_SDFFR_X2%12_r20 x_PM_SDFFR_X2%12_19 x_PM_SDFFR_X2%12_18 0.651429
R_x_PM_SDFFR_X2%12_r21 x_PM_SDFFR_X2%12_21 x_PM_SDFFR_X2%12_17 0.212317
R_x_PM_SDFFR_X2%12_r22 x_PM_SDFFR_X2%12_32 x_PM_SDFFR_X2%12_16 0.0418175
R_x_PM_SDFFR_X2%12_r23 x_PM_SDFFR_X2%12_17 x_PM_SDFFR_X2%12_16 2.52429
R_x_PM_SDFFR_X2%12_r24 x_PM_SDFFR_X2%12_36 x_PM_SDFFR_X2%12_14 1.3
R_x_PM_SDFFR_X2%12_r25 x_PM_SDFFR_X2%12_14 x_PM_SDFFR_X2%12_33 3.38
R_x_PM_SDFFR_X2%12_r26 x_PM_SDFFR_X2%12_14 x_PM_SDFFR_X2%12_12 25.0012
R_x_PM_SDFFR_X2%12_r27 x_PM_SDFFR_X2%12_32 x_PM_SDFFR_X2%12_11 0.160909
R_x_PM_SDFFR_X2%12_r28 x_PM_SDFFR_X2%12_12 x_PM_SDFFR_X2%12_11 2.32071
R_x_PM_SDFFR_X2%12_r29 N_12_M39_d x_PM_SDFFR_X2%12_24 0.963571
R_x_PM_SDFFR_X2%12_r30 x_PM_SDFFR_X2%12_36 x_PM_SDFFR_X2%12_5 1.95
R_x_PM_SDFFR_X2%12_r31 N_12_M15_g x_PM_SDFFR_X2%12_5 85.02
R_x_PM_SDFFR_X2%12_r32 x_PM_SDFFR_X2%12_33 x_PM_SDFFR_X2%12_VSS 1.95
R_x_PM_SDFFR_X2%12_r33 N_12_M36_g x_PM_SDFFR_X2%12_VSS 32.76
C_x_PM_SDFFR_X2%CK_c0 VSS x_PM_SDFFR_X2%CK_19 1.20472e-17
C_x_PM_SDFFR_X2%CK_c1 VSS x_PM_SDFFR_X2%CK_12 3.52207e-17
C_x_PM_SDFFR_X2%CK_c2 VSS N_CK_M16_g 5.36496e-17
C_x_PM_SDFFR_X2%CK_c3 VSS N_CK_M37_g 6.26997e-17
R_x_PM_SDFFR_X2%CK_r4 x_PM_SDFFR_X2%CK_19 x_PM_SDFFR_X2%CK_14 3.38
R_x_PM_SDFFR_X2%CK_r5 x_PM_SDFFR_X2%CK_14 x_PM_SDFFR_X2%CK_16 1.3
R_x_PM_SDFFR_X2%CK_r6 x_PM_SDFFR_X2%CK_14 x_PM_SDFFR_X2%CK_12 25.0012
R_x_PM_SDFFR_X2%CK_r7 x_PM_SDFFR_X2%CK_12 CK 0.0203571
R_x_PM_SDFFR_X2%CK_r8 x_PM_SDFFR_X2%CK_19 x_PM_SDFFR_X2%CK_5 1.95
R_x_PM_SDFFR_X2%CK_r9 N_CK_M16_g x_PM_SDFFR_X2%CK_5 46.8
R_x_PM_SDFFR_X2%CK_r10 x_PM_SDFFR_X2%CK_16 x_PM_SDFFR_X2%CK_VSS 1.95
R_x_PM_SDFFR_X2%CK_r11 N_CK_M37_g x_PM_SDFFR_X2%CK_VSS 63.96
C_x_PM_SDFFR_X2%D_c0 VSS x_PM_SDFFR_X2%D_21 1.17034e-17
C_x_PM_SDFFR_X2%D_c1 VSS D 2.74108e-17
C_x_PM_SDFFR_X2%D_c2 VSS x_PM_SDFFR_X2%D_15 3.96709e-17
C_x_PM_SDFFR_X2%D_c3 VSS x_PM_SDFFR_X2%D_14 1.01187e-16
C_x_PM_SDFFR_X2%D_c4 VSS x_PM_SDFFR_X2%D_12 1.14329e-17
C_x_PM_SDFFR_X2%D_c5 VSS x_PM_SDFFR_X2%D_10 7.32586e-17
C_x_PM_SDFFR_X2%D_c6 VSS N_D_M20_g 3.76164e-17
C_x_PM_SDFFR_X2%D_c7 VSS N_D_M38_g 4.42454e-17
R_x_PM_SDFFR_X2%D_r8 x_PM_SDFFR_X2%D_27 x_PM_SDFFR_X2%D_21 4.7687
R_x_PM_SDFFR_X2%D_r9 x_PM_SDFFR_X2%D_21 x_PM_SDFFR_X2%D_19 25.0012
R_x_PM_SDFFR_X2%D_r10 x_PM_SDFFR_X2%D_19 D 0.17
R_x_PM_SDFFR_X2%D_r11 D x_PM_SDFFR_X2%D_16 0.18
R_x_PM_SDFFR_X2%D_r12 x_PM_SDFFR_X2%D_16 x_PM_SDFFR_X2%D_14 0.218718
R_x_PM_SDFFR_X2%D_r13 x_PM_SDFFR_X2%D_15 x_PM_SDFFR_X2%D_14 2.41571
R_x_PM_SDFFR_X2%D_r14 x_PM_SDFFR_X2%D_23 x_PM_SDFFR_X2%D_12 4.7687
R_x_PM_SDFFR_X2%D_r15 x_PM_SDFFR_X2%D_12 x_PM_SDFFR_X2%D_10 25.0012
R_x_PM_SDFFR_X2%D_r16 x_PM_SDFFR_X2%D_15 x_PM_SDFFR_X2%D_9 0.212317
R_x_PM_SDFFR_X2%D_r17 x_PM_SDFFR_X2%D_10 x_PM_SDFFR_X2%D_9 1.07214
R_x_PM_SDFFR_X2%D_r18 N_D_M20_g x_PM_SDFFR_X2%D_27 28.86
R_x_PM_SDFFR_X2%D_r19 N_D_M38_g x_PM_SDFFR_X2%D_23 39.78
C_x_PM_SDFFR_X2%15_c0 VSS x_PM_SDFFR_X2%15_26 2.18387e-18
C_x_PM_SDFFR_X2%15_c1 VSS N_15_M21_d 5.8346e-17
C_x_PM_SDFFR_X2%15_c2 VSS x_PM_SDFFR_X2%15_17 3.4205e-17
C_x_PM_SDFFR_X2%15_c3 VSS x_PM_SDFFR_X2%15_16 9.05762e-17
C_x_PM_SDFFR_X2%15_c4 VSS x_PM_SDFFR_X2%15_14 8.52879e-18
C_x_PM_SDFFR_X2%15_c5 VSS x_PM_SDFFR_X2%15_12 8.48833e-18
C_x_PM_SDFFR_X2%15_c6 VSS N_15_M42_d 1.32575e-17
C_x_PM_SDFFR_X2%15_c7 VSS N_15_M18_g 9.05338e-17
C_x_PM_SDFFR_X2%15_c8 VSS N_15_M39_g 3.29469e-17
R_x_PM_SDFFR_X2%15_r9 x_PM_SDFFR_X2%15_26 x_PM_SDFFR_X2%15_22 0.160909
R_x_PM_SDFFR_X2%15_r10 N_15_M21_d x_PM_SDFFR_X2%15_22 3.37929
R_x_PM_SDFFR_X2%15_r11 x_PM_SDFFR_X2%15_26 x_PM_SDFFR_X2%15_18 0.160909
R_x_PM_SDFFR_X2%15_r12 x_PM_SDFFR_X2%15_26 x_PM_SDFFR_X2%15_16 0.0418175
R_x_PM_SDFFR_X2%15_r13 x_PM_SDFFR_X2%15_17 x_PM_SDFFR_X2%15_16 3.12143
R_x_PM_SDFFR_X2%15_r14 x_PM_SDFFR_X2%15_29 x_PM_SDFFR_X2%15_14 4.7687
R_x_PM_SDFFR_X2%15_r15 x_PM_SDFFR_X2%15_28 x_PM_SDFFR_X2%15_14 4.7687
R_x_PM_SDFFR_X2%15_r16 x_PM_SDFFR_X2%15_14 x_PM_SDFFR_X2%15_12 25.0012
R_x_PM_SDFFR_X2%15_r17 x_PM_SDFFR_X2%15_17 x_PM_SDFFR_X2%15_11 0.212317
R_x_PM_SDFFR_X2%15_r18 x_PM_SDFFR_X2%15_12 x_PM_SDFFR_X2%15_11 0.149286
R_x_PM_SDFFR_X2%15_r19 N_15_M42_d x_PM_SDFFR_X2%15_18 0.149286
R_x_PM_SDFFR_X2%15_r20 N_15_M18_g x_PM_SDFFR_X2%15_29 102.18
R_x_PM_SDFFR_X2%15_r21 N_15_M39_g x_PM_SDFFR_X2%15_28 21.84
C_x_PM_SDFFR_X2%SE_c0 VSS x_PM_SDFFR_X2%SE_28 9.4901e-18
C_x_PM_SDFFR_X2%SE_c1 VSS x_PM_SDFFR_X2%SE_26 3.88631e-17
C_x_PM_SDFFR_X2%SE_c2 VSS x_PM_SDFFR_X2%SE_22 4.45005e-18
C_x_PM_SDFFR_X2%SE_c3 VSS x_PM_SDFFR_X2%SE_21 4.60738e-18
C_x_PM_SDFFR_X2%SE_c4 VSS N_SE_M21_g 5.81856e-17
C_x_PM_SDFFR_X2%SE_c5 VSS N_SE_M42_g 7.38782e-17
C_x_PM_SDFFR_X2%SE_c6 VSS x_PM_SDFFR_X2%SE_11 3.21646e-17
C_x_PM_SDFFR_X2%SE_c7 VSS N_SE_M19_g 5.55203e-17
C_x_PM_SDFFR_X2%SE_c8 VSS x_PM_SDFFR_X2%SE_6 1.17184e-17
C_x_PM_SDFFR_X2%SE_c9 VSS N_SE_M40_g 4.67224e-17
R_x_PM_SDFFR_X2%SE_r10 x_PM_SDFFR_X2%SE_32 x_PM_SDFFR_X2%SE_28 4.7687
R_x_PM_SDFFR_X2%SE_r11 x_PM_SDFFR_X2%SE_31 x_PM_SDFFR_X2%SE_28 4.7687
R_x_PM_SDFFR_X2%SE_r12 x_PM_SDFFR_X2%SE_28 x_PM_SDFFR_X2%SE_26 25.0012
R_x_PM_SDFFR_X2%SE_r13 x_PM_SDFFR_X2%SE_26 SE 0.0746429
R_x_PM_SDFFR_X2%SE_r14 x_PM_SDFFR_X2%SE_22 x_PM_SDFFR_X2%SE_17 3.30287
R_x_PM_SDFFR_X2%SE_r15 N_SE_M21_g x_PM_SDFFR_X2%SE_17 52.26
R_x_PM_SDFFR_X2%SE_r16 x_PM_SDFFR_X2%SE_22 x_PM_SDFFR_X2%SE_13 3.30287
R_x_PM_SDFFR_X2%SE_r17 N_SE_M42_g x_PM_SDFFR_X2%SE_13 75.66
R_x_PM_SDFFR_X2%SE_r18 x_PM_SDFFR_X2%SE_21 x_PM_SDFFR_X2%SE_12 0.858359
R_x_PM_SDFFR_X2%SE_r19 x_PM_SDFFR_X2%SE_22 x_PM_SDFFR_X2%SE_11 0.858359
R_x_PM_SDFFR_X2%SE_r20 x_PM_SDFFR_X2%SE_12 x_PM_SDFFR_X2%SE_11 51.48
R_x_PM_SDFFR_X2%SE_r21 x_PM_SDFFR_X2%SE_21 x_PM_SDFFR_X2%SE_7 3.30287
R_x_PM_SDFFR_X2%SE_r22 N_SE_M19_g x_PM_SDFFR_X2%SE_7 52.26
R_x_PM_SDFFR_X2%SE_r23 x_PM_SDFFR_X2%SE_21 x_PM_SDFFR_X2%SE_6 3.30287
R_x_PM_SDFFR_X2%SE_r24 x_PM_SDFFR_X2%SE_6 x_PM_SDFFR_X2%SE_32 19.5
R_x_PM_SDFFR_X2%SE_r25 N_SE_M40_g x_PM_SDFFR_X2%SE_31 44.46
C_x_PM_SDFFR_X2%SI_c0 VSS x_PM_SDFFR_X2%SI_17 1.06582e-17
C_x_PM_SDFFR_X2%SI_c1 VSS x_PM_SDFFR_X2%SI_15 5.4769e-17
C_x_PM_SDFFR_X2%SI_c2 VSS N_SI_M41_g 4.81976e-17
C_x_PM_SDFFR_X2%SI_c3 VSS N_SI_M17_g 7.32301e-17
C_x_PM_SDFFR_X2%SI_c4 VSS x_PM_SDFFR_X2%SI_6 5.3745e-18
C_x_PM_SDFFR_X2%SI_c5 VSS x_PM_SDFFR_X2%SI_5 2.64883e-17
C_x_PM_SDFFR_X2%SI_c6 VSS x_PM_SDFFR_X2%SI_4 6.64293e-18
C_x_PM_SDFFR_X2%SI_c7 VSS x_PM_SDFFR_X2%SI_3 9.64197e-17
C_x_PM_SDFFR_X2%SI_c8 VSS x_PM_SDFFR_X2%SI_2 5.98597e-17
R_x_PM_SDFFR_X2%SI_r9 x_PM_SDFFR_X2%SI_23 x_PM_SDFFR_X2%SI_17 4.7687
R_x_PM_SDFFR_X2%SI_r10 x_PM_SDFFR_X2%SI_17 x_PM_SDFFR_X2%SI_15 25.0012
R_x_PM_SDFFR_X2%SI_r11 SI x_PM_SDFFR_X2%SI_15 0.17
R_x_PM_SDFFR_X2%SI_r12 N_SI_M41_g x_PM_SDFFR_X2%SI_23 38.22
R_x_PM_SDFFR_X2%SI_r13 N_SI_M41_g x_PM_SDFFR_X2%SI_11 33.54
R_x_PM_SDFFR_X2%SI_r14 N_SI_M17_g x_PM_SDFFR_X2%SI_7 64.74
R_x_PM_SDFFR_X2%SI_r15 x_PM_SDFFR_X2%SI_7 x_PM_SDFFR_X2%SI_5 4.35808
R_x_PM_SDFFR_X2%SI_r16 x_PM_SDFFR_X2%SI_6 x_PM_SDFFR_X2%SI_5 24.18
R_x_PM_SDFFR_X2%SI_r17 x_PM_SDFFR_X2%SI_11 x_PM_SDFFR_X2%SI_3 4.35808
R_x_PM_SDFFR_X2%SI_r18 x_PM_SDFFR_X2%SI_4 x_PM_SDFFR_X2%SI_3 113.1
R_x_PM_SDFFR_X2%SI_r19 x_PM_SDFFR_X2%SI_6 x_PM_SDFFR_X2%SI_2 4.35808
R_x_PM_SDFFR_X2%SI_r20 x_PM_SDFFR_X2%SI_4 x_PM_SDFFR_X2%SI_VSS 4.35808
R_x_PM_SDFFR_X2%SI_r21 x_PM_SDFFR_X2%SI_2 x_PM_SDFFR_X2%SI_VSS 96.72
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X1 VSS VDD SE D SI CK SN QN Q
*.PININFO VSS:B VDD:B SE:I D:I SI:I CK:I SN:I QN:O Q:O
M_M21 N_VDD_M0_d N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 18 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 N_7_M2_d N_SE_M2_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M24 19 N_3_M3_g N_7_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M4_d N_SI_M4_g 19 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_VDD_M5_d N_CK_M5_g N_8_M5_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 N_10_M6_d N_8_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M28 20 N_7_M7_g N_VDD_M7_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M29 N_11_M8_d N_10_M8_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M30 21 N_8_M9_g N_11_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M10_d N_12_M10_g 21 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 22 N_SN_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M33 N_11_M12_d N_8_M12_g 22 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M34 N_VDD_M13_d N_11_M13_g N_12_M13_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 23 N_11_M14_g N_VDD_M13_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M36 N_14_M15_d N_8_M15_g 23 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M37 24 N_10_M16_g N_14_M15_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M38 N_VDD_M17_d N_15_M17_g 24 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M39 N_15_M18_d N_SN_M18_g N_VDD_M17_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M40 N_VDD_M19_d N_14_M19_g N_15_M18_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M41 N_VDD_M20_d N_15_M20_g N_QN_M20_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M42 N_Q_M21_d N_14_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M22_d N_SE_M22_g N_3_M22_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 25 N_SI_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_7_M24_d N_SE_M24_g 25 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 26 N_3_M25_g N_7_M24_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M26_d N_D_M26_g 26 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M27_d N_CK_M27_g N_8_M27_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_10_M28_d N_8_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 27 N_7_M29_g N_VSS_M29_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_11_M30_d N_8_M30_g 27 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 28 N_10_M31_g N_11_M30_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 29 N_12_M32_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M33_d N_SN_M33_g 29 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_12_M34_d N_11_M34_g N_VSS_M33_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 30 N_11_M35_g N_VSS_M33_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 N_14_M36_d N_10_M36_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 31 N_8_M37_g N_14_M36_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 N_VSS_M38_d N_15_M38_g 31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M17 32 N_SN_M39_g N_VSS_M38_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M18 N_15_M40_d N_14_M40_g 32 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VSS_M41_d N_15_M41_g N_QN_M41_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M20 N_Q_M42_d N_14_M42_g N_VSS_M41_d VSS NMOS_VTL W=0.090000U L=0.050000U
C_x_PM_SDFFS_X1%VSS_c0 VSS x_PM_SDFFS_X1%VSS_58 5.6044e-18
C_x_PM_SDFFS_X1%VSS_c1 VSS x_PM_SDFFS_X1%VSS_57 5.72882e-18
C_x_PM_SDFFS_X1%VSS_c2 VSS x_PM_SDFFS_X1%VSS_52 5.06625e-17
C_x_PM_SDFFS_X1%VSS_c3 VSS x_PM_SDFFS_X1%VSS_51 4.6069e-18
C_x_PM_SDFFS_X1%VSS_c4 VSS x_PM_SDFFS_X1%VSS_46 2.01538e-17
C_x_PM_SDFFS_X1%VSS_c5 VSS x_PM_SDFFS_X1%VSS_45 8.86015e-18
C_x_PM_SDFFS_X1%VSS_c6 VSS x_PM_SDFFS_X1%VSS_44 2.94666e-17
C_x_PM_SDFFS_X1%VSS_c7 VSS VSS 4.33461e-17
C_x_PM_SDFFS_X1%VSS_c8 VSS N_VSS_M41_d 3.2293e-17
C_x_PM_SDFFS_X1%VSS_c9 VSS x_PM_SDFFS_X1%VSS_34 5.79764e-17
C_x_PM_SDFFS_X1%VSS_c10 VSS N_VSS_M38_d 6.53843e-17
C_x_PM_SDFFS_X1%VSS_c11 VSS x_PM_SDFFS_X1%VSS_28 1.23182e-16
C_x_PM_SDFFS_X1%VSS_c12 VSS x_PM_SDFFS_X1%VSS_26 9.89883e-17
C_x_PM_SDFFS_X1%VSS_c13 VSS N_VSS_M29_s 3.48936e-17
C_x_PM_SDFFS_X1%VSS_c14 VSS x_PM_SDFFS_X1%VSS_20 3.56945e-17
C_x_PM_SDFFS_X1%VSS_c15 VSS x_PM_SDFFS_X1%VSS_18 2.81273e-17
C_x_PM_SDFFS_X1%VSS_c16 VSS x_PM_SDFFS_X1%VSS_17 5.01338e-17
C_x_PM_SDFFS_X1%VSS_c17 VSS x_PM_SDFFS_X1%VSS_14 6.96871e-17
C_x_PM_SDFFS_X1%VSS_c18 VSS N_VSS_M22_d 2.97277e-17
R_x_PM_SDFFS_X1%VSS_r19 N_VSS_M33_d x_PM_SDFFS_X1%VSS_52 0.49963
R_x_PM_SDFFS_X1%VSS_r20 N_VSS_M27_d x_PM_SDFFS_X1%VSS_46 0.49963
R_x_PM_SDFFS_X1%VSS_r21 x_PM_SDFFS_X1%VSS_58 x_PM_SDFFS_X1%VSS_40 0.132285
R_x_PM_SDFFS_X1%VSS_r22 VSS x_PM_SDFFS_X1%VSS_40 0.558824
R_x_PM_SDFFS_X1%VSS_r23 x_PM_SDFFS_X1%VSS_58 x_PM_SDFFS_X1%VSS_36 0.0680382
R_x_PM_SDFFS_X1%VSS_r24 N_VSS_M41_d x_PM_SDFFS_X1%VSS_36 0.330741
R_x_PM_SDFFS_X1%VSS_r25 x_PM_SDFFS_X1%VSS_57 x_PM_SDFFS_X1%VSS_35 0.132285
R_x_PM_SDFFS_X1%VSS_r26 x_PM_SDFFS_X1%VSS_58 x_PM_SDFFS_X1%VSS_34 0.132285
R_x_PM_SDFFS_X1%VSS_r27 x_PM_SDFFS_X1%VSS_35 x_PM_SDFFS_X1%VSS_34 1.36353
R_x_PM_SDFFS_X1%VSS_r28 x_PM_SDFFS_X1%VSS_57 x_PM_SDFFS_X1%VSS_30 0.0680382
R_x_PM_SDFFS_X1%VSS_r29 N_VSS_M38_d x_PM_SDFFS_X1%VSS_30 0.851481
R_x_PM_SDFFS_X1%VSS_r30 x_PM_SDFFS_X1%VSS_52 x_PM_SDFFS_X1%VSS_29 0.095
R_x_PM_SDFFS_X1%VSS_r31 x_PM_SDFFS_X1%VSS_57 x_PM_SDFFS_X1%VSS_28 0.132285
R_x_PM_SDFFS_X1%VSS_r32 x_PM_SDFFS_X1%VSS_29 x_PM_SDFFS_X1%VSS_28 2.45882
R_x_PM_SDFFS_X1%VSS_r33 x_PM_SDFFS_X1%VSS_51 x_PM_SDFFS_X1%VSS_27 0.0731438
R_x_PM_SDFFS_X1%VSS_r34 x_PM_SDFFS_X1%VSS_52 x_PM_SDFFS_X1%VSS_26 0.095
R_x_PM_SDFFS_X1%VSS_r35 x_PM_SDFFS_X1%VSS_27 x_PM_SDFFS_X1%VSS_26 1.92235
R_x_PM_SDFFS_X1%VSS_r36 x_PM_SDFFS_X1%VSS_51 x_PM_SDFFS_X1%VSS_22 0.145286
R_x_PM_SDFFS_X1%VSS_r37 N_VSS_M29_s x_PM_SDFFS_X1%VSS_22 0.909286
R_x_PM_SDFFS_X1%VSS_r38 x_PM_SDFFS_X1%VSS_46 x_PM_SDFFS_X1%VSS_21 0.095
R_x_PM_SDFFS_X1%VSS_r39 x_PM_SDFFS_X1%VSS_51 x_PM_SDFFS_X1%VSS_20 0.0731438
R_x_PM_SDFFS_X1%VSS_r40 x_PM_SDFFS_X1%VSS_21 x_PM_SDFFS_X1%VSS_20 0.625882
R_x_PM_SDFFS_X1%VSS_r41 x_PM_SDFFS_X1%VSS_45 x_PM_SDFFS_X1%VSS_19 0.132285
R_x_PM_SDFFS_X1%VSS_r42 x_PM_SDFFS_X1%VSS_46 x_PM_SDFFS_X1%VSS_18 0.095
R_x_PM_SDFFS_X1%VSS_r43 x_PM_SDFFS_X1%VSS_19 x_PM_SDFFS_X1%VSS_18 0.625882
R_x_PM_SDFFS_X1%VSS_r44 x_PM_SDFFS_X1%VSS_45 x_PM_SDFFS_X1%VSS_17 0.0680382
R_x_PM_SDFFS_X1%VSS_r45 x_PM_SDFFS_X1%VSS_17 N_VSS_M26_d 0.403583
R_x_PM_SDFFS_X1%VSS_r46 x_PM_SDFFS_X1%VSS_44 x_PM_SDFFS_X1%VSS_15 0.0731438
R_x_PM_SDFFS_X1%VSS_r47 x_PM_SDFFS_X1%VSS_45 x_PM_SDFFS_X1%VSS_14 0.132285
R_x_PM_SDFFS_X1%VSS_r48 x_PM_SDFFS_X1%VSS_15 x_PM_SDFFS_X1%VSS_14 1.47529
R_x_PM_SDFFS_X1%VSS_r49 x_PM_SDFFS_X1%VSS_44 x_PM_SDFFS_X1%VSS_10 0.145286
R_x_PM_SDFFS_X1%VSS_r50 N_VSS_M22_d x_PM_SDFFS_X1%VSS_10 0.909286
C_x_PM_SDFFS_X1%VDD_c0 VSS x_PM_SDFFS_X1%VDD_65 3.77744e-17
C_x_PM_SDFFS_X1%VDD_c1 VSS x_PM_SDFFS_X1%VDD_64 8.85742e-18
C_x_PM_SDFFS_X1%VDD_c2 VSS x_PM_SDFFS_X1%VDD_63 5.64357e-18
C_x_PM_SDFFS_X1%VDD_c3 VSS x_PM_SDFFS_X1%VDD_62 8.86015e-18
C_x_PM_SDFFS_X1%VDD_c4 VSS x_PM_SDFFS_X1%VDD_61 8.87094e-18
C_x_PM_SDFFS_X1%VDD_c5 VSS x_PM_SDFFS_X1%VDD_60 4.62499e-18
C_x_PM_SDFFS_X1%VDD_c6 VSS x_PM_SDFFS_X1%VDD_58 6.66378e-17
C_x_PM_SDFFS_X1%VDD_c7 VSS N_VDD_M0_d 2.93958e-17
C_x_PM_SDFFS_X1%VDD_c8 VSS N_VDD_M20_d 2.92988e-17
C_x_PM_SDFFS_X1%VDD_c9 VSS x_PM_SDFFS_X1%VDD_44 2.83698e-17
C_x_PM_SDFFS_X1%VDD_c10 VSS x_PM_SDFFS_X1%VDD_43 2.60666e-17
C_x_PM_SDFFS_X1%VDD_c11 VSS x_PM_SDFFS_X1%VDD_40 1.73771e-17
C_x_PM_SDFFS_X1%VDD_c12 VSS x_PM_SDFFS_X1%VDD_39 2.56853e-17
C_x_PM_SDFFS_X1%VDD_c13 VSS x_PM_SDFFS_X1%VDD_36 6.73444e-17
C_x_PM_SDFFS_X1%VDD_c14 VSS x_PM_SDFFS_X1%VDD_35 2.2975e-17
C_x_PM_SDFFS_X1%VDD_c15 VSS x_PM_SDFFS_X1%VDD_32 3.98129e-17
C_x_PM_SDFFS_X1%VDD_c16 VSS N_VDD_M10_d 2.5547e-17
C_x_PM_SDFFS_X1%VDD_c17 VSS x_PM_SDFFS_X1%VDD_24 6.05558e-17
C_x_PM_SDFFS_X1%VDD_c18 VSS N_VDD_M7_s 2.53188e-17
C_x_PM_SDFFS_X1%VDD_c19 VSS x_PM_SDFFS_X1%VDD_16 7.06321e-17
C_x_PM_SDFFS_X1%VDD_c20 VSS x_PM_SDFFS_X1%VDD_15 2.72697e-17
C_x_PM_SDFFS_X1%VDD_c21 VSS x_PM_SDFFS_X1%VDD_14 1.31497e-16
C_x_PM_SDFFS_X1%VDD_c22 VSS x_PM_SDFFS_X1%VDD_13 1.93235e-17
R_x_PM_SDFFS_X1%VDD_r23 x_PM_SDFFS_X1%VDD_58 N_VDD_M4_d 0.140674
R_x_PM_SDFFS_X1%VDD_r24 x_PM_SDFFS_X1%VDD_65 x_PM_SDFFS_X1%VDD_46 0.145286
R_x_PM_SDFFS_X1%VDD_r25 N_VDD_M20_d x_PM_SDFFS_X1%VDD_46 0.909286
R_x_PM_SDFFS_X1%VDD_r26 x_PM_SDFFS_X1%VDD_64 x_PM_SDFFS_X1%VDD_45 0.132285
R_x_PM_SDFFS_X1%VDD_r27 x_PM_SDFFS_X1%VDD_65 x_PM_SDFFS_X1%VDD_44 0.0731438
R_x_PM_SDFFS_X1%VDD_r28 x_PM_SDFFS_X1%VDD_45 x_PM_SDFFS_X1%VDD_44 0.648235
R_x_PM_SDFFS_X1%VDD_r29 x_PM_SDFFS_X1%VDD_64 x_PM_SDFFS_X1%VDD_43 0.0680382
R_x_PM_SDFFS_X1%VDD_r30 x_PM_SDFFS_X1%VDD_43 N_VDD_M19_d 0.403583
R_x_PM_SDFFS_X1%VDD_r31 x_PM_SDFFS_X1%VDD_63 x_PM_SDFFS_X1%VDD_41 0.132285
R_x_PM_SDFFS_X1%VDD_r32 x_PM_SDFFS_X1%VDD_64 x_PM_SDFFS_X1%VDD_40 0.132285
R_x_PM_SDFFS_X1%VDD_r33 x_PM_SDFFS_X1%VDD_41 x_PM_SDFFS_X1%VDD_40 0.57
R_x_PM_SDFFS_X1%VDD_r34 x_PM_SDFFS_X1%VDD_63 x_PM_SDFFS_X1%VDD_39 0.0680382
R_x_PM_SDFFS_X1%VDD_r35 x_PM_SDFFS_X1%VDD_39 N_VDD_M17_d 0.403583
R_x_PM_SDFFS_X1%VDD_r36 x_PM_SDFFS_X1%VDD_62 x_PM_SDFFS_X1%VDD_37 0.132285
R_x_PM_SDFFS_X1%VDD_r37 x_PM_SDFFS_X1%VDD_63 x_PM_SDFFS_X1%VDD_36 0.132285
R_x_PM_SDFFS_X1%VDD_r38 x_PM_SDFFS_X1%VDD_37 x_PM_SDFFS_X1%VDD_36 1.73235
R_x_PM_SDFFS_X1%VDD_r39 x_PM_SDFFS_X1%VDD_62 x_PM_SDFFS_X1%VDD_35 0.0680382
R_x_PM_SDFFS_X1%VDD_r40 x_PM_SDFFS_X1%VDD_35 N_VDD_M13_d 0.403583
R_x_PM_SDFFS_X1%VDD_r41 x_PM_SDFFS_X1%VDD_61 x_PM_SDFFS_X1%VDD_33 0.132285
R_x_PM_SDFFS_X1%VDD_r42 x_PM_SDFFS_X1%VDD_62 x_PM_SDFFS_X1%VDD_32 0.132285
R_x_PM_SDFFS_X1%VDD_r43 x_PM_SDFFS_X1%VDD_33 x_PM_SDFFS_X1%VDD_32 0.938824
R_x_PM_SDFFS_X1%VDD_r44 VDD N_VDD_M10_d 0.344815
R_x_PM_SDFFS_X1%VDD_r45 x_PM_SDFFS_X1%VDD_61 x_PM_SDFFS_X1%VDD_26 0.0680382
R_x_PM_SDFFS_X1%VDD_r46 VDD x_PM_SDFFS_X1%VDD_26 0.168889
R_x_PM_SDFFS_X1%VDD_r47 x_PM_SDFFS_X1%VDD_60 x_PM_SDFFS_X1%VDD_25 0.0731438
R_x_PM_SDFFS_X1%VDD_r48 x_PM_SDFFS_X1%VDD_61 x_PM_SDFFS_X1%VDD_24 0.132285
R_x_PM_SDFFS_X1%VDD_r49 x_PM_SDFFS_X1%VDD_25 x_PM_SDFFS_X1%VDD_24 1.46412
R_x_PM_SDFFS_X1%VDD_r50 x_PM_SDFFS_X1%VDD_60 x_PM_SDFFS_X1%VDD_21 0.145286
R_x_PM_SDFFS_X1%VDD_r51 N_VDD_M7_s x_PM_SDFFS_X1%VDD_21 1.07214
R_x_PM_SDFFS_X1%VDD_r52 N_VDD_M7_s x_PM_SDFFS_X1%VDD_20 0.122143
R_x_PM_SDFFS_X1%VDD_r53 x_PM_SDFFS_X1%VDD_20 x_PM_SDFFS_X1%VDD_16 0.212317
R_x_PM_SDFFS_X1%VDD_r54 N_VDD_M5_d x_PM_SDFFS_X1%VDD_16 1.53357
R_x_PM_SDFFS_X1%VDD_r55 x_PM_SDFFS_X1%VDD_15 N_VDD_M4_d 0.140674
R_x_PM_SDFFS_X1%VDD_r56 x_PM_SDFFS_X1%VDD_60 x_PM_SDFFS_X1%VDD_14 0.0731438
R_x_PM_SDFFS_X1%VDD_r57 x_PM_SDFFS_X1%VDD_15 x_PM_SDFFS_X1%VDD_14 1.34118
R_x_PM_SDFFS_X1%VDD_r58 x_PM_SDFFS_X1%VDD_13 N_VDD_M0_d 0.140674
R_x_PM_SDFFS_X1%VDD_r59 x_PM_SDFFS_X1%VDD_13 x_PM_SDFFS_X1%VDD_58 1.39706
C_x_PM_SDFFS_X1%3_c0 VSS x_PM_SDFFS_X1%3_25 8.39994e-18
C_x_PM_SDFFS_X1%3_c1 VSS x_PM_SDFFS_X1%3_24 3.12377e-18
C_x_PM_SDFFS_X1%3_c2 VSS x_PM_SDFFS_X1%3_21 1.4749e-16
C_x_PM_SDFFS_X1%3_c3 VSS N_3_M0_s 3.31612e-17
C_x_PM_SDFFS_X1%3_c4 VSS N_3_M22_s 7.63374e-17
C_x_PM_SDFFS_X1%3_c5 VSS N_3_M3_g 5.78772e-17
C_x_PM_SDFFS_X1%3_c6 VSS N_3_M25_g 6.56127e-17
R_x_PM_SDFFS_X1%3_r7 x_PM_SDFFS_X1%3_27 x_PM_SDFFS_X1%3_25 4.7687
R_x_PM_SDFFS_X1%3_r8 x_PM_SDFFS_X1%3_25 x_PM_SDFFS_X1%3_21 25.0012
R_x_PM_SDFFS_X1%3_r9 x_PM_SDFFS_X1%3_24 x_PM_SDFFS_X1%3_19 0.0604376
R_x_PM_SDFFS_X1%3_r10 x_PM_SDFFS_X1%3_21 x_PM_SDFFS_X1%3_19 3.35214
R_x_PM_SDFFS_X1%3_r11 x_PM_SDFFS_X1%3_24 x_PM_SDFFS_X1%3_15 0.140052
R_x_PM_SDFFS_X1%3_r12 N_3_M0_s x_PM_SDFFS_X1%3_15 0.89
R_x_PM_SDFFS_X1%3_r13 x_PM_SDFFS_X1%3_24 x_PM_SDFFS_X1%3_11 0.140052
R_x_PM_SDFFS_X1%3_r14 N_3_M22_s x_PM_SDFFS_X1%3_11 2.32071
R_x_PM_SDFFS_X1%3_r15 N_3_M3_g x_PM_SDFFS_X1%3_27 49.92
R_x_PM_SDFFS_X1%3_r16 x_PM_SDFFS_X1%3_VSS x_PM_SDFFS_X1%3_25 4.7687
R_x_PM_SDFFS_X1%3_r17 N_3_M25_g x_PM_SDFFS_X1%3_VSS 74.1
C_x_PM_SDFFS_X1%SE_c0 VSS x_PM_SDFFS_X1%SE_25 1.1528e-17
C_x_PM_SDFFS_X1%SE_c1 VSS SE 9.75823e-17
C_x_PM_SDFFS_X1%SE_c2 VSS x_PM_SDFFS_X1%SE_19 8.55477e-18
C_x_PM_SDFFS_X1%SE_c3 VSS N_SE_M2_g 7.276e-17
C_x_PM_SDFFS_X1%SE_c4 VSS N_SE_M24_g 4.40829e-17
C_x_PM_SDFFS_X1%SE_c5 VSS x_PM_SDFFS_X1%SE_9 3.20188e-17
C_x_PM_SDFFS_X1%SE_c6 VSS N_SE_M0_g 7.29076e-17
C_x_PM_SDFFS_X1%SE_c7 VSS N_SE_M22_g 4.6793e-17
R_x_PM_SDFFS_X1%SE_r8 x_PM_SDFFS_X1%SE_25 x_PM_SDFFS_X1%SE_23 25.0012
R_x_PM_SDFFS_X1%SE_r9 x_PM_SDFFS_X1%SE_23 SE 0.5415
R_x_PM_SDFFS_X1%SE_r10 x_PM_SDFFS_X1%SE_19 x_PM_SDFFS_X1%SE_15 5.81291
R_x_PM_SDFFS_X1%SE_r11 N_SE_M2_g x_PM_SDFFS_X1%SE_15 74.1
R_x_PM_SDFFS_X1%SE_r12 x_PM_SDFFS_X1%SE_19 x_PM_SDFFS_X1%SE_11 5.81291
R_x_PM_SDFFS_X1%SE_r13 N_SE_M24_g x_PM_SDFFS_X1%SE_11 45.24
R_x_PM_SDFFS_X1%SE_r14 x_PM_SDFFS_X1%SE_25 x_PM_SDFFS_X1%SE_10 0.725724
R_x_PM_SDFFS_X1%SE_r15 x_PM_SDFFS_X1%SE_19 x_PM_SDFFS_X1%SE_9 0.725724
R_x_PM_SDFFS_X1%SE_r16 x_PM_SDFFS_X1%SE_10 x_PM_SDFFS_X1%SE_9 22.6571
R_x_PM_SDFFS_X1%SE_r17 x_PM_SDFFS_X1%SE_25 x_PM_SDFFS_X1%SE_5 5.81291
R_x_PM_SDFFS_X1%SE_r18 N_SE_M0_g x_PM_SDFFS_X1%SE_5 74.1
R_x_PM_SDFFS_X1%SE_r19 x_PM_SDFFS_X1%SE_25 x_PM_SDFFS_X1%SE_VSS 5.81291
R_x_PM_SDFFS_X1%SE_r20 N_SE_M22_g x_PM_SDFFS_X1%SE_VSS 45.24
C_x_PM_SDFFS_X1%D_c0 VSS x_PM_SDFFS_X1%D_18 1.05336e-17
C_x_PM_SDFFS_X1%D_c1 VSS x_PM_SDFFS_X1%D_16 5.68114e-17
C_x_PM_SDFFS_X1%D_c2 VSS x_PM_SDFFS_X1%D_14 1.05732e-17
C_x_PM_SDFFS_X1%D_c3 VSS x_PM_SDFFS_X1%D_12 1.18855e-16
C_x_PM_SDFFS_X1%D_c4 VSS x_PM_SDFFS_X1%D_9 1.60201e-16
C_x_PM_SDFFS_X1%D_c5 VSS N_D_M26_g 3.86329e-17
C_x_PM_SDFFS_X1%D_c6 VSS N_D_M1_g 3.63076e-17
R_x_PM_SDFFS_X1%D_r7 D x_PM_SDFFS_X1%D_20 0.267407
R_x_PM_SDFFS_X1%D_r8 x_PM_SDFFS_X1%D_26 x_PM_SDFFS_X1%D_18 4.7687
R_x_PM_SDFFS_X1%D_r9 x_PM_SDFFS_X1%D_18 x_PM_SDFFS_X1%D_16 25.0012
R_x_PM_SDFFS_X1%D_r10 x_PM_SDFFS_X1%D_20 x_PM_SDFFS_X1%D_16 0.00703704
R_x_PM_SDFFS_X1%D_r11 x_PM_SDFFS_X1%D_28 x_PM_SDFFS_X1%D_14 4.7687
R_x_PM_SDFFS_X1%D_r12 x_PM_SDFFS_X1%D_14 x_PM_SDFFS_X1%D_12 25.0012
R_x_PM_SDFFS_X1%D_r13 x_PM_SDFFS_X1%D_12 x_PM_SDFFS_X1%D_11 1.995
R_x_PM_SDFFS_X1%D_r14 x_PM_SDFFS_X1%D_20 x_PM_SDFFS_X1%D_10 0.095
R_x_PM_SDFFS_X1%D_r15 x_PM_SDFFS_X1%D_11 x_PM_SDFFS_X1%D_9 0.212317
R_x_PM_SDFFS_X1%D_r16 x_PM_SDFFS_X1%D_10 x_PM_SDFFS_X1%D_9 2.28
R_x_PM_SDFFS_X1%D_r17 N_D_M26_g x_PM_SDFFS_X1%D_28 32.76
R_x_PM_SDFFS_X1%D_r18 N_D_M1_g x_PM_SDFFS_X1%D_26 28.86
C_x_PM_SDFFS_X1%SI_c0 VSS SI 4.25752e-17
C_x_PM_SDFFS_X1%SI_c1 VSS x_PM_SDFFS_X1%SI_17 1.21995e-17
C_x_PM_SDFFS_X1%SI_c2 VSS x_PM_SDFFS_X1%SI_14 5.27934e-17
C_x_PM_SDFFS_X1%SI_c3 VSS x_PM_SDFFS_X1%SI_12 7.00738e-18
C_x_PM_SDFFS_X1%SI_c4 VSS x_PM_SDFFS_X1%SI_11 2.0915e-17
C_x_PM_SDFFS_X1%SI_c5 VSS N_SI_M4_g 7.80931e-17
C_x_PM_SDFFS_X1%SI_c6 VSS x_PM_SDFFS_X1%SI_6 5.91176e-18
C_x_PM_SDFFS_X1%SI_c7 VSS x_PM_SDFFS_X1%SI_5 9.60993e-17
C_x_PM_SDFFS_X1%SI_c8 VSS N_SI_M23_g 3.423e-17
R_x_PM_SDFFS_X1%SI_r9 x_PM_SDFFS_X1%SI_23 x_PM_SDFFS_X1%SI_17 4.7687
R_x_PM_SDFFS_X1%SI_r10 x_PM_SDFFS_X1%SI_17 x_PM_SDFFS_X1%SI_15 25.0012
R_x_PM_SDFFS_X1%SI_r11 SI x_PM_SDFFS_X1%SI_15 0.15069
R_x_PM_SDFFS_X1%SI_r12 x_PM_SDFFS_X1%SI_14 x_PM_SDFFS_X1%SI_13 89.7
R_x_PM_SDFFS_X1%SI_r13 x_PM_SDFFS_X1%SI_14 x_PM_SDFFS_X1%SI_11 4.35808
R_x_PM_SDFFS_X1%SI_r14 x_PM_SDFFS_X1%SI_12 x_PM_SDFFS_X1%SI_11 20.28
R_x_PM_SDFFS_X1%SI_r15 x_PM_SDFFS_X1%SI_12 x_PM_SDFFS_X1%SI_7 4.35808
R_x_PM_SDFFS_X1%SI_r16 N_SI_M4_g x_PM_SDFFS_X1%SI_7 71.76
R_x_PM_SDFFS_X1%SI_r17 x_PM_SDFFS_X1%SI_13 x_PM_SDFFS_X1%SI_5 4.35808
R_x_PM_SDFFS_X1%SI_r18 x_PM_SDFFS_X1%SI_6 x_PM_SDFFS_X1%SI_5 113.1
R_x_PM_SDFFS_X1%SI_r19 N_SI_M23_g x_PM_SDFFS_X1%SI_23 21.84
R_x_PM_SDFFS_X1%SI_r20 x_PM_SDFFS_X1%SI_6 x_PM_SDFFS_X1%SI_VSS 4.35808
R_x_PM_SDFFS_X1%SI_r21 N_SI_M23_g x_PM_SDFFS_X1%SI_VSS 33.54
C_x_PM_SDFFS_X1%7_c0 VSS x_PM_SDFFS_X1%7_40 1.03212e-17
C_x_PM_SDFFS_X1%7_c1 VSS x_PM_SDFFS_X1%7_39 9.42476e-18
C_x_PM_SDFFS_X1%7_c2 VSS x_PM_SDFFS_X1%7_32 1.22189e-16
C_x_PM_SDFFS_X1%7_c3 VSS x_PM_SDFFS_X1%7_30 2.09115e-17
C_x_PM_SDFFS_X1%7_c4 VSS x_PM_SDFFS_X1%7_29 4.38966e-18
C_x_PM_SDFFS_X1%7_c5 VSS x_PM_SDFFS_X1%7_26 2.10408e-17
C_x_PM_SDFFS_X1%7_c6 VSS x_PM_SDFFS_X1%7_25 1.57054e-16
C_x_PM_SDFFS_X1%7_c7 VSS x_PM_SDFFS_X1%7_23 1.79403e-17
C_x_PM_SDFFS_X1%7_c8 VSS x_PM_SDFFS_X1%7_22 7.62718e-17
C_x_PM_SDFFS_X1%7_c9 VSS x_PM_SDFFS_X1%7_18 9.66591e-17
C_x_PM_SDFFS_X1%7_c10 VSS x_PM_SDFFS_X1%7_14 1.35632e-17
C_x_PM_SDFFS_X1%7_c11 VSS N_7_M29_g 3.36019e-17
C_x_PM_SDFFS_X1%7_c12 VSS N_7_M7_g 7.92799e-17
C_x_PM_SDFFS_X1%7_c13 VSS x_PM_SDFFS_X1%7_2 8.36035e-18
C_x_PM_SDFFS_X1%7_c14 VSS x_PM_SDFFS_X1%7_VSS 2.48035e-17
R_x_PM_SDFFS_X1%7_r15 x_PM_SDFFS_X1%7_40 x_PM_SDFFS_X1%7_32 25.0012
R_x_PM_SDFFS_X1%7_r16 x_PM_SDFFS_X1%7_32 x_PM_SDFFS_X1%7_30 1.805
R_x_PM_SDFFS_X1%7_r17 x_PM_SDFFS_X1%7_30 x_PM_SDFFS_X1%7_29 0.212317
R_x_PM_SDFFS_X1%7_r18 x_PM_SDFFS_X1%7_29 x_PM_SDFFS_X1%7_28 0.298571
R_x_PM_SDFFS_X1%7_r19 x_PM_SDFFS_X1%7_39 x_PM_SDFFS_X1%7_27 0.160909
R_x_PM_SDFFS_X1%7_r20 x_PM_SDFFS_X1%7_28 x_PM_SDFFS_X1%7_26 0.212317
R_x_PM_SDFFS_X1%7_r21 x_PM_SDFFS_X1%7_27 x_PM_SDFFS_X1%7_26 0.488571
R_x_PM_SDFFS_X1%7_r22 x_PM_SDFFS_X1%7_39 x_PM_SDFFS_X1%7_25 0.0418175
R_x_PM_SDFFS_X1%7_r23 x_PM_SDFFS_X1%7_25 x_PM_SDFFS_X1%7_24 3.44714
R_x_PM_SDFFS_X1%7_r24 x_PM_SDFFS_X1%7_23 N_7_M24_d 0.297071
R_x_PM_SDFFS_X1%7_r25 x_PM_SDFFS_X1%7_24 x_PM_SDFFS_X1%7_22 0.212317
R_x_PM_SDFFS_X1%7_r26 x_PM_SDFFS_X1%7_23 x_PM_SDFFS_X1%7_22 1.65571
R_x_PM_SDFFS_X1%7_r27 x_PM_SDFFS_X1%7_39 x_PM_SDFFS_X1%7_18 0.160909
R_x_PM_SDFFS_X1%7_r28 N_7_M2_d x_PM_SDFFS_X1%7_18 1.88643
R_x_PM_SDFFS_X1%7_r29 x_PM_SDFFS_X1%7_14 x_PM_SDFFS_X1%7_12 10.92
R_x_PM_SDFFS_X1%7_r30 x_PM_SDFFS_X1%7_40 x_PM_SDFFS_X1%7_11 9.62
R_x_PM_SDFFS_X1%7_r31 x_PM_SDFFS_X1%7_14 x_PM_SDFFS_X1%7_7 1.95
R_x_PM_SDFFS_X1%7_r32 N_7_M29_g x_PM_SDFFS_X1%7_7 21.84
R_x_PM_SDFFS_X1%7_r33 N_7_M7_g x_PM_SDFFS_X1%7_4 21.84
R_x_PM_SDFFS_X1%7_r34 x_PM_SDFFS_X1%7_12 x_PM_SDFFS_X1%7_3 1.95
R_x_PM_SDFFS_X1%7_r35 N_7_M7_g x_PM_SDFFS_X1%7_3 105.3
R_x_PM_SDFFS_X1%7_r36 x_PM_SDFFS_X1%7_11 x_PM_SDFFS_X1%7_2 4.58872
R_x_PM_SDFFS_X1%7_r37 x_PM_SDFFS_X1%7_4 x_PM_SDFFS_X1%7_VSS 4.35808
R_x_PM_SDFFS_X1%7_r38 x_PM_SDFFS_X1%7_2 x_PM_SDFFS_X1%7_VSS 30.42
C_x_PM_SDFFS_X1%8_c0 VSS x_PM_SDFFS_X1%8_80 1.7825e-17
C_x_PM_SDFFS_X1%8_c1 VSS x_PM_SDFFS_X1%8_73 9.40697e-18
C_x_PM_SDFFS_X1%8_c2 VSS N_8_M5_s 2.1527e-17
C_x_PM_SDFFS_X1%8_c3 VSS x_PM_SDFFS_X1%8_64 1.18771e-17
C_x_PM_SDFFS_X1%8_c4 VSS N_8_M27_s 1.9391e-17
C_x_PM_SDFFS_X1%8_c5 VSS x_PM_SDFFS_X1%8_56 1.07001e-16
C_x_PM_SDFFS_X1%8_c6 VSS x_PM_SDFFS_X1%8_52 9.7396e-18
C_x_PM_SDFFS_X1%8_c7 VSS x_PM_SDFFS_X1%8_49 3.05458e-17
C_x_PM_SDFFS_X1%8_c8 VSS x_PM_SDFFS_X1%8_46 4.63594e-17
C_x_PM_SDFFS_X1%8_c9 VSS x_PM_SDFFS_X1%8_43 6.14202e-17
C_x_PM_SDFFS_X1%8_c10 VSS x_PM_SDFFS_X1%8_41 1.25212e-17
C_x_PM_SDFFS_X1%8_c11 VSS x_PM_SDFFS_X1%8_37 4.56398e-18
C_x_PM_SDFFS_X1%8_c12 VSS N_8_M37_g 3.76816e-17
C_x_PM_SDFFS_X1%8_c13 VSS x_PM_SDFFS_X1%8_32 6.4995e-18
C_x_PM_SDFFS_X1%8_c14 VSS x_PM_SDFFS_X1%8_31 2.39578e-17
C_x_PM_SDFFS_X1%8_c15 VSS N_8_M15_g 5.52287e-17
C_x_PM_SDFFS_X1%8_c16 VSS x_PM_SDFFS_X1%8_25 7.5782e-17
C_x_PM_SDFFS_X1%8_c17 VSS N_8_M12_g 5.79926e-17
C_x_PM_SDFFS_X1%8_c18 VSS x_PM_SDFFS_X1%8_20 6.45879e-18
C_x_PM_SDFFS_X1%8_c19 VSS x_PM_SDFFS_X1%8_19 5.9493e-17
C_x_PM_SDFFS_X1%8_c20 VSS N_8_M9_g 4.51124e-17
C_x_PM_SDFFS_X1%8_c21 VSS N_8_M30_g 3.31447e-17
C_x_PM_SDFFS_X1%8_c22 VSS x_PM_SDFFS_X1%8_10 6.62418e-18
C_x_PM_SDFFS_X1%8_c23 VSS x_PM_SDFFS_X1%8_9 7.11535e-17
C_x_PM_SDFFS_X1%8_c24 VSS N_8_M6_g 5.54632e-17
C_x_PM_SDFFS_X1%8_c25 VSS N_8_M28_g 3.33844e-17
R_x_PM_SDFFS_X1%8_r26 x_PM_SDFFS_X1%8_80 x_PM_SDFFS_X1%8_78 5.46
R_x_PM_SDFFS_X1%8_r27 x_PM_SDFFS_X1%8_73 x_PM_SDFFS_X1%8_72 1.56
R_x_PM_SDFFS_X1%8_r28 x_PM_SDFFS_X1%8_72 x_PM_SDFFS_X1%8_70 1.3
R_x_PM_SDFFS_X1%8_r29 N_8_M5_s x_PM_SDFFS_X1%8_65 0.176429
R_x_PM_SDFFS_X1%8_r30 N_8_M27_s x_PM_SDFFS_X1%8_59 0.176429
R_x_PM_SDFFS_X1%8_r31 x_PM_SDFFS_X1%8_78 x_PM_SDFFS_X1%8_56 25.0012
R_x_PM_SDFFS_X1%8_r32 x_PM_SDFFS_X1%8_56 x_PM_SDFFS_X1%8_54 1.72357
R_x_PM_SDFFS_X1%8_r33 x_PM_SDFFS_X1%8_76 x_PM_SDFFS_X1%8_52 4.7687
R_x_PM_SDFFS_X1%8_r34 x_PM_SDFFS_X1%8_52 x_PM_SDFFS_X1%8_50 25.0012
R_x_PM_SDFFS_X1%8_r35 x_PM_SDFFS_X1%8_54 x_PM_SDFFS_X1%8_49 0.212317
R_x_PM_SDFFS_X1%8_r36 x_PM_SDFFS_X1%8_50 x_PM_SDFFS_X1%8_49 0.230714
R_x_PM_SDFFS_X1%8_r37 x_PM_SDFFS_X1%8_70 x_PM_SDFFS_X1%8_46 25.0012
R_x_PM_SDFFS_X1%8_r38 x_PM_SDFFS_X1%8_64 x_PM_SDFFS_X1%8_44 0.0418175
R_x_PM_SDFFS_X1%8_r39 x_PM_SDFFS_X1%8_46 x_PM_SDFFS_X1%8_44 1.45214
R_x_PM_SDFFS_X1%8_r40 x_PM_SDFFS_X1%8_65 x_PM_SDFFS_X1%8_43 0.095
R_x_PM_SDFFS_X1%8_r41 x_PM_SDFFS_X1%8_64 x_PM_SDFFS_X1%8_42 0.160909
R_x_PM_SDFFS_X1%8_r42 x_PM_SDFFS_X1%8_43 x_PM_SDFFS_X1%8_42 1.87286
R_x_PM_SDFFS_X1%8_r43 x_PM_SDFFS_X1%8_64 x_PM_SDFFS_X1%8_41 0.160909
R_x_PM_SDFFS_X1%8_r44 x_PM_SDFFS_X1%8_59 x_PM_SDFFS_X1%8_40 0.095
R_x_PM_SDFFS_X1%8_r45 x_PM_SDFFS_X1%8_41 x_PM_SDFFS_X1%8_40 0.515714
R_x_PM_SDFFS_X1%8_r46 N_8_M37_g x_PM_SDFFS_X1%8_33 35.88
R_x_PM_SDFFS_X1%8_r47 x_PM_SDFFS_X1%8_33 x_PM_SDFFS_X1%8_31 4.35808
R_x_PM_SDFFS_X1%8_r48 x_PM_SDFFS_X1%8_32 x_PM_SDFFS_X1%8_31 20.28
R_x_PM_SDFFS_X1%8_r49 N_8_M15_g x_PM_SDFFS_X1%8_28 40.56
R_x_PM_SDFFS_X1%8_r50 x_PM_SDFFS_X1%8_32 x_PM_SDFFS_X1%8_27 4.35808
R_x_PM_SDFFS_X1%8_r51 N_8_M15_g x_PM_SDFFS_X1%8_27 52.26
R_x_PM_SDFFS_X1%8_r52 x_PM_SDFFS_X1%8_37 x_PM_SDFFS_X1%8_26 3.30287
R_x_PM_SDFFS_X1%8_r53 x_PM_SDFFS_X1%8_28 x_PM_SDFFS_X1%8_25 4.35808
R_x_PM_SDFFS_X1%8_r54 x_PM_SDFFS_X1%8_26 x_PM_SDFFS_X1%8_25 93.6
R_x_PM_SDFFS_X1%8_r55 x_PM_SDFFS_X1%8_37 x_PM_SDFFS_X1%8_21 0.858359
R_x_PM_SDFFS_X1%8_r56 N_8_M12_g x_PM_SDFFS_X1%8_21 49.92
R_x_PM_SDFFS_X1%8_r57 x_PM_SDFFS_X1%8_37 x_PM_SDFFS_X1%8_19 3.30287
R_x_PM_SDFFS_X1%8_r58 x_PM_SDFFS_X1%8_20 x_PM_SDFFS_X1%8_19 81.9
R_x_PM_SDFFS_X1%8_r59 x_PM_SDFFS_X1%8_20 x_PM_SDFFS_X1%8_16 4.35808
R_x_PM_SDFFS_X1%8_r60 N_8_M9_g x_PM_SDFFS_X1%8_16 28.86
R_x_PM_SDFFS_X1%8_r61 x_PM_SDFFS_X1%8_80 x_PM_SDFFS_X1%8_15 1.95
R_x_PM_SDFFS_X1%8_r62 N_8_M9_g x_PM_SDFFS_X1%8_15 39
R_x_PM_SDFFS_X1%8_r63 N_8_M30_g x_PM_SDFFS_X1%8_76 21.84
R_x_PM_SDFFS_X1%8_r64 N_8_M30_g x_PM_SDFFS_X1%8_11 33.54
R_x_PM_SDFFS_X1%8_r65 x_PM_SDFFS_X1%8_11 x_PM_SDFFS_X1%8_9 4.35808
R_x_PM_SDFFS_X1%8_r66 x_PM_SDFFS_X1%8_10 x_PM_SDFFS_X1%8_9 81.12
R_x_PM_SDFFS_X1%8_r67 x_PM_SDFFS_X1%8_73 x_PM_SDFFS_X1%8_5 1.95
R_x_PM_SDFFS_X1%8_r68 N_8_M6_g x_PM_SDFFS_X1%8_5 67.08
R_x_PM_SDFFS_X1%8_r69 x_PM_SDFFS_X1%8_72 x_PM_SDFFS_X1%8_2 1.95
R_x_PM_SDFFS_X1%8_r70 N_8_M28_g x_PM_SDFFS_X1%8_2 28.08
R_x_PM_SDFFS_X1%8_r71 x_PM_SDFFS_X1%8_10 x_PM_SDFFS_X1%8_VSS 4.35808
R_x_PM_SDFFS_X1%8_r72 N_8_M28_g x_PM_SDFFS_X1%8_VSS 21.84
C_x_PM_SDFFS_X1%CK_c0 VSS x_PM_SDFFS_X1%CK_14 1.23256e-17
C_x_PM_SDFFS_X1%CK_c1 VSS x_PM_SDFFS_X1%CK_12 3.52547e-17
C_x_PM_SDFFS_X1%CK_c2 VSS N_CK_M5_g 5.34432e-17
C_x_PM_SDFFS_X1%CK_c3 VSS N_CK_M27_g 5.45606e-17
R_x_PM_SDFFS_X1%CK_r4 x_PM_SDFFS_X1%CK_14 x_PM_SDFFS_X1%CK_16 5.46
R_x_PM_SDFFS_X1%CK_r5 x_PM_SDFFS_X1%CK_14 x_PM_SDFFS_X1%CK_12 25.0012
R_x_PM_SDFFS_X1%CK_r6 x_PM_SDFFS_X1%CK_12 CK 0.0339286
R_x_PM_SDFFS_X1%CK_r7 x_PM_SDFFS_X1%CK_16 x_PM_SDFFS_X1%CK_5 1.95
R_x_PM_SDFFS_X1%CK_r8 N_CK_M5_g x_PM_SDFFS_X1%CK_5 46.02
R_x_PM_SDFFS_X1%CK_r9 x_PM_SDFFS_X1%CK_16 x_PM_SDFFS_X1%CK_VSS 1.95
R_x_PM_SDFFS_X1%CK_r10 N_CK_M27_g x_PM_SDFFS_X1%CK_VSS 56.16
C_x_PM_SDFFS_X1%10_c0 VSS x_PM_SDFFS_X1%10_64 1.93305e-17
C_x_PM_SDFFS_X1%10_c1 VSS x_PM_SDFFS_X1%10_59 9.48089e-18
C_x_PM_SDFFS_X1%10_c2 VSS x_PM_SDFFS_X1%10_54 4.39502e-18
C_x_PM_SDFFS_X1%10_c3 VSS x_PM_SDFFS_X1%10_52 3.07245e-17
C_x_PM_SDFFS_X1%10_c4 VSS x_PM_SDFFS_X1%10_47 4.29952e-17
C_x_PM_SDFFS_X1%10_c5 VSS x_PM_SDFFS_X1%10_40 7.64086e-17
C_x_PM_SDFFS_X1%10_c6 VSS x_PM_SDFFS_X1%10_38 5.79751e-18
C_x_PM_SDFFS_X1%10_c7 VSS x_PM_SDFFS_X1%10_37 5.7949e-17
C_x_PM_SDFFS_X1%10_c8 VSS x_PM_SDFFS_X1%10_34 3.20508e-17
C_x_PM_SDFFS_X1%10_c9 VSS x_PM_SDFFS_X1%10_29 4.08727e-17
C_x_PM_SDFFS_X1%10_c10 VSS x_PM_SDFFS_X1%10_26 4.15796e-18
C_x_PM_SDFFS_X1%10_c11 VSS x_PM_SDFFS_X1%10_24 3.65626e-17
C_x_PM_SDFFS_X1%10_c12 VSS N_10_M16_g 3.98509e-17
C_x_PM_SDFFS_X1%10_c13 VSS N_10_M36_g 3.43903e-17
C_x_PM_SDFFS_X1%10_c14 VSS x_PM_SDFFS_X1%10_12 6.60929e-18
C_x_PM_SDFFS_X1%10_c15 VSS x_PM_SDFFS_X1%10_11 1.39754e-16
C_x_PM_SDFFS_X1%10_c16 VSS N_10_M31_g 6.88149e-17
C_x_PM_SDFFS_X1%10_c17 VSS x_PM_SDFFS_X1%10_6 9.63865e-18
C_x_PM_SDFFS_X1%10_c18 VSS x_PM_SDFFS_X1%10_5 3.16452e-17
C_x_PM_SDFFS_X1%10_c19 VSS N_10_M8_g 5.80364e-17
R_x_PM_SDFFS_X1%10_r20 x_PM_SDFFS_X1%10_57 x_PM_SDFFS_X1%10_55 3.38
R_x_PM_SDFFS_X1%10_r21 x_PM_SDFFS_X1%10_52 N_10_M6_d 0.133704
R_x_PM_SDFFS_X1%10_r22 x_PM_SDFFS_X1%10_47 N_10_M28_d 0.175926
R_x_PM_SDFFS_X1%10_r23 x_PM_SDFFS_X1%10_64 x_PM_SDFFS_X1%10_42 7.02
R_x_PM_SDFFS_X1%10_r24 x_PM_SDFFS_X1%10_42 x_PM_SDFFS_X1%10_40 25.0012
R_x_PM_SDFFS_X1%10_r25 x_PM_SDFFS_X1%10_40 x_PM_SDFFS_X1%10_39 1.15357
R_x_PM_SDFFS_X1%10_r26 x_PM_SDFFS_X1%10_39 x_PM_SDFFS_X1%10_37 0.212317
R_x_PM_SDFFS_X1%10_r27 x_PM_SDFFS_X1%10_38 x_PM_SDFFS_X1%10_37 0.787143
R_x_PM_SDFFS_X1%10_r28 x_PM_SDFFS_X1%10_59 x_PM_SDFFS_X1%10_34 25.0012
R_x_PM_SDFFS_X1%10_r29 x_PM_SDFFS_X1%10_38 x_PM_SDFFS_X1%10_32 0.212317
R_x_PM_SDFFS_X1%10_r30 x_PM_SDFFS_X1%10_34 x_PM_SDFFS_X1%10_32 0.366429
R_x_PM_SDFFS_X1%10_r31 x_PM_SDFFS_X1%10_55 x_PM_SDFFS_X1%10_29 25.0012
R_x_PM_SDFFS_X1%10_r32 x_PM_SDFFS_X1%10_54 x_PM_SDFFS_X1%10_27 0.0418175
R_x_PM_SDFFS_X1%10_r33 x_PM_SDFFS_X1%10_29 x_PM_SDFFS_X1%10_27 1.50643
R_x_PM_SDFFS_X1%10_r34 x_PM_SDFFS_X1%10_52 x_PM_SDFFS_X1%10_26 0.095
R_x_PM_SDFFS_X1%10_r35 x_PM_SDFFS_X1%10_54 x_PM_SDFFS_X1%10_25 0.160909
R_x_PM_SDFFS_X1%10_r36 x_PM_SDFFS_X1%10_26 x_PM_SDFFS_X1%10_25 0.271429
R_x_PM_SDFFS_X1%10_r37 x_PM_SDFFS_X1%10_54 x_PM_SDFFS_X1%10_24 0.160909
R_x_PM_SDFFS_X1%10_r38 x_PM_SDFFS_X1%10_47 x_PM_SDFFS_X1%10_23 0.095
R_x_PM_SDFFS_X1%10_r39 x_PM_SDFFS_X1%10_24 x_PM_SDFFS_X1%10_23 1.76429
R_x_PM_SDFFS_X1%10_r40 x_PM_SDFFS_X1%10_64 x_PM_SDFFS_X1%10_17 1.95
R_x_PM_SDFFS_X1%10_r41 N_10_M16_g x_PM_SDFFS_X1%10_17 42.9
R_x_PM_SDFFS_X1%10_r42 x_PM_SDFFS_X1%10_14 x_PM_SDFFS_X1%10_59 4.7687
R_x_PM_SDFFS_X1%10_r43 N_10_M36_g x_PM_SDFFS_X1%10_14 28.08
R_x_PM_SDFFS_X1%10_r44 N_10_M36_g x_PM_SDFFS_X1%10_13 26.52
R_x_PM_SDFFS_X1%10_r45 x_PM_SDFFS_X1%10_13 x_PM_SDFFS_X1%10_11 4.35808
R_x_PM_SDFFS_X1%10_r46 x_PM_SDFFS_X1%10_12 x_PM_SDFFS_X1%10_11 162.24
R_x_PM_SDFFS_X1%10_r47 N_10_M31_g x_PM_SDFFS_X1%10_8 64.74
R_x_PM_SDFFS_X1%10_r48 x_PM_SDFFS_X1%10_12 x_PM_SDFFS_X1%10_7 4.35808
R_x_PM_SDFFS_X1%10_r49 N_10_M31_g x_PM_SDFFS_X1%10_7 26.52
R_x_PM_SDFFS_X1%10_r50 x_PM_SDFFS_X1%10_6 x_PM_SDFFS_X1%10_57 3.4687
R_x_PM_SDFFS_X1%10_r51 x_PM_SDFFS_X1%10_8 x_PM_SDFFS_X1%10_5 4.35808
R_x_PM_SDFFS_X1%10_r52 x_PM_SDFFS_X1%10_6 x_PM_SDFFS_X1%10_5 32.76
R_x_PM_SDFFS_X1%10_r53 x_PM_SDFFS_X1%10_57 x_PM_SDFFS_X1%10_VSS 1.95
R_x_PM_SDFFS_X1%10_r54 N_10_M8_g x_PM_SDFFS_X1%10_VSS 65.52
C_x_PM_SDFFS_X1%11_c0 VSS x_PM_SDFFS_X1%11_51 7.3005e-18
C_x_PM_SDFFS_X1%11_c1 VSS x_PM_SDFFS_X1%11_49 1.83794e-17
C_x_PM_SDFFS_X1%11_c2 VSS x_PM_SDFFS_X1%11_43 1.05965e-17
C_x_PM_SDFFS_X1%11_c3 VSS x_PM_SDFFS_X1%11_41 2.3435e-17
C_x_PM_SDFFS_X1%11_c4 VSS x_PM_SDFFS_X1%11_37 8.2233e-17
C_x_PM_SDFFS_X1%11_c5 VSS x_PM_SDFFS_X1%11_36 1.04429e-17
C_x_PM_SDFFS_X1%11_c6 VSS x_PM_SDFFS_X1%11_34 1.10185e-16
C_x_PM_SDFFS_X1%11_c7 VSS x_PM_SDFFS_X1%11_32 1.27656e-17
C_x_PM_SDFFS_X1%11_c8 VSS x_PM_SDFFS_X1%11_31 2.24818e-17
C_x_PM_SDFFS_X1%11_c9 VSS x_PM_SDFFS_X1%11_27 3.20421e-17
C_x_PM_SDFFS_X1%11_c10 VSS N_11_M8_d 2.02667e-17
C_x_PM_SDFFS_X1%11_c11 VSS x_PM_SDFFS_X1%11_19 2.85041e-18
C_x_PM_SDFFS_X1%11_c12 VSS N_11_M14_g 3.81533e-17
C_x_PM_SDFFS_X1%11_c13 VSS x_PM_SDFFS_X1%11_14 3.49475e-17
C_x_PM_SDFFS_X1%11_c14 VSS N_11_M35_g 2.38959e-17
C_x_PM_SDFFS_X1%11_c15 VSS x_PM_SDFFS_X1%11_VSS 3.69363e-17
R_x_PM_SDFFS_X1%11_r16 x_PM_SDFFS_X1%11_51 x_PM_SDFFS_X1%11_50 1.3
R_x_PM_SDFFS_X1%11_r17 x_PM_SDFFS_X1%11_50 x_PM_SDFFS_X1%11_48 5.46
R_x_PM_SDFFS_X1%11_r18 x_PM_SDFFS_X1%11_49 x_PM_SDFFS_X1%11_48 3.4687
R_x_PM_SDFFS_X1%11_r19 x_PM_SDFFS_X1%11_46 x_PM_SDFFS_X1%11_43 0.257857
R_x_PM_SDFFS_X1%11_r20 x_PM_SDFFS_X1%11_50 x_PM_SDFFS_X1%11_43 25.0012
R_x_PM_SDFFS_X1%11_r21 x_PM_SDFFS_X1%11_41 x_PM_SDFFS_X1%11_38 0.0418175
R_x_PM_SDFFS_X1%11_r22 N_11_M12_d x_PM_SDFFS_X1%11_38 2.99929
R_x_PM_SDFFS_X1%11_r23 x_PM_SDFFS_X1%11_46 x_PM_SDFFS_X1%11_37 0.095
R_x_PM_SDFFS_X1%11_r24 N_11_M12_d x_PM_SDFFS_X1%11_37 1.75071
R_x_PM_SDFFS_X1%11_r25 x_PM_SDFFS_X1%11_41 x_PM_SDFFS_X1%11_35 0.160909
R_x_PM_SDFFS_X1%11_r26 x_PM_SDFFS_X1%11_36 x_PM_SDFFS_X1%11_35 0.488571
R_x_PM_SDFFS_X1%11_r27 x_PM_SDFFS_X1%11_41 x_PM_SDFFS_X1%11_34 0.160909
R_x_PM_SDFFS_X1%11_r28 x_PM_SDFFS_X1%11_34 x_PM_SDFFS_X1%11_33 2.74143
R_x_PM_SDFFS_X1%11_r29 x_PM_SDFFS_X1%11_36 x_PM_SDFFS_X1%11_31 0.212317
R_x_PM_SDFFS_X1%11_r30 x_PM_SDFFS_X1%11_32 x_PM_SDFFS_X1%11_31 0.542857
R_x_PM_SDFFS_X1%11_r31 x_PM_SDFFS_X1%11_33 x_PM_SDFFS_X1%11_27 0.212317
R_x_PM_SDFFS_X1%11_r32 N_11_M30_d x_PM_SDFFS_X1%11_27 0.366429
R_x_PM_SDFFS_X1%11_r33 x_PM_SDFFS_X1%11_32 x_PM_SDFFS_X1%11_23 0.212317
R_x_PM_SDFFS_X1%11_r34 N_11_M8_d x_PM_SDFFS_X1%11_23 0.420714
R_x_PM_SDFFS_X1%11_r35 x_PM_SDFFS_X1%11_51 x_PM_SDFFS_X1%11_15 1.95
R_x_PM_SDFFS_X1%11_r36 N_11_M14_g x_PM_SDFFS_X1%11_15 33.54
R_x_PM_SDFFS_X1%11_r37 x_PM_SDFFS_X1%11_48 x_PM_SDFFS_X1%11_14 1.95
R_x_PM_SDFFS_X1%11_r38 x_PM_SDFFS_X1%11_19 x_PM_SDFFS_X1%11_13 3.30287
R_x_PM_SDFFS_X1%11_r39 x_PM_SDFFS_X1%11_14 x_PM_SDFFS_X1%11_13 55.38
R_x_PM_SDFFS_X1%11_r40 x_PM_SDFFS_X1%11_19 x_PM_SDFFS_X1%11_9 3.30287
R_x_PM_SDFFS_X1%11_r41 N_11_M35_g x_PM_SDFFS_X1%11_9 14.82
R_x_PM_SDFFS_X1%11_r42 N_11_M13_g x_PM_SDFFS_X1%11_49 14.82
R_x_PM_SDFFS_X1%11_r43 x_PM_SDFFS_X1%11_19 x_PM_SDFFS_X1%11_VSS 0.858359
R_x_PM_SDFFS_X1%11_r44 N_11_M34_g x_PM_SDFFS_X1%11_VSS 28.08
C_x_PM_SDFFS_X1%12_c0 VSS x_PM_SDFFS_X1%12_31 1.45907e-17
C_x_PM_SDFFS_X1%12_c1 VSS N_12_M13_s 2.75905e-17
C_x_PM_SDFFS_X1%12_c2 VSS x_PM_SDFFS_X1%12_17 3.76361e-18
C_x_PM_SDFFS_X1%12_c3 VSS x_PM_SDFFS_X1%12_11 7.28714e-17
C_x_PM_SDFFS_X1%12_c4 VSS N_12_M34_d 3.36558e-17
C_x_PM_SDFFS_X1%12_c5 VSS N_12_M32_g 3.79472e-17
C_x_PM_SDFFS_X1%12_c6 VSS N_12_M10_g 6.79274e-17
R_x_PM_SDFFS_X1%12_r7 N_12_M13_s x_PM_SDFFS_X1%12_23 0.285
R_x_PM_SDFFS_X1%12_r8 x_PM_SDFFS_X1%12_22 x_PM_SDFFS_X1%12_21 0.186267
R_x_PM_SDFFS_X1%12_r9 x_PM_SDFFS_X1%12_23 x_PM_SDFFS_X1%12_17 0.095
R_x_PM_SDFFS_X1%12_r10 x_PM_SDFFS_X1%12_17 x_PM_SDFFS_X1%12_22 0.271429
R_x_PM_SDFFS_X1%12_r11 x_PM_SDFFS_X1%12_31 x_PM_SDFFS_X1%12_14 1.3
R_x_PM_SDFFS_X1%12_r12 x_PM_SDFFS_X1%12_14 x_PM_SDFFS_X1%12_28 5.46
R_x_PM_SDFFS_X1%12_r13 x_PM_SDFFS_X1%12_14 x_PM_SDFFS_X1%12_12 25.0012
R_x_PM_SDFFS_X1%12_r14 x_PM_SDFFS_X1%12_21 x_PM_SDFFS_X1%12_11 0.095
R_x_PM_SDFFS_X1%12_r15 x_PM_SDFFS_X1%12_12 x_PM_SDFFS_X1%12_11 2.40214
R_x_PM_SDFFS_X1%12_r16 x_PM_SDFFS_X1%12_21 N_12_M34_d 0.246296
R_x_PM_SDFFS_X1%12_r17 x_PM_SDFFS_X1%12_31 x_PM_SDFFS_X1%12_5 1.95
R_x_PM_SDFFS_X1%12_r18 N_12_M32_g x_PM_SDFFS_X1%12_5 40.56
R_x_PM_SDFFS_X1%12_r19 x_PM_SDFFS_X1%12_28 x_PM_SDFFS_X1%12_VSS 1.95
R_x_PM_SDFFS_X1%12_r20 N_12_M10_g x_PM_SDFFS_X1%12_VSS 82.68
C_x_PM_SDFFS_X1%SN_c0 VSS x_PM_SDFFS_X1%SN_41 1.10911e-17
C_x_PM_SDFFS_X1%SN_c1 VSS x_PM_SDFFS_X1%SN_36 1.36149e-17
C_x_PM_SDFFS_X1%SN_c2 VSS x_PM_SDFFS_X1%SN_29 3.05043e-17
C_x_PM_SDFFS_X1%SN_c3 VSS x_PM_SDFFS_X1%SN_28 2.22977e-17
C_x_PM_SDFFS_X1%SN_c4 VSS SN 4.19287e-17
C_x_PM_SDFFS_X1%SN_c5 VSS x_PM_SDFFS_X1%SN_23 7.71249e-18
C_x_PM_SDFFS_X1%SN_c6 VSS x_PM_SDFFS_X1%SN_22 2.09317e-16
C_x_PM_SDFFS_X1%SN_c7 VSS x_PM_SDFFS_X1%SN_18 2.04447e-17
C_x_PM_SDFFS_X1%SN_c8 VSS N_SN_M39_g 3.72081e-17
C_x_PM_SDFFS_X1%SN_c9 VSS N_SN_M18_g 6.71966e-17
C_x_PM_SDFFS_X1%SN_c10 VSS N_SN_M33_g 1.87402e-17
C_x_PM_SDFFS_X1%SN_c11 VSS N_SN_M11_g 8.61308e-17
R_x_PM_SDFFS_X1%SN_r12 x_PM_SDFFS_X1%SN_41 x_PM_SDFFS_X1%SN_31 3.38
R_x_PM_SDFFS_X1%SN_r13 x_PM_SDFFS_X1%SN_31 x_PM_SDFFS_X1%SN_38 1.3
R_x_PM_SDFFS_X1%SN_r14 x_PM_SDFFS_X1%SN_31 x_PM_SDFFS_X1%SN_29 25.0012
R_x_PM_SDFFS_X1%SN_r15 x_PM_SDFFS_X1%SN_29 x_PM_SDFFS_X1%SN_28 1.045
R_x_PM_SDFFS_X1%SN_r16 x_PM_SDFFS_X1%SN_28 x_PM_SDFFS_X1%SN_25 0.212317
R_x_PM_SDFFS_X1%SN_r17 SN x_PM_SDFFS_X1%SN_25 0.217143
R_x_PM_SDFFS_X1%SN_r18 SN x_PM_SDFFS_X1%SN_24 0.787143
R_x_PM_SDFFS_X1%SN_r19 x_PM_SDFFS_X1%SN_24 x_PM_SDFFS_X1%SN_22 0.212317
R_x_PM_SDFFS_X1%SN_r20 x_PM_SDFFS_X1%SN_23 x_PM_SDFFS_X1%SN_22 6.08
R_x_PM_SDFFS_X1%SN_r21 x_PM_SDFFS_X1%SN_36 x_PM_SDFFS_X1%SN_20 1.3
R_x_PM_SDFFS_X1%SN_r22 x_PM_SDFFS_X1%SN_20 x_PM_SDFFS_X1%SN_33 5.46
R_x_PM_SDFFS_X1%SN_r23 x_PM_SDFFS_X1%SN_20 x_PM_SDFFS_X1%SN_18 25.0012
R_x_PM_SDFFS_X1%SN_r24 x_PM_SDFFS_X1%SN_23 x_PM_SDFFS_X1%SN_17 0.212317
R_x_PM_SDFFS_X1%SN_r25 x_PM_SDFFS_X1%SN_18 x_PM_SDFFS_X1%SN_17 0.257857
R_x_PM_SDFFS_X1%SN_r26 x_PM_SDFFS_X1%SN_41 x_PM_SDFFS_X1%SN_13 1.95
R_x_PM_SDFFS_X1%SN_r27 N_SN_M39_g x_PM_SDFFS_X1%SN_13 28.86
R_x_PM_SDFFS_X1%SN_r28 x_PM_SDFFS_X1%SN_38 x_PM_SDFFS_X1%SN_9 1.95
R_x_PM_SDFFS_X1%SN_r29 N_SN_M18_g x_PM_SDFFS_X1%SN_9 69.42
R_x_PM_SDFFS_X1%SN_r30 x_PM_SDFFS_X1%SN_36 x_PM_SDFFS_X1%SN_5 1.95
R_x_PM_SDFFS_X1%SN_r31 N_SN_M33_g x_PM_SDFFS_X1%SN_5 14.82
R_x_PM_SDFFS_X1%SN_r32 x_PM_SDFFS_X1%SN_33 x_PM_SDFFS_X1%SN_VSS 1.95
R_x_PM_SDFFS_X1%SN_r33 N_SN_M11_g x_PM_SDFFS_X1%SN_VSS 87.36
C_x_PM_SDFFS_X1%14_c0 VSS x_PM_SDFFS_X1%14_40 1.36635e-17
C_x_PM_SDFFS_X1%14_c1 VSS x_PM_SDFFS_X1%14_36 2.07142e-17
C_x_PM_SDFFS_X1%14_c2 VSS x_PM_SDFFS_X1%14_33 1.29105e-16
C_x_PM_SDFFS_X1%14_c3 VSS x_PM_SDFFS_X1%14_30 2.50424e-17
C_x_PM_SDFFS_X1%14_c4 VSS x_PM_SDFFS_X1%14_28 7.71569e-17
C_x_PM_SDFFS_X1%14_c5 VSS x_PM_SDFFS_X1%14_23 4.23178e-17
C_x_PM_SDFFS_X1%14_c6 VSS x_PM_SDFFS_X1%14_19 1.17636e-16
C_x_PM_SDFFS_X1%14_c7 VSS N_14_M42_g 1.35428e-16
C_x_PM_SDFFS_X1%14_c8 VSS x_PM_SDFFS_X1%14_10 5.20047e-18
C_x_PM_SDFFS_X1%14_c9 VSS x_PM_SDFFS_X1%14_9 6.48647e-17
C_x_PM_SDFFS_X1%14_c10 VSS N_14_M40_g 6.73255e-17
C_x_PM_SDFFS_X1%14_c11 VSS N_14_M19_g 5.13136e-17
R_x_PM_SDFFS_X1%14_r12 x_PM_SDFFS_X1%14_40 x_PM_SDFFS_X1%14_39 2.46316
R_x_PM_SDFFS_X1%14_r13 x_PM_SDFFS_X1%14_39 x_PM_SDFFS_X1%14_37 1.02632
R_x_PM_SDFFS_X1%14_r14 x_PM_SDFFS_X1%14_37 x_PM_SDFFS_X1%14_33 25.0012
R_x_PM_SDFFS_X1%14_r15 x_PM_SDFFS_X1%14_36 x_PM_SDFFS_X1%14_31 0.0418175
R_x_PM_SDFFS_X1%14_r16 x_PM_SDFFS_X1%14_33 x_PM_SDFFS_X1%14_31 2.755
R_x_PM_SDFFS_X1%14_r17 x_PM_SDFFS_X1%14_36 x_PM_SDFFS_X1%14_29 0.160909
R_x_PM_SDFFS_X1%14_r18 x_PM_SDFFS_X1%14_30 x_PM_SDFFS_X1%14_29 0.597143
R_x_PM_SDFFS_X1%14_r19 x_PM_SDFFS_X1%14_36 x_PM_SDFFS_X1%14_28 0.160909
R_x_PM_SDFFS_X1%14_r20 x_PM_SDFFS_X1%14_28 x_PM_SDFFS_X1%14_27 1.62857
R_x_PM_SDFFS_X1%14_r21 x_PM_SDFFS_X1%14_30 x_PM_SDFFS_X1%14_23 0.212317
R_x_PM_SDFFS_X1%14_r22 N_14_M15_d x_PM_SDFFS_X1%14_23 0.773571
R_x_PM_SDFFS_X1%14_r23 x_PM_SDFFS_X1%14_27 x_PM_SDFFS_X1%14_19 0.212317
R_x_PM_SDFFS_X1%14_r24 N_14_M36_d x_PM_SDFFS_X1%14_19 0.800714
R_x_PM_SDFFS_X1%14_r25 N_14_M21_g N_14_M42_g 141.57
R_x_PM_SDFFS_X1%14_r26 N_14_M21_g x_PM_SDFFS_X1%14_11 30.03
R_x_PM_SDFFS_X1%14_r27 x_PM_SDFFS_X1%14_11 x_PM_SDFFS_X1%14_9 4.35808
R_x_PM_SDFFS_X1%14_r28 x_PM_SDFFS_X1%14_10 x_PM_SDFFS_X1%14_9 83.46
R_x_PM_SDFFS_X1%14_r29 x_PM_SDFFS_X1%14_40 x_PM_SDFFS_X1%14_5 1.95
R_x_PM_SDFFS_X1%14_r30 N_14_M40_g x_PM_SDFFS_X1%14_5 63.96
R_x_PM_SDFFS_X1%14_r31 x_PM_SDFFS_X1%14_10 x_PM_SDFFS_X1%14_2 4.35808
R_x_PM_SDFFS_X1%14_r32 N_14_M19_g x_PM_SDFFS_X1%14_2 26.52
R_x_PM_SDFFS_X1%14_r33 x_PM_SDFFS_X1%14_39 x_PM_SDFFS_X1%14_VSS 1.95
R_x_PM_SDFFS_X1%14_r34 N_14_M19_g x_PM_SDFFS_X1%14_VSS 45.24
C_x_PM_SDFFS_X1%15_c0 VSS x_PM_SDFFS_X1%15_35 8.93455e-17
C_x_PM_SDFFS_X1%15_c1 VSS x_PM_SDFFS_X1%15_32 1.40855e-17
C_x_PM_SDFFS_X1%15_c2 VSS N_15_M40_d 6.23163e-17
C_x_PM_SDFFS_X1%15_c3 VSS x_PM_SDFFS_X1%15_24 8.68536e-18
C_x_PM_SDFFS_X1%15_c4 VSS x_PM_SDFFS_X1%15_21 1.63095e-16
C_x_PM_SDFFS_X1%15_c5 VSS x_PM_SDFFS_X1%15_18 4.44968e-18
C_x_PM_SDFFS_X1%15_c6 VSS x_PM_SDFFS_X1%15_17 2.92637e-17
C_x_PM_SDFFS_X1%15_c7 VSS N_15_M20_g 7.2891e-17
C_x_PM_SDFFS_X1%15_c8 VSS N_15_M41_g 5.13308e-17
C_x_PM_SDFFS_X1%15_c9 VSS N_15_M38_g 6.7856e-17
C_x_PM_SDFFS_X1%15_c10 VSS N_15_M17_g 2.4377e-17
R_x_PM_SDFFS_X1%15_r11 x_PM_SDFFS_X1%15_38 x_PM_SDFFS_X1%15_35 25.0012
R_x_PM_SDFFS_X1%15_r12 x_PM_SDFFS_X1%15_35 x_PM_SDFFS_X1%15_33 1.805
R_x_PM_SDFFS_X1%15_r13 x_PM_SDFFS_X1%15_35 x_PM_SDFFS_X1%15_32 0.393571
R_x_PM_SDFFS_X1%15_r14 x_PM_SDFFS_X1%15_32 x_PM_SDFFS_X1%15_28 0.247769
R_x_PM_SDFFS_X1%15_r15 N_15_M40_d x_PM_SDFFS_X1%15_28 0.0330435
R_x_PM_SDFFS_X1%15_r16 x_PM_SDFFS_X1%15_42 x_PM_SDFFS_X1%15_24 4.7687
R_x_PM_SDFFS_X1%15_r17 x_PM_SDFFS_X1%15_41 x_PM_SDFFS_X1%15_24 4.7687
R_x_PM_SDFFS_X1%15_r18 x_PM_SDFFS_X1%15_24 x_PM_SDFFS_X1%15_22 25.0012
R_x_PM_SDFFS_X1%15_r19 N_15_M18_d x_PM_SDFFS_X1%15_22 1.49286
R_x_PM_SDFFS_X1%15_r20 x_PM_SDFFS_X1%15_33 x_PM_SDFFS_X1%15_21 0.212317
R_x_PM_SDFFS_X1%15_r21 N_15_M18_d x_PM_SDFFS_X1%15_21 1.34357
R_x_PM_SDFFS_X1%15_r22 x_PM_SDFFS_X1%15_38 x_PM_SDFFS_X1%15_17 20.54
R_x_PM_SDFFS_X1%15_r23 x_PM_SDFFS_X1%15_18 x_PM_SDFFS_X1%15_17 0.043368
R_x_PM_SDFFS_X1%15_r24 x_PM_SDFFS_X1%15_18 x_PM_SDFFS_X1%15_13 4.56151
R_x_PM_SDFFS_X1%15_r25 N_15_M20_g x_PM_SDFFS_X1%15_13 77.61
R_x_PM_SDFFS_X1%15_r26 x_PM_SDFFS_X1%15_18 x_PM_SDFFS_X1%15_9 4.56151
R_x_PM_SDFFS_X1%15_r27 N_15_M41_g x_PM_SDFFS_X1%15_9 52.26
R_x_PM_SDFFS_X1%15_r28 N_15_M38_g x_PM_SDFFS_X1%15_41 74.1
R_x_PM_SDFFS_X1%15_r29 N_15_M17_g x_PM_SDFFS_X1%15_42 24.18
C_x_PM_SDFFS_X1%QN_c0 VSS QN 3.92114e-17
C_x_PM_SDFFS_X1%QN_c1 VSS N_QN_M20_s 1.54145e-16
C_x_PM_SDFFS_X1%QN_c2 VSS N_QN_M41_s 4.32443e-17
R_x_PM_SDFFS_X1%QN_r3 x_PM_SDFFS_X1%QN_14 QN 0.295654
R_x_PM_SDFFS_X1%QN_r4 x_PM_SDFFS_X1%QN_13 QN 0.295654
R_x_PM_SDFFS_X1%QN_r5 N_QN_M20_s x_PM_SDFFS_X1%QN_14 3.62357
R_x_PM_SDFFS_X1%QN_r6 N_QN_M41_s x_PM_SDFFS_X1%QN_13 0.339286
C_x_PM_SDFFS_X1%Q_c0 VSS N_Q_M42_d 1.34419e-16
R_x_PM_SDFFS_X1%Q_r1 N_Q_M21_d Q 1.58045
R_x_PM_SDFFS_X1%Q_r2 Q N_Q_M42_d 1.425
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFFS_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFFS_X2 VSS VDD SE D SI CK SN QN Q
*.PININFO VSS:B VDD:B SE:I D:I SI:I CK:I SN:I QN:O Q:O
M_M21 N_VDD_M0_d N_SE_M0_g N_3_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M22 18 N_D_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M23 N_7_M2_d N_SE_M2_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M24 19 N_3_M3_g N_7_M2_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M4_d N_SI_M4_g 19 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_VDD_M5_d N_CK_M5_g N_8_M5_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M27 N_10_M6_d N_8_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M28 20 N_7_M7_g N_VDD_M7_s VDD PMOS_VTL W=0.180000U L=0.050000U
M_M29 N_11_M8_d N_10_M8_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M30 21 N_8_M9_g N_11_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M31 N_VDD_M10_d N_12_M10_g 21 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M32 22 N_SN_M11_g N_VDD_M10_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M33 N_11_M12_d N_8_M12_g 22 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M34 N_VDD_M13_d N_11_M13_g N_12_M13_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M35 23 N_11_M14_g N_VDD_M13_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M36 N_14_M15_d N_8_M15_g 23 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M37 24 N_10_M16_g N_14_M15_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M38 N_VDD_M17_d N_15_M17_g 24 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M39 N_15_M18_d N_SN_M18_g N_VDD_M17_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M40 N_VDD_M19_d N_14_M19_g N_15_M18_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M41 N_VDD_M20_d N_15_M20_g N_QN_M20_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M42 N_Q_M21_d N_14_M21_g N_VDD_M20_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M22_d N_SE_M22_g N_3_M22_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 25 N_SI_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_7_M24_d N_SE_M24_g 25 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 26 N_3_M25_g N_7_M24_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 N_VSS_M26_d N_D_M26_g 26 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M27_d N_CK_M27_g N_8_M27_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_10_M28_d N_8_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M7 27 N_7_M29_g N_VSS_M29_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_11_M30_d N_8_M30_g 27 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M9 28 N_10_M31_g N_11_M30_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 29 N_12_M32_g 28 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 N_VSS_M33_d N_SN_M33_g 29 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M12 N_12_M34_d N_11_M34_g N_VSS_M33_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M13 30 N_11_M35_g N_VSS_M33_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M14 N_14_M36_d N_10_M36_g 30 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M15 31 N_8_M37_g N_14_M36_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M16 N_VSS_M38_d N_15_M38_g 31 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M17 32 N_SN_M39_g N_VSS_M38_d VSS NMOS_VTL W=0.270000U L=0.050000U
M_M18 N_15_M40_d N_14_M40_g 32 VSS NMOS_VTL W=0.270000U L=0.050000U
M_M19 N_VSS_M41_d N_15_M41_g N_QN_M41_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M20 N_Q_M42_d N_14_M42_g N_VSS_M41_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFFS_X2%VSS_c0 VSS x_PM_SDFFS_X2%VSS_58 5.6044e-18
C_x_PM_SDFFS_X2%VSS_c1 VSS x_PM_SDFFS_X2%VSS_57 5.72882e-18
C_x_PM_SDFFS_X2%VSS_c2 VSS x_PM_SDFFS_X2%VSS_52 5.06625e-17
C_x_PM_SDFFS_X2%VSS_c3 VSS x_PM_SDFFS_X2%VSS_51 4.6069e-18
C_x_PM_SDFFS_X2%VSS_c4 VSS x_PM_SDFFS_X2%VSS_46 2.01079e-17
C_x_PM_SDFFS_X2%VSS_c5 VSS x_PM_SDFFS_X2%VSS_45 8.86015e-18
C_x_PM_SDFFS_X2%VSS_c6 VSS x_PM_SDFFS_X2%VSS_44 2.94666e-17
C_x_PM_SDFFS_X2%VSS_c7 VSS VSS 4.33461e-17
C_x_PM_SDFFS_X2%VSS_c8 VSS N_VSS_M41_d 3.2293e-17
C_x_PM_SDFFS_X2%VSS_c9 VSS x_PM_SDFFS_X2%VSS_34 5.76115e-17
C_x_PM_SDFFS_X2%VSS_c10 VSS N_VSS_M38_d 6.53843e-17
C_x_PM_SDFFS_X2%VSS_c11 VSS x_PM_SDFFS_X2%VSS_28 1.23204e-16
C_x_PM_SDFFS_X2%VSS_c12 VSS x_PM_SDFFS_X2%VSS_26 9.87519e-17
C_x_PM_SDFFS_X2%VSS_c13 VSS N_VSS_M29_s 3.50247e-17
C_x_PM_SDFFS_X2%VSS_c14 VSS x_PM_SDFFS_X2%VSS_20 3.57023e-17
C_x_PM_SDFFS_X2%VSS_c15 VSS x_PM_SDFFS_X2%VSS_18 2.81273e-17
C_x_PM_SDFFS_X2%VSS_c16 VSS x_PM_SDFFS_X2%VSS_17 5.01338e-17
C_x_PM_SDFFS_X2%VSS_c17 VSS x_PM_SDFFS_X2%VSS_14 6.96871e-17
C_x_PM_SDFFS_X2%VSS_c18 VSS N_VSS_M22_d 2.97277e-17
R_x_PM_SDFFS_X2%VSS_r19 N_VSS_M33_d x_PM_SDFFS_X2%VSS_52 0.49963
R_x_PM_SDFFS_X2%VSS_r20 N_VSS_M27_d x_PM_SDFFS_X2%VSS_46 0.49963
R_x_PM_SDFFS_X2%VSS_r21 x_PM_SDFFS_X2%VSS_58 x_PM_SDFFS_X2%VSS_40 0.132285
R_x_PM_SDFFS_X2%VSS_r22 VSS x_PM_SDFFS_X2%VSS_40 0.558824
R_x_PM_SDFFS_X2%VSS_r23 x_PM_SDFFS_X2%VSS_58 x_PM_SDFFS_X2%VSS_36 0.0680382
R_x_PM_SDFFS_X2%VSS_r24 N_VSS_M41_d x_PM_SDFFS_X2%VSS_36 0.330741
R_x_PM_SDFFS_X2%VSS_r25 x_PM_SDFFS_X2%VSS_57 x_PM_SDFFS_X2%VSS_35 0.132285
R_x_PM_SDFFS_X2%VSS_r26 x_PM_SDFFS_X2%VSS_58 x_PM_SDFFS_X2%VSS_34 0.132285
R_x_PM_SDFFS_X2%VSS_r27 x_PM_SDFFS_X2%VSS_35 x_PM_SDFFS_X2%VSS_34 1.36353
R_x_PM_SDFFS_X2%VSS_r28 x_PM_SDFFS_X2%VSS_57 x_PM_SDFFS_X2%VSS_30 0.0680382
R_x_PM_SDFFS_X2%VSS_r29 N_VSS_M38_d x_PM_SDFFS_X2%VSS_30 0.851481
R_x_PM_SDFFS_X2%VSS_r30 x_PM_SDFFS_X2%VSS_52 x_PM_SDFFS_X2%VSS_29 0.095
R_x_PM_SDFFS_X2%VSS_r31 x_PM_SDFFS_X2%VSS_57 x_PM_SDFFS_X2%VSS_28 0.132285
R_x_PM_SDFFS_X2%VSS_r32 x_PM_SDFFS_X2%VSS_29 x_PM_SDFFS_X2%VSS_28 2.45882
R_x_PM_SDFFS_X2%VSS_r33 x_PM_SDFFS_X2%VSS_51 x_PM_SDFFS_X2%VSS_27 0.0731438
R_x_PM_SDFFS_X2%VSS_r34 x_PM_SDFFS_X2%VSS_52 x_PM_SDFFS_X2%VSS_26 0.095
R_x_PM_SDFFS_X2%VSS_r35 x_PM_SDFFS_X2%VSS_27 x_PM_SDFFS_X2%VSS_26 1.92235
R_x_PM_SDFFS_X2%VSS_r36 x_PM_SDFFS_X2%VSS_51 x_PM_SDFFS_X2%VSS_22 0.145286
R_x_PM_SDFFS_X2%VSS_r37 N_VSS_M29_s x_PM_SDFFS_X2%VSS_22 0.909286
R_x_PM_SDFFS_X2%VSS_r38 x_PM_SDFFS_X2%VSS_46 x_PM_SDFFS_X2%VSS_21 0.095
R_x_PM_SDFFS_X2%VSS_r39 x_PM_SDFFS_X2%VSS_51 x_PM_SDFFS_X2%VSS_20 0.0731438
R_x_PM_SDFFS_X2%VSS_r40 x_PM_SDFFS_X2%VSS_21 x_PM_SDFFS_X2%VSS_20 0.625882
R_x_PM_SDFFS_X2%VSS_r41 x_PM_SDFFS_X2%VSS_45 x_PM_SDFFS_X2%VSS_19 0.132285
R_x_PM_SDFFS_X2%VSS_r42 x_PM_SDFFS_X2%VSS_46 x_PM_SDFFS_X2%VSS_18 0.095
R_x_PM_SDFFS_X2%VSS_r43 x_PM_SDFFS_X2%VSS_19 x_PM_SDFFS_X2%VSS_18 0.625882
R_x_PM_SDFFS_X2%VSS_r44 x_PM_SDFFS_X2%VSS_45 x_PM_SDFFS_X2%VSS_17 0.0680382
R_x_PM_SDFFS_X2%VSS_r45 x_PM_SDFFS_X2%VSS_17 N_VSS_M26_d 0.403583
R_x_PM_SDFFS_X2%VSS_r46 x_PM_SDFFS_X2%VSS_44 x_PM_SDFFS_X2%VSS_15 0.0731438
R_x_PM_SDFFS_X2%VSS_r47 x_PM_SDFFS_X2%VSS_45 x_PM_SDFFS_X2%VSS_14 0.132285
R_x_PM_SDFFS_X2%VSS_r48 x_PM_SDFFS_X2%VSS_15 x_PM_SDFFS_X2%VSS_14 1.47529
R_x_PM_SDFFS_X2%VSS_r49 x_PM_SDFFS_X2%VSS_44 x_PM_SDFFS_X2%VSS_10 0.145286
R_x_PM_SDFFS_X2%VSS_r50 N_VSS_M22_d x_PM_SDFFS_X2%VSS_10 0.909286
C_x_PM_SDFFS_X2%VDD_c0 VSS x_PM_SDFFS_X2%VDD_65 3.47116e-17
C_x_PM_SDFFS_X2%VDD_c1 VSS x_PM_SDFFS_X2%VDD_64 8.85742e-18
C_x_PM_SDFFS_X2%VDD_c2 VSS x_PM_SDFFS_X2%VDD_63 5.64357e-18
C_x_PM_SDFFS_X2%VDD_c3 VSS x_PM_SDFFS_X2%VDD_62 8.86015e-18
C_x_PM_SDFFS_X2%VDD_c4 VSS x_PM_SDFFS_X2%VDD_61 8.87094e-18
C_x_PM_SDFFS_X2%VDD_c5 VSS x_PM_SDFFS_X2%VDD_60 4.62499e-18
C_x_PM_SDFFS_X2%VDD_c6 VSS x_PM_SDFFS_X2%VDD_58 6.66288e-17
C_x_PM_SDFFS_X2%VDD_c7 VSS N_VDD_M0_d 2.93921e-17
C_x_PM_SDFFS_X2%VDD_c8 VSS N_VDD_M20_d 2.39239e-17
C_x_PM_SDFFS_X2%VDD_c9 VSS x_PM_SDFFS_X2%VDD_44 2.67781e-17
C_x_PM_SDFFS_X2%VDD_c10 VSS x_PM_SDFFS_X2%VDD_43 2.2754e-17
C_x_PM_SDFFS_X2%VDD_c11 VSS x_PM_SDFFS_X2%VDD_40 1.73771e-17
C_x_PM_SDFFS_X2%VDD_c12 VSS x_PM_SDFFS_X2%VDD_39 2.56853e-17
C_x_PM_SDFFS_X2%VDD_c13 VSS x_PM_SDFFS_X2%VDD_36 6.73434e-17
C_x_PM_SDFFS_X2%VDD_c14 VSS x_PM_SDFFS_X2%VDD_35 2.23174e-17
C_x_PM_SDFFS_X2%VDD_c15 VSS x_PM_SDFFS_X2%VDD_32 4.16437e-17
C_x_PM_SDFFS_X2%VDD_c16 VSS N_VDD_M10_d 5.01475e-17
C_x_PM_SDFFS_X2%VDD_c17 VSS x_PM_SDFFS_X2%VDD_24 6.06663e-17
C_x_PM_SDFFS_X2%VDD_c18 VSS N_VDD_M7_s 2.53188e-17
C_x_PM_SDFFS_X2%VDD_c19 VSS x_PM_SDFFS_X2%VDD_16 7.02646e-17
C_x_PM_SDFFS_X2%VDD_c20 VSS x_PM_SDFFS_X2%VDD_15 2.72697e-17
C_x_PM_SDFFS_X2%VDD_c21 VSS x_PM_SDFFS_X2%VDD_14 1.31491e-16
C_x_PM_SDFFS_X2%VDD_c22 VSS x_PM_SDFFS_X2%VDD_13 1.93104e-17
R_x_PM_SDFFS_X2%VDD_r23 x_PM_SDFFS_X2%VDD_58 N_VDD_M4_d 0.140674
R_x_PM_SDFFS_X2%VDD_r24 x_PM_SDFFS_X2%VDD_65 x_PM_SDFFS_X2%VDD_46 0.145286
R_x_PM_SDFFS_X2%VDD_r25 N_VDD_M20_d x_PM_SDFFS_X2%VDD_46 0.909286
R_x_PM_SDFFS_X2%VDD_r26 x_PM_SDFFS_X2%VDD_64 x_PM_SDFFS_X2%VDD_45 0.132285
R_x_PM_SDFFS_X2%VDD_r27 x_PM_SDFFS_X2%VDD_65 x_PM_SDFFS_X2%VDD_44 0.0731438
R_x_PM_SDFFS_X2%VDD_r28 x_PM_SDFFS_X2%VDD_45 x_PM_SDFFS_X2%VDD_44 0.648235
R_x_PM_SDFFS_X2%VDD_r29 x_PM_SDFFS_X2%VDD_64 x_PM_SDFFS_X2%VDD_43 0.0680382
R_x_PM_SDFFS_X2%VDD_r30 x_PM_SDFFS_X2%VDD_43 N_VDD_M19_d 0.403583
R_x_PM_SDFFS_X2%VDD_r31 x_PM_SDFFS_X2%VDD_63 x_PM_SDFFS_X2%VDD_41 0.132285
R_x_PM_SDFFS_X2%VDD_r32 x_PM_SDFFS_X2%VDD_64 x_PM_SDFFS_X2%VDD_40 0.132285
R_x_PM_SDFFS_X2%VDD_r33 x_PM_SDFFS_X2%VDD_41 x_PM_SDFFS_X2%VDD_40 0.57
R_x_PM_SDFFS_X2%VDD_r34 x_PM_SDFFS_X2%VDD_63 x_PM_SDFFS_X2%VDD_39 0.0680382
R_x_PM_SDFFS_X2%VDD_r35 x_PM_SDFFS_X2%VDD_39 N_VDD_M17_d 0.403583
R_x_PM_SDFFS_X2%VDD_r36 x_PM_SDFFS_X2%VDD_62 x_PM_SDFFS_X2%VDD_37 0.132285
R_x_PM_SDFFS_X2%VDD_r37 x_PM_SDFFS_X2%VDD_63 x_PM_SDFFS_X2%VDD_36 0.132285
R_x_PM_SDFFS_X2%VDD_r38 x_PM_SDFFS_X2%VDD_37 x_PM_SDFFS_X2%VDD_36 1.73235
R_x_PM_SDFFS_X2%VDD_r39 x_PM_SDFFS_X2%VDD_62 x_PM_SDFFS_X2%VDD_35 0.0680382
R_x_PM_SDFFS_X2%VDD_r40 x_PM_SDFFS_X2%VDD_35 N_VDD_M13_d 0.403583
R_x_PM_SDFFS_X2%VDD_r41 x_PM_SDFFS_X2%VDD_61 x_PM_SDFFS_X2%VDD_33 0.132285
R_x_PM_SDFFS_X2%VDD_r42 x_PM_SDFFS_X2%VDD_62 x_PM_SDFFS_X2%VDD_32 0.132285
R_x_PM_SDFFS_X2%VDD_r43 x_PM_SDFFS_X2%VDD_33 x_PM_SDFFS_X2%VDD_32 0.938824
R_x_PM_SDFFS_X2%VDD_r44 VDD N_VDD_M10_d 0.344815
R_x_PM_SDFFS_X2%VDD_r45 x_PM_SDFFS_X2%VDD_61 x_PM_SDFFS_X2%VDD_26 0.0680382
R_x_PM_SDFFS_X2%VDD_r46 VDD x_PM_SDFFS_X2%VDD_26 0.168889
R_x_PM_SDFFS_X2%VDD_r47 x_PM_SDFFS_X2%VDD_60 x_PM_SDFFS_X2%VDD_25 0.0731438
R_x_PM_SDFFS_X2%VDD_r48 x_PM_SDFFS_X2%VDD_61 x_PM_SDFFS_X2%VDD_24 0.132285
R_x_PM_SDFFS_X2%VDD_r49 x_PM_SDFFS_X2%VDD_25 x_PM_SDFFS_X2%VDD_24 1.46412
R_x_PM_SDFFS_X2%VDD_r50 x_PM_SDFFS_X2%VDD_60 x_PM_SDFFS_X2%VDD_21 0.145286
R_x_PM_SDFFS_X2%VDD_r51 N_VDD_M7_s x_PM_SDFFS_X2%VDD_21 1.07214
R_x_PM_SDFFS_X2%VDD_r52 N_VDD_M7_s x_PM_SDFFS_X2%VDD_20 0.122143
R_x_PM_SDFFS_X2%VDD_r53 x_PM_SDFFS_X2%VDD_20 x_PM_SDFFS_X2%VDD_16 0.212317
R_x_PM_SDFFS_X2%VDD_r54 N_VDD_M5_d x_PM_SDFFS_X2%VDD_16 1.53357
R_x_PM_SDFFS_X2%VDD_r55 x_PM_SDFFS_X2%VDD_15 N_VDD_M4_d 0.140674
R_x_PM_SDFFS_X2%VDD_r56 x_PM_SDFFS_X2%VDD_60 x_PM_SDFFS_X2%VDD_14 0.0731438
R_x_PM_SDFFS_X2%VDD_r57 x_PM_SDFFS_X2%VDD_15 x_PM_SDFFS_X2%VDD_14 1.34118
R_x_PM_SDFFS_X2%VDD_r58 x_PM_SDFFS_X2%VDD_13 N_VDD_M0_d 0.140674
R_x_PM_SDFFS_X2%VDD_r59 x_PM_SDFFS_X2%VDD_13 x_PM_SDFFS_X2%VDD_58 1.39706
C_x_PM_SDFFS_X2%3_c0 VSS x_PM_SDFFS_X2%3_25 8.39994e-18
C_x_PM_SDFFS_X2%3_c1 VSS x_PM_SDFFS_X2%3_24 3.12377e-18
C_x_PM_SDFFS_X2%3_c2 VSS x_PM_SDFFS_X2%3_21 1.47211e-16
C_x_PM_SDFFS_X2%3_c3 VSS N_3_M0_s 3.31612e-17
C_x_PM_SDFFS_X2%3_c4 VSS N_3_M22_s 7.63299e-17
C_x_PM_SDFFS_X2%3_c5 VSS N_3_M3_g 5.78772e-17
C_x_PM_SDFFS_X2%3_c6 VSS N_3_M25_g 6.56127e-17
R_x_PM_SDFFS_X2%3_r7 x_PM_SDFFS_X2%3_27 x_PM_SDFFS_X2%3_25 4.7687
R_x_PM_SDFFS_X2%3_r8 x_PM_SDFFS_X2%3_25 x_PM_SDFFS_X2%3_21 25.0012
R_x_PM_SDFFS_X2%3_r9 x_PM_SDFFS_X2%3_24 x_PM_SDFFS_X2%3_19 0.0604376
R_x_PM_SDFFS_X2%3_r10 x_PM_SDFFS_X2%3_21 x_PM_SDFFS_X2%3_19 3.35214
R_x_PM_SDFFS_X2%3_r11 x_PM_SDFFS_X2%3_24 x_PM_SDFFS_X2%3_15 0.140052
R_x_PM_SDFFS_X2%3_r12 N_3_M0_s x_PM_SDFFS_X2%3_15 0.89
R_x_PM_SDFFS_X2%3_r13 x_PM_SDFFS_X2%3_24 x_PM_SDFFS_X2%3_11 0.140052
R_x_PM_SDFFS_X2%3_r14 N_3_M22_s x_PM_SDFFS_X2%3_11 2.32071
R_x_PM_SDFFS_X2%3_r15 N_3_M3_g x_PM_SDFFS_X2%3_27 49.92
R_x_PM_SDFFS_X2%3_r16 x_PM_SDFFS_X2%3_VSS x_PM_SDFFS_X2%3_25 4.7687
R_x_PM_SDFFS_X2%3_r17 N_3_M25_g x_PM_SDFFS_X2%3_VSS 74.1
C_x_PM_SDFFS_X2%SE_c0 VSS x_PM_SDFFS_X2%SE_25 8.65542e-18
C_x_PM_SDFFS_X2%SE_c1 VSS SE 9.84829e-17
C_x_PM_SDFFS_X2%SE_c2 VSS x_PM_SDFFS_X2%SE_19 6.52967e-18
C_x_PM_SDFFS_X2%SE_c3 VSS N_SE_M2_g 7.53232e-17
C_x_PM_SDFFS_X2%SE_c4 VSS N_SE_M24_g 4.40829e-17
C_x_PM_SDFFS_X2%SE_c5 VSS x_PM_SDFFS_X2%SE_9 2.88622e-17
C_x_PM_SDFFS_X2%SE_c6 VSS N_SE_M0_g 7.55697e-17
C_x_PM_SDFFS_X2%SE_c7 VSS N_SE_M22_g 4.6793e-17
R_x_PM_SDFFS_X2%SE_r8 x_PM_SDFFS_X2%SE_25 x_PM_SDFFS_X2%SE_23 25.0012
R_x_PM_SDFFS_X2%SE_r9 x_PM_SDFFS_X2%SE_23 SE 0.5415
R_x_PM_SDFFS_X2%SE_r10 x_PM_SDFFS_X2%SE_19 x_PM_SDFFS_X2%SE_15 4.56151
R_x_PM_SDFFS_X2%SE_r11 N_SE_M2_g x_PM_SDFFS_X2%SE_15 78.78
R_x_PM_SDFFS_X2%SE_r12 x_PM_SDFFS_X2%SE_19 x_PM_SDFFS_X2%SE_11 4.56151
R_x_PM_SDFFS_X2%SE_r13 N_SE_M24_g x_PM_SDFFS_X2%SE_11 45.24
R_x_PM_SDFFS_X2%SE_r14 x_PM_SDFFS_X2%SE_25 x_PM_SDFFS_X2%SE_10 0.043368
R_x_PM_SDFFS_X2%SE_r15 x_PM_SDFFS_X2%SE_19 x_PM_SDFFS_X2%SE_9 0.043368
R_x_PM_SDFFS_X2%SE_r16 x_PM_SDFFS_X2%SE_10 x_PM_SDFFS_X2%SE_9 31.72
R_x_PM_SDFFS_X2%SE_r17 x_PM_SDFFS_X2%SE_25 x_PM_SDFFS_X2%SE_5 4.56151
R_x_PM_SDFFS_X2%SE_r18 N_SE_M0_g x_PM_SDFFS_X2%SE_5 78.78
R_x_PM_SDFFS_X2%SE_r19 x_PM_SDFFS_X2%SE_25 x_PM_SDFFS_X2%SE_VSS 4.56151
R_x_PM_SDFFS_X2%SE_r20 N_SE_M22_g x_PM_SDFFS_X2%SE_VSS 45.24
C_x_PM_SDFFS_X2%D_c0 VSS x_PM_SDFFS_X2%D_18 1.05115e-17
C_x_PM_SDFFS_X2%D_c1 VSS x_PM_SDFFS_X2%D_16 5.67964e-17
C_x_PM_SDFFS_X2%D_c2 VSS x_PM_SDFFS_X2%D_14 1.05732e-17
C_x_PM_SDFFS_X2%D_c3 VSS x_PM_SDFFS_X2%D_12 1.18855e-16
C_x_PM_SDFFS_X2%D_c4 VSS x_PM_SDFFS_X2%D_9 1.60196e-16
C_x_PM_SDFFS_X2%D_c5 VSS N_D_M26_g 3.86329e-17
C_x_PM_SDFFS_X2%D_c6 VSS N_D_M1_g 3.63076e-17
R_x_PM_SDFFS_X2%D_r7 D x_PM_SDFFS_X2%D_20 0.267407
R_x_PM_SDFFS_X2%D_r8 x_PM_SDFFS_X2%D_26 x_PM_SDFFS_X2%D_18 4.7687
R_x_PM_SDFFS_X2%D_r9 x_PM_SDFFS_X2%D_18 x_PM_SDFFS_X2%D_16 25.0012
R_x_PM_SDFFS_X2%D_r10 x_PM_SDFFS_X2%D_20 x_PM_SDFFS_X2%D_16 0.00703704
R_x_PM_SDFFS_X2%D_r11 x_PM_SDFFS_X2%D_28 x_PM_SDFFS_X2%D_14 4.7687
R_x_PM_SDFFS_X2%D_r12 x_PM_SDFFS_X2%D_14 x_PM_SDFFS_X2%D_12 25.0012
R_x_PM_SDFFS_X2%D_r13 x_PM_SDFFS_X2%D_12 x_PM_SDFFS_X2%D_11 1.995
R_x_PM_SDFFS_X2%D_r14 x_PM_SDFFS_X2%D_20 x_PM_SDFFS_X2%D_10 0.095
R_x_PM_SDFFS_X2%D_r15 x_PM_SDFFS_X2%D_11 x_PM_SDFFS_X2%D_9 0.212317
R_x_PM_SDFFS_X2%D_r16 x_PM_SDFFS_X2%D_10 x_PM_SDFFS_X2%D_9 2.28
R_x_PM_SDFFS_X2%D_r17 N_D_M26_g x_PM_SDFFS_X2%D_28 32.76
R_x_PM_SDFFS_X2%D_r18 N_D_M1_g x_PM_SDFFS_X2%D_26 28.86
C_x_PM_SDFFS_X2%SI_c0 VSS SI 4.25752e-17
C_x_PM_SDFFS_X2%SI_c1 VSS x_PM_SDFFS_X2%SI_17 1.21995e-17
C_x_PM_SDFFS_X2%SI_c2 VSS x_PM_SDFFS_X2%SI_14 5.27934e-17
C_x_PM_SDFFS_X2%SI_c3 VSS x_PM_SDFFS_X2%SI_12 7.00738e-18
C_x_PM_SDFFS_X2%SI_c4 VSS x_PM_SDFFS_X2%SI_11 2.0915e-17
C_x_PM_SDFFS_X2%SI_c5 VSS N_SI_M4_g 7.80931e-17
C_x_PM_SDFFS_X2%SI_c6 VSS x_PM_SDFFS_X2%SI_6 5.91176e-18
C_x_PM_SDFFS_X2%SI_c7 VSS x_PM_SDFFS_X2%SI_5 9.60993e-17
C_x_PM_SDFFS_X2%SI_c8 VSS N_SI_M23_g 3.423e-17
R_x_PM_SDFFS_X2%SI_r9 x_PM_SDFFS_X2%SI_23 x_PM_SDFFS_X2%SI_17 4.7687
R_x_PM_SDFFS_X2%SI_r10 x_PM_SDFFS_X2%SI_17 x_PM_SDFFS_X2%SI_15 25.0012
R_x_PM_SDFFS_X2%SI_r11 SI x_PM_SDFFS_X2%SI_15 0.15069
R_x_PM_SDFFS_X2%SI_r12 x_PM_SDFFS_X2%SI_14 x_PM_SDFFS_X2%SI_13 89.7
R_x_PM_SDFFS_X2%SI_r13 x_PM_SDFFS_X2%SI_14 x_PM_SDFFS_X2%SI_11 4.35808
R_x_PM_SDFFS_X2%SI_r14 x_PM_SDFFS_X2%SI_12 x_PM_SDFFS_X2%SI_11 20.28
R_x_PM_SDFFS_X2%SI_r15 x_PM_SDFFS_X2%SI_12 x_PM_SDFFS_X2%SI_7 4.35808
R_x_PM_SDFFS_X2%SI_r16 N_SI_M4_g x_PM_SDFFS_X2%SI_7 71.76
R_x_PM_SDFFS_X2%SI_r17 x_PM_SDFFS_X2%SI_13 x_PM_SDFFS_X2%SI_5 4.35808
R_x_PM_SDFFS_X2%SI_r18 x_PM_SDFFS_X2%SI_6 x_PM_SDFFS_X2%SI_5 113.1
R_x_PM_SDFFS_X2%SI_r19 N_SI_M23_g x_PM_SDFFS_X2%SI_23 21.84
R_x_PM_SDFFS_X2%SI_r20 x_PM_SDFFS_X2%SI_6 x_PM_SDFFS_X2%SI_VSS 4.35808
R_x_PM_SDFFS_X2%SI_r21 N_SI_M23_g x_PM_SDFFS_X2%SI_VSS 33.54
C_x_PM_SDFFS_X2%7_c0 VSS x_PM_SDFFS_X2%7_40 1.03212e-17
C_x_PM_SDFFS_X2%7_c1 VSS x_PM_SDFFS_X2%7_39 9.42476e-18
C_x_PM_SDFFS_X2%7_c2 VSS x_PM_SDFFS_X2%7_32 1.2187e-16
C_x_PM_SDFFS_X2%7_c3 VSS x_PM_SDFFS_X2%7_30 2.09115e-17
C_x_PM_SDFFS_X2%7_c4 VSS x_PM_SDFFS_X2%7_29 4.38966e-18
C_x_PM_SDFFS_X2%7_c5 VSS x_PM_SDFFS_X2%7_26 2.24026e-17
C_x_PM_SDFFS_X2%7_c6 VSS x_PM_SDFFS_X2%7_25 1.59356e-16
C_x_PM_SDFFS_X2%7_c7 VSS x_PM_SDFFS_X2%7_23 1.79403e-17
C_x_PM_SDFFS_X2%7_c8 VSS x_PM_SDFFS_X2%7_22 7.62718e-17
C_x_PM_SDFFS_X2%7_c9 VSS x_PM_SDFFS_X2%7_18 9.66591e-17
C_x_PM_SDFFS_X2%7_c10 VSS x_PM_SDFFS_X2%7_14 1.37447e-17
C_x_PM_SDFFS_X2%7_c11 VSS N_7_M29_g 3.36019e-17
C_x_PM_SDFFS_X2%7_c12 VSS N_7_M7_g 7.91895e-17
C_x_PM_SDFFS_X2%7_c13 VSS x_PM_SDFFS_X2%7_2 8.36035e-18
C_x_PM_SDFFS_X2%7_c14 VSS x_PM_SDFFS_X2%7_VSS 2.47957e-17
R_x_PM_SDFFS_X2%7_r15 x_PM_SDFFS_X2%7_40 x_PM_SDFFS_X2%7_32 25.0012
R_x_PM_SDFFS_X2%7_r16 x_PM_SDFFS_X2%7_32 x_PM_SDFFS_X2%7_30 1.805
R_x_PM_SDFFS_X2%7_r17 x_PM_SDFFS_X2%7_30 x_PM_SDFFS_X2%7_29 0.212317
R_x_PM_SDFFS_X2%7_r18 x_PM_SDFFS_X2%7_29 x_PM_SDFFS_X2%7_28 0.298571
R_x_PM_SDFFS_X2%7_r19 x_PM_SDFFS_X2%7_39 x_PM_SDFFS_X2%7_27 0.160909
R_x_PM_SDFFS_X2%7_r20 x_PM_SDFFS_X2%7_28 x_PM_SDFFS_X2%7_26 0.212317
R_x_PM_SDFFS_X2%7_r21 x_PM_SDFFS_X2%7_27 x_PM_SDFFS_X2%7_26 0.488571
R_x_PM_SDFFS_X2%7_r22 x_PM_SDFFS_X2%7_39 x_PM_SDFFS_X2%7_25 0.0418175
R_x_PM_SDFFS_X2%7_r23 x_PM_SDFFS_X2%7_25 x_PM_SDFFS_X2%7_24 3.44714
R_x_PM_SDFFS_X2%7_r24 x_PM_SDFFS_X2%7_23 N_7_M24_d 0.297071
R_x_PM_SDFFS_X2%7_r25 x_PM_SDFFS_X2%7_24 x_PM_SDFFS_X2%7_22 0.212317
R_x_PM_SDFFS_X2%7_r26 x_PM_SDFFS_X2%7_23 x_PM_SDFFS_X2%7_22 1.65571
R_x_PM_SDFFS_X2%7_r27 x_PM_SDFFS_X2%7_39 x_PM_SDFFS_X2%7_18 0.160909
R_x_PM_SDFFS_X2%7_r28 N_7_M2_d x_PM_SDFFS_X2%7_18 1.88643
R_x_PM_SDFFS_X2%7_r29 x_PM_SDFFS_X2%7_14 x_PM_SDFFS_X2%7_12 10.92
R_x_PM_SDFFS_X2%7_r30 x_PM_SDFFS_X2%7_40 x_PM_SDFFS_X2%7_11 9.62
R_x_PM_SDFFS_X2%7_r31 x_PM_SDFFS_X2%7_14 x_PM_SDFFS_X2%7_7 1.95
R_x_PM_SDFFS_X2%7_r32 N_7_M29_g x_PM_SDFFS_X2%7_7 21.84
R_x_PM_SDFFS_X2%7_r33 N_7_M7_g x_PM_SDFFS_X2%7_4 21.84
R_x_PM_SDFFS_X2%7_r34 x_PM_SDFFS_X2%7_12 x_PM_SDFFS_X2%7_3 1.95
R_x_PM_SDFFS_X2%7_r35 N_7_M7_g x_PM_SDFFS_X2%7_3 105.3
R_x_PM_SDFFS_X2%7_r36 x_PM_SDFFS_X2%7_11 x_PM_SDFFS_X2%7_2 4.58872
R_x_PM_SDFFS_X2%7_r37 x_PM_SDFFS_X2%7_4 x_PM_SDFFS_X2%7_VSS 4.35808
R_x_PM_SDFFS_X2%7_r38 x_PM_SDFFS_X2%7_2 x_PM_SDFFS_X2%7_VSS 30.42
C_x_PM_SDFFS_X2%8_c0 VSS x_PM_SDFFS_X2%8_74 1.78257e-17
C_x_PM_SDFFS_X2%8_c1 VSS x_PM_SDFFS_X2%8_67 9.40697e-18
C_x_PM_SDFFS_X2%8_c2 VSS N_8_M5_s 3.32686e-17
C_x_PM_SDFFS_X2%8_c3 VSS x_PM_SDFFS_X2%8_59 1.4256e-17
C_x_PM_SDFFS_X2%8_c4 VSS x_PM_SDFFS_X2%8_56 1.06795e-16
C_x_PM_SDFFS_X2%8_c5 VSS x_PM_SDFFS_X2%8_52 1.00811e-17
C_x_PM_SDFFS_X2%8_c6 VSS x_PM_SDFFS_X2%8_49 3.12505e-17
C_x_PM_SDFFS_X2%8_c7 VSS x_PM_SDFFS_X2%8_46 4.49418e-17
C_x_PM_SDFFS_X2%8_c8 VSS x_PM_SDFFS_X2%8_43 6.268e-17
C_x_PM_SDFFS_X2%8_c9 VSS x_PM_SDFFS_X2%8_41 3.3334e-17
C_x_PM_SDFFS_X2%8_c10 VSS x_PM_SDFFS_X2%8_37 4.45541e-18
C_x_PM_SDFFS_X2%8_c11 VSS N_8_M37_g 3.76816e-17
C_x_PM_SDFFS_X2%8_c12 VSS x_PM_SDFFS_X2%8_32 6.4995e-18
C_x_PM_SDFFS_X2%8_c13 VSS x_PM_SDFFS_X2%8_31 2.39578e-17
C_x_PM_SDFFS_X2%8_c14 VSS N_8_M15_g 5.55831e-17
C_x_PM_SDFFS_X2%8_c15 VSS x_PM_SDFFS_X2%8_25 7.58918e-17
C_x_PM_SDFFS_X2%8_c16 VSS N_8_M12_g 6.12068e-17
C_x_PM_SDFFS_X2%8_c17 VSS x_PM_SDFFS_X2%8_20 6.46286e-18
C_x_PM_SDFFS_X2%8_c18 VSS x_PM_SDFFS_X2%8_19 5.99742e-17
C_x_PM_SDFFS_X2%8_c19 VSS N_8_M9_g 4.55506e-17
C_x_PM_SDFFS_X2%8_c20 VSS N_8_M30_g 3.31447e-17
C_x_PM_SDFFS_X2%8_c21 VSS x_PM_SDFFS_X2%8_10 6.62418e-18
C_x_PM_SDFFS_X2%8_c22 VSS x_PM_SDFFS_X2%8_9 7.1135e-17
C_x_PM_SDFFS_X2%8_c23 VSS N_8_M6_g 5.48982e-17
C_x_PM_SDFFS_X2%8_c24 VSS N_8_M28_g 3.33844e-17
R_x_PM_SDFFS_X2%8_r25 x_PM_SDFFS_X2%8_74 x_PM_SDFFS_X2%8_72 5.46
R_x_PM_SDFFS_X2%8_r26 x_PM_SDFFS_X2%8_67 x_PM_SDFFS_X2%8_66 1.56
R_x_PM_SDFFS_X2%8_r27 x_PM_SDFFS_X2%8_66 x_PM_SDFFS_X2%8_64 1.3
R_x_PM_SDFFS_X2%8_r28 x_PM_SDFFS_X2%8_72 x_PM_SDFFS_X2%8_56 25.0012
R_x_PM_SDFFS_X2%8_r29 x_PM_SDFFS_X2%8_56 x_PM_SDFFS_X2%8_54 1.69643
R_x_PM_SDFFS_X2%8_r30 x_PM_SDFFS_X2%8_70 x_PM_SDFFS_X2%8_52 4.7687
R_x_PM_SDFFS_X2%8_r31 x_PM_SDFFS_X2%8_52 x_PM_SDFFS_X2%8_50 25.0012
R_x_PM_SDFFS_X2%8_r32 x_PM_SDFFS_X2%8_54 x_PM_SDFFS_X2%8_49 0.212317
R_x_PM_SDFFS_X2%8_r33 x_PM_SDFFS_X2%8_50 x_PM_SDFFS_X2%8_49 0.230714
R_x_PM_SDFFS_X2%8_r34 x_PM_SDFFS_X2%8_64 x_PM_SDFFS_X2%8_46 25.0012
R_x_PM_SDFFS_X2%8_r35 x_PM_SDFFS_X2%8_59 x_PM_SDFFS_X2%8_44 0.0855182
R_x_PM_SDFFS_X2%8_r36 x_PM_SDFFS_X2%8_46 x_PM_SDFFS_X2%8_44 1.09929
R_x_PM_SDFFS_X2%8_r37 x_PM_SDFFS_X2%8_43 N_8_M5_s 0.29113
R_x_PM_SDFFS_X2%8_r38 x_PM_SDFFS_X2%8_59 x_PM_SDFFS_X2%8_42 0.115915
R_x_PM_SDFFS_X2%8_r39 x_PM_SDFFS_X2%8_43 x_PM_SDFFS_X2%8_42 1.68286
R_x_PM_SDFFS_X2%8_r40 x_PM_SDFFS_X2%8_59 x_PM_SDFFS_X2%8_41 0.115915
R_x_PM_SDFFS_X2%8_r41 x_PM_SDFFS_X2%8_41 N_8_M27_s 0.305065
R_x_PM_SDFFS_X2%8_r42 N_8_M37_g x_PM_SDFFS_X2%8_33 35.88
R_x_PM_SDFFS_X2%8_r43 x_PM_SDFFS_X2%8_33 x_PM_SDFFS_X2%8_31 4.35808
R_x_PM_SDFFS_X2%8_r44 x_PM_SDFFS_X2%8_32 x_PM_SDFFS_X2%8_31 20.28
R_x_PM_SDFFS_X2%8_r45 N_8_M15_g x_PM_SDFFS_X2%8_28 40.56
R_x_PM_SDFFS_X2%8_r46 x_PM_SDFFS_X2%8_32 x_PM_SDFFS_X2%8_27 4.35808
R_x_PM_SDFFS_X2%8_r47 N_8_M15_g x_PM_SDFFS_X2%8_27 52.26
R_x_PM_SDFFS_X2%8_r48 x_PM_SDFFS_X2%8_37 x_PM_SDFFS_X2%8_26 3.30287
R_x_PM_SDFFS_X2%8_r49 x_PM_SDFFS_X2%8_28 x_PM_SDFFS_X2%8_25 4.35808
R_x_PM_SDFFS_X2%8_r50 x_PM_SDFFS_X2%8_26 x_PM_SDFFS_X2%8_25 93.6
R_x_PM_SDFFS_X2%8_r51 x_PM_SDFFS_X2%8_37 x_PM_SDFFS_X2%8_21 0.858359
R_x_PM_SDFFS_X2%8_r52 N_8_M12_g x_PM_SDFFS_X2%8_21 49.92
R_x_PM_SDFFS_X2%8_r53 x_PM_SDFFS_X2%8_37 x_PM_SDFFS_X2%8_19 3.30287
R_x_PM_SDFFS_X2%8_r54 x_PM_SDFFS_X2%8_20 x_PM_SDFFS_X2%8_19 81.9
R_x_PM_SDFFS_X2%8_r55 x_PM_SDFFS_X2%8_20 x_PM_SDFFS_X2%8_16 4.35808
R_x_PM_SDFFS_X2%8_r56 N_8_M9_g x_PM_SDFFS_X2%8_16 28.86
R_x_PM_SDFFS_X2%8_r57 x_PM_SDFFS_X2%8_74 x_PM_SDFFS_X2%8_15 1.95
R_x_PM_SDFFS_X2%8_r58 N_8_M9_g x_PM_SDFFS_X2%8_15 39.78
R_x_PM_SDFFS_X2%8_r59 N_8_M30_g x_PM_SDFFS_X2%8_70 21.84
R_x_PM_SDFFS_X2%8_r60 N_8_M30_g x_PM_SDFFS_X2%8_11 33.54
R_x_PM_SDFFS_X2%8_r61 x_PM_SDFFS_X2%8_11 x_PM_SDFFS_X2%8_9 4.35808
R_x_PM_SDFFS_X2%8_r62 x_PM_SDFFS_X2%8_10 x_PM_SDFFS_X2%8_9 81.12
R_x_PM_SDFFS_X2%8_r63 x_PM_SDFFS_X2%8_67 x_PM_SDFFS_X2%8_5 1.95
R_x_PM_SDFFS_X2%8_r64 N_8_M6_g x_PM_SDFFS_X2%8_5 67.08
R_x_PM_SDFFS_X2%8_r65 x_PM_SDFFS_X2%8_66 x_PM_SDFFS_X2%8_2 1.95
R_x_PM_SDFFS_X2%8_r66 N_8_M28_g x_PM_SDFFS_X2%8_2 28.08
R_x_PM_SDFFS_X2%8_r67 x_PM_SDFFS_X2%8_10 x_PM_SDFFS_X2%8_VSS 4.35808
R_x_PM_SDFFS_X2%8_r68 N_8_M28_g x_PM_SDFFS_X2%8_VSS 21.84
C_x_PM_SDFFS_X2%CK_c0 VSS CK 4.46865e-17
C_x_PM_SDFFS_X2%CK_c1 VSS x_PM_SDFFS_X2%CK_11 8.56287e-18
C_x_PM_SDFFS_X2%CK_c2 VSS N_CK_M5_g 5.40757e-17
C_x_PM_SDFFS_X2%CK_c3 VSS N_CK_M27_g 5.39258e-17
R_x_PM_SDFFS_X2%CK_r4 x_PM_SDFFS_X2%CK_18 x_PM_SDFFS_X2%CK_11 4.7687
R_x_PM_SDFFS_X2%CK_r5 x_PM_SDFFS_X2%CK_17 x_PM_SDFFS_X2%CK_11 4.7687
R_x_PM_SDFFS_X2%CK_r6 x_PM_SDFFS_X2%CK_11 x_PM_SDFFS_X2%CK_9 25.0012
R_x_PM_SDFFS_X2%CK_r7 CK x_PM_SDFFS_X2%CK_9 0.0746429
R_x_PM_SDFFS_X2%CK_r8 N_CK_M5_g x_PM_SDFFS_X2%CK_18 46.02
R_x_PM_SDFFS_X2%CK_r9 N_CK_M27_g x_PM_SDFFS_X2%CK_17 56.16
C_x_PM_SDFFS_X2%10_c0 VSS x_PM_SDFFS_X2%10_63 1.93294e-17
C_x_PM_SDFFS_X2%10_c1 VSS x_PM_SDFFS_X2%10_58 9.48089e-18
C_x_PM_SDFFS_X2%10_c2 VSS x_PM_SDFFS_X2%10_54 4.68028e-18
C_x_PM_SDFFS_X2%10_c3 VSS x_PM_SDFFS_X2%10_52 3.07906e-17
C_x_PM_SDFFS_X2%10_c4 VSS x_PM_SDFFS_X2%10_47 4.29565e-17
C_x_PM_SDFFS_X2%10_c5 VSS x_PM_SDFFS_X2%10_40 7.70008e-17
C_x_PM_SDFFS_X2%10_c6 VSS x_PM_SDFFS_X2%10_38 5.79751e-18
C_x_PM_SDFFS_X2%10_c7 VSS x_PM_SDFFS_X2%10_37 5.7949e-17
C_x_PM_SDFFS_X2%10_c8 VSS x_PM_SDFFS_X2%10_34 3.20508e-17
C_x_PM_SDFFS_X2%10_c9 VSS x_PM_SDFFS_X2%10_29 4.17152e-17
C_x_PM_SDFFS_X2%10_c10 VSS x_PM_SDFFS_X2%10_26 6.66275e-18
C_x_PM_SDFFS_X2%10_c11 VSS x_PM_SDFFS_X2%10_24 3.38473e-17
C_x_PM_SDFFS_X2%10_c12 VSS N_10_M16_g 3.99031e-17
C_x_PM_SDFFS_X2%10_c13 VSS N_10_M36_g 3.43903e-17
C_x_PM_SDFFS_X2%10_c14 VSS x_PM_SDFFS_X2%10_12 6.60929e-18
C_x_PM_SDFFS_X2%10_c15 VSS x_PM_SDFFS_X2%10_11 1.39555e-16
C_x_PM_SDFFS_X2%10_c16 VSS N_10_M31_g 6.47067e-17
C_x_PM_SDFFS_X2%10_c17 VSS x_PM_SDFFS_X2%10_6 8.74331e-18
C_x_PM_SDFFS_X2%10_c18 VSS x_PM_SDFFS_X2%10_5 3.81252e-17
C_x_PM_SDFFS_X2%10_c19 VSS N_10_M8_g 6.11987e-17
R_x_PM_SDFFS_X2%10_r20 x_PM_SDFFS_X2%10_57 x_PM_SDFFS_X2%10_55 3.38
R_x_PM_SDFFS_X2%10_r21 x_PM_SDFFS_X2%10_52 N_10_M6_d 0.133704
R_x_PM_SDFFS_X2%10_r22 x_PM_SDFFS_X2%10_47 N_10_M28_d 0.175926
R_x_PM_SDFFS_X2%10_r23 x_PM_SDFFS_X2%10_63 x_PM_SDFFS_X2%10_42 7.02
R_x_PM_SDFFS_X2%10_r24 x_PM_SDFFS_X2%10_42 x_PM_SDFFS_X2%10_40 25.0012
R_x_PM_SDFFS_X2%10_r25 x_PM_SDFFS_X2%10_40 x_PM_SDFFS_X2%10_39 1.15357
R_x_PM_SDFFS_X2%10_r26 x_PM_SDFFS_X2%10_39 x_PM_SDFFS_X2%10_37 0.212317
R_x_PM_SDFFS_X2%10_r27 x_PM_SDFFS_X2%10_38 x_PM_SDFFS_X2%10_37 0.787143
R_x_PM_SDFFS_X2%10_r28 x_PM_SDFFS_X2%10_58 x_PM_SDFFS_X2%10_34 25.0012
R_x_PM_SDFFS_X2%10_r29 x_PM_SDFFS_X2%10_38 x_PM_SDFFS_X2%10_32 0.212317
R_x_PM_SDFFS_X2%10_r30 x_PM_SDFFS_X2%10_34 x_PM_SDFFS_X2%10_32 0.366429
R_x_PM_SDFFS_X2%10_r31 x_PM_SDFFS_X2%10_55 x_PM_SDFFS_X2%10_29 25.0012
R_x_PM_SDFFS_X2%10_r32 x_PM_SDFFS_X2%10_54 x_PM_SDFFS_X2%10_27 0.0418175
R_x_PM_SDFFS_X2%10_r33 x_PM_SDFFS_X2%10_29 x_PM_SDFFS_X2%10_27 1.50643
R_x_PM_SDFFS_X2%10_r34 x_PM_SDFFS_X2%10_52 x_PM_SDFFS_X2%10_26 0.095
R_x_PM_SDFFS_X2%10_r35 x_PM_SDFFS_X2%10_54 x_PM_SDFFS_X2%10_25 0.160909
R_x_PM_SDFFS_X2%10_r36 x_PM_SDFFS_X2%10_26 x_PM_SDFFS_X2%10_25 0.434286
R_x_PM_SDFFS_X2%10_r37 x_PM_SDFFS_X2%10_54 x_PM_SDFFS_X2%10_24 0.160909
R_x_PM_SDFFS_X2%10_r38 x_PM_SDFFS_X2%10_47 x_PM_SDFFS_X2%10_23 0.095
R_x_PM_SDFFS_X2%10_r39 x_PM_SDFFS_X2%10_24 x_PM_SDFFS_X2%10_23 1.60143
R_x_PM_SDFFS_X2%10_r40 x_PM_SDFFS_X2%10_63 x_PM_SDFFS_X2%10_17 1.95
R_x_PM_SDFFS_X2%10_r41 N_10_M16_g x_PM_SDFFS_X2%10_17 42.9
R_x_PM_SDFFS_X2%10_r42 x_PM_SDFFS_X2%10_14 x_PM_SDFFS_X2%10_58 4.7687
R_x_PM_SDFFS_X2%10_r43 N_10_M36_g x_PM_SDFFS_X2%10_14 28.08
R_x_PM_SDFFS_X2%10_r44 N_10_M36_g x_PM_SDFFS_X2%10_13 26.52
R_x_PM_SDFFS_X2%10_r45 x_PM_SDFFS_X2%10_13 x_PM_SDFFS_X2%10_11 4.35808
R_x_PM_SDFFS_X2%10_r46 x_PM_SDFFS_X2%10_12 x_PM_SDFFS_X2%10_11 162.24
R_x_PM_SDFFS_X2%10_r47 N_10_M31_g x_PM_SDFFS_X2%10_8 60.06
R_x_PM_SDFFS_X2%10_r48 x_PM_SDFFS_X2%10_12 x_PM_SDFFS_X2%10_7 4.35808
R_x_PM_SDFFS_X2%10_r49 N_10_M31_g x_PM_SDFFS_X2%10_7 26.52
R_x_PM_SDFFS_X2%10_r50 x_PM_SDFFS_X2%10_57 x_PM_SDFFS_X2%10_6 2.6
R_x_PM_SDFFS_X2%10_r51 x_PM_SDFFS_X2%10_8 x_PM_SDFFS_X2%10_5 4.58872
R_x_PM_SDFFS_X2%10_r52 x_PM_SDFFS_X2%10_6 x_PM_SDFFS_X2%10_5 21.84
R_x_PM_SDFFS_X2%10_r53 x_PM_SDFFS_X2%10_57 x_PM_SDFFS_X2%10_VSS 1.95
R_x_PM_SDFFS_X2%10_r54 N_10_M8_g x_PM_SDFFS_X2%10_VSS 70.2
C_x_PM_SDFFS_X2%11_c0 VSS x_PM_SDFFS_X2%11_53 8.8406e-18
C_x_PM_SDFFS_X2%11_c1 VSS x_PM_SDFFS_X2%11_51 1.39638e-17
C_x_PM_SDFFS_X2%11_c2 VSS x_PM_SDFFS_X2%11_49 3.44156e-17
C_x_PM_SDFFS_X2%11_c3 VSS x_PM_SDFFS_X2%11_48 3.78811e-18
C_x_PM_SDFFS_X2%11_c4 VSS x_PM_SDFFS_X2%11_45 8.1671e-18
C_x_PM_SDFFS_X2%11_c5 VSS x_PM_SDFFS_X2%11_43 1.76141e-18
C_x_PM_SDFFS_X2%11_c6 VSS x_PM_SDFFS_X2%11_42 7.0081e-18
C_x_PM_SDFFS_X2%11_c7 VSS x_PM_SDFFS_X2%11_40 7.01333e-18
C_x_PM_SDFFS_X2%11_c8 VSS x_PM_SDFFS_X2%11_35 7.17833e-17
C_x_PM_SDFFS_X2%11_c9 VSS x_PM_SDFFS_X2%11_34 1.30521e-16
C_x_PM_SDFFS_X2%11_c10 VSS x_PM_SDFFS_X2%11_32 1.37361e-17
C_x_PM_SDFFS_X2%11_c11 VSS x_PM_SDFFS_X2%11_31 1.46694e-17
C_x_PM_SDFFS_X2%11_c12 VSS x_PM_SDFFS_X2%11_27 3.20684e-17
C_x_PM_SDFFS_X2%11_c13 VSS N_11_M8_d 2.08334e-17
C_x_PM_SDFFS_X2%11_c14 VSS x_PM_SDFFS_X2%11_19 2.85041e-18
C_x_PM_SDFFS_X2%11_c15 VSS N_11_M14_g 3.88154e-17
C_x_PM_SDFFS_X2%11_c16 VSS x_PM_SDFFS_X2%11_14 3.52772e-17
C_x_PM_SDFFS_X2%11_c17 VSS N_11_M35_g 2.38766e-17
C_x_PM_SDFFS_X2%11_c18 VSS x_PM_SDFFS_X2%11_VSS 3.69363e-17
R_x_PM_SDFFS_X2%11_r19 x_PM_SDFFS_X2%11_53 x_PM_SDFFS_X2%11_52 1.3
R_x_PM_SDFFS_X2%11_r20 x_PM_SDFFS_X2%11_52 x_PM_SDFFS_X2%11_50 5.46
R_x_PM_SDFFS_X2%11_r21 x_PM_SDFFS_X2%11_51 x_PM_SDFFS_X2%11_50 3.4687
R_x_PM_SDFFS_X2%11_r22 x_PM_SDFFS_X2%11_52 x_PM_SDFFS_X2%11_45 25.0012
R_x_PM_SDFFS_X2%11_r23 x_PM_SDFFS_X2%11_49 x_PM_SDFFS_X2%11_43 0.202958
R_x_PM_SDFFS_X2%11_r24 x_PM_SDFFS_X2%11_45 x_PM_SDFFS_X2%11_43 0.111765
R_x_PM_SDFFS_X2%11_r25 x_PM_SDFFS_X2%11_42 x_PM_SDFFS_X2%11_49 1.08571
R_x_PM_SDFFS_X2%11_r26 x_PM_SDFFS_X2%11_42 x_PM_SDFFS_X2%11_39 0.212317
R_x_PM_SDFFS_X2%11_r27 x_PM_SDFFS_X2%11_40 x_PM_SDFFS_X2%11_39 0.624286
R_x_PM_SDFFS_X2%11_r28 x_PM_SDFFS_X2%11_48 x_PM_SDFFS_X2%11_36 0.160909
R_x_PM_SDFFS_X2%11_r29 N_11_M12_d x_PM_SDFFS_X2%11_36 2.99929
R_x_PM_SDFFS_X2%11_r30 x_PM_SDFFS_X2%11_40 x_PM_SDFFS_X2%11_35 0.212317
R_x_PM_SDFFS_X2%11_r31 N_11_M12_d x_PM_SDFFS_X2%11_35 0.095
R_x_PM_SDFFS_X2%11_r32 x_PM_SDFFS_X2%11_48 x_PM_SDFFS_X2%11_34 0.0418175
R_x_PM_SDFFS_X2%11_r33 x_PM_SDFFS_X2%11_34 x_PM_SDFFS_X2%11_33 3.58286
R_x_PM_SDFFS_X2%11_r34 x_PM_SDFFS_X2%11_48 x_PM_SDFFS_X2%11_31 0.160909
R_x_PM_SDFFS_X2%11_r35 x_PM_SDFFS_X2%11_32 x_PM_SDFFS_X2%11_31 0.542857
R_x_PM_SDFFS_X2%11_r36 x_PM_SDFFS_X2%11_33 x_PM_SDFFS_X2%11_27 0.212317
R_x_PM_SDFFS_X2%11_r37 N_11_M30_d x_PM_SDFFS_X2%11_27 0.366429
R_x_PM_SDFFS_X2%11_r38 x_PM_SDFFS_X2%11_32 x_PM_SDFFS_X2%11_23 0.212317
R_x_PM_SDFFS_X2%11_r39 N_11_M8_d x_PM_SDFFS_X2%11_23 0.447857
R_x_PM_SDFFS_X2%11_r40 x_PM_SDFFS_X2%11_53 x_PM_SDFFS_X2%11_15 1.95
R_x_PM_SDFFS_X2%11_r41 N_11_M14_g x_PM_SDFFS_X2%11_15 33.54
R_x_PM_SDFFS_X2%11_r42 x_PM_SDFFS_X2%11_50 x_PM_SDFFS_X2%11_14 1.95
R_x_PM_SDFFS_X2%11_r43 x_PM_SDFFS_X2%11_19 x_PM_SDFFS_X2%11_13 3.30287
R_x_PM_SDFFS_X2%11_r44 x_PM_SDFFS_X2%11_14 x_PM_SDFFS_X2%11_13 55.38
R_x_PM_SDFFS_X2%11_r45 x_PM_SDFFS_X2%11_19 x_PM_SDFFS_X2%11_9 3.30287
R_x_PM_SDFFS_X2%11_r46 N_11_M35_g x_PM_SDFFS_X2%11_9 14.82
R_x_PM_SDFFS_X2%11_r47 N_11_M13_g x_PM_SDFFS_X2%11_51 14.82
R_x_PM_SDFFS_X2%11_r48 x_PM_SDFFS_X2%11_19 x_PM_SDFFS_X2%11_VSS 0.858359
R_x_PM_SDFFS_X2%11_r49 N_11_M34_g x_PM_SDFFS_X2%11_VSS 28.08
C_x_PM_SDFFS_X2%12_c0 VSS x_PM_SDFFS_X2%12_31 1.42903e-17
C_x_PM_SDFFS_X2%12_c1 VSS N_12_M13_s 3.93746e-17
C_x_PM_SDFFS_X2%12_c2 VSS x_PM_SDFFS_X2%12_17 3.76361e-18
C_x_PM_SDFFS_X2%12_c3 VSS x_PM_SDFFS_X2%12_11 6.6843e-17
C_x_PM_SDFFS_X2%12_c4 VSS N_12_M34_d 3.41318e-17
C_x_PM_SDFFS_X2%12_c5 VSS N_12_M32_g 3.79472e-17
C_x_PM_SDFFS_X2%12_c6 VSS N_12_M10_g 6.75559e-17
R_x_PM_SDFFS_X2%12_r7 N_12_M13_s x_PM_SDFFS_X2%12_23 0.285
R_x_PM_SDFFS_X2%12_r8 x_PM_SDFFS_X2%12_22 x_PM_SDFFS_X2%12_21 0.186267
R_x_PM_SDFFS_X2%12_r9 x_PM_SDFFS_X2%12_23 x_PM_SDFFS_X2%12_17 0.095
R_x_PM_SDFFS_X2%12_r10 x_PM_SDFFS_X2%12_17 x_PM_SDFFS_X2%12_22 0.271429
R_x_PM_SDFFS_X2%12_r11 x_PM_SDFFS_X2%12_31 x_PM_SDFFS_X2%12_14 1.3
R_x_PM_SDFFS_X2%12_r12 x_PM_SDFFS_X2%12_14 x_PM_SDFFS_X2%12_28 5.46
R_x_PM_SDFFS_X2%12_r13 x_PM_SDFFS_X2%12_14 x_PM_SDFFS_X2%12_12 25.0012
R_x_PM_SDFFS_X2%12_r14 x_PM_SDFFS_X2%12_21 x_PM_SDFFS_X2%12_11 0.095
R_x_PM_SDFFS_X2%12_r15 x_PM_SDFFS_X2%12_12 x_PM_SDFFS_X2%12_11 2.40214
R_x_PM_SDFFS_X2%12_r16 x_PM_SDFFS_X2%12_21 N_12_M34_d 0.246296
R_x_PM_SDFFS_X2%12_r17 x_PM_SDFFS_X2%12_31 x_PM_SDFFS_X2%12_5 1.95
R_x_PM_SDFFS_X2%12_r18 N_12_M32_g x_PM_SDFFS_X2%12_5 40.56
R_x_PM_SDFFS_X2%12_r19 x_PM_SDFFS_X2%12_28 x_PM_SDFFS_X2%12_VSS 1.95
R_x_PM_SDFFS_X2%12_r20 N_12_M10_g x_PM_SDFFS_X2%12_VSS 82.68
C_x_PM_SDFFS_X2%SN_c0 VSS x_PM_SDFFS_X2%SN_41 1.10911e-17
C_x_PM_SDFFS_X2%SN_c1 VSS x_PM_SDFFS_X2%SN_36 1.36149e-17
C_x_PM_SDFFS_X2%SN_c2 VSS x_PM_SDFFS_X2%SN_29 3.05043e-17
C_x_PM_SDFFS_X2%SN_c3 VSS x_PM_SDFFS_X2%SN_28 2.22977e-17
C_x_PM_SDFFS_X2%SN_c4 VSS SN 4.19287e-17
C_x_PM_SDFFS_X2%SN_c5 VSS x_PM_SDFFS_X2%SN_23 7.71249e-18
C_x_PM_SDFFS_X2%SN_c6 VSS x_PM_SDFFS_X2%SN_22 2.09356e-16
C_x_PM_SDFFS_X2%SN_c7 VSS x_PM_SDFFS_X2%SN_18 2.04447e-17
C_x_PM_SDFFS_X2%SN_c8 VSS N_SN_M39_g 3.72081e-17
C_x_PM_SDFFS_X2%SN_c9 VSS N_SN_M18_g 6.70529e-17
C_x_PM_SDFFS_X2%SN_c10 VSS N_SN_M33_g 1.87402e-17
C_x_PM_SDFFS_X2%SN_c11 VSS N_SN_M11_g 8.63565e-17
R_x_PM_SDFFS_X2%SN_r12 x_PM_SDFFS_X2%SN_41 x_PM_SDFFS_X2%SN_31 3.38
R_x_PM_SDFFS_X2%SN_r13 x_PM_SDFFS_X2%SN_31 x_PM_SDFFS_X2%SN_38 1.3
R_x_PM_SDFFS_X2%SN_r14 x_PM_SDFFS_X2%SN_31 x_PM_SDFFS_X2%SN_29 25.0012
R_x_PM_SDFFS_X2%SN_r15 x_PM_SDFFS_X2%SN_29 x_PM_SDFFS_X2%SN_28 1.045
R_x_PM_SDFFS_X2%SN_r16 x_PM_SDFFS_X2%SN_28 x_PM_SDFFS_X2%SN_25 0.212317
R_x_PM_SDFFS_X2%SN_r17 SN x_PM_SDFFS_X2%SN_25 0.217143
R_x_PM_SDFFS_X2%SN_r18 SN x_PM_SDFFS_X2%SN_24 0.787143
R_x_PM_SDFFS_X2%SN_r19 x_PM_SDFFS_X2%SN_24 x_PM_SDFFS_X2%SN_22 0.212317
R_x_PM_SDFFS_X2%SN_r20 x_PM_SDFFS_X2%SN_23 x_PM_SDFFS_X2%SN_22 6.08
R_x_PM_SDFFS_X2%SN_r21 x_PM_SDFFS_X2%SN_36 x_PM_SDFFS_X2%SN_20 1.3
R_x_PM_SDFFS_X2%SN_r22 x_PM_SDFFS_X2%SN_20 x_PM_SDFFS_X2%SN_33 5.46
R_x_PM_SDFFS_X2%SN_r23 x_PM_SDFFS_X2%SN_20 x_PM_SDFFS_X2%SN_18 25.0012
R_x_PM_SDFFS_X2%SN_r24 x_PM_SDFFS_X2%SN_23 x_PM_SDFFS_X2%SN_17 0.212317
R_x_PM_SDFFS_X2%SN_r25 x_PM_SDFFS_X2%SN_18 x_PM_SDFFS_X2%SN_17 0.257857
R_x_PM_SDFFS_X2%SN_r26 x_PM_SDFFS_X2%SN_41 x_PM_SDFFS_X2%SN_13 1.95
R_x_PM_SDFFS_X2%SN_r27 N_SN_M39_g x_PM_SDFFS_X2%SN_13 28.86
R_x_PM_SDFFS_X2%SN_r28 x_PM_SDFFS_X2%SN_38 x_PM_SDFFS_X2%SN_9 1.95
R_x_PM_SDFFS_X2%SN_r29 N_SN_M18_g x_PM_SDFFS_X2%SN_9 69.42
R_x_PM_SDFFS_X2%SN_r30 x_PM_SDFFS_X2%SN_36 x_PM_SDFFS_X2%SN_5 1.95
R_x_PM_SDFFS_X2%SN_r31 N_SN_M33_g x_PM_SDFFS_X2%SN_5 14.82
R_x_PM_SDFFS_X2%SN_r32 x_PM_SDFFS_X2%SN_33 x_PM_SDFFS_X2%SN_VSS 1.95
R_x_PM_SDFFS_X2%SN_r33 N_SN_M11_g x_PM_SDFFS_X2%SN_VSS 87.36
C_x_PM_SDFFS_X2%14_c0 VSS x_PM_SDFFS_X2%14_40 1.10573e-17
C_x_PM_SDFFS_X2%14_c1 VSS x_PM_SDFFS_X2%14_36 2.07142e-17
C_x_PM_SDFFS_X2%14_c2 VSS x_PM_SDFFS_X2%14_33 1.29105e-16
C_x_PM_SDFFS_X2%14_c3 VSS x_PM_SDFFS_X2%14_30 2.50424e-17
C_x_PM_SDFFS_X2%14_c4 VSS x_PM_SDFFS_X2%14_28 7.71569e-17
C_x_PM_SDFFS_X2%14_c5 VSS x_PM_SDFFS_X2%14_23 4.17028e-17
C_x_PM_SDFFS_X2%14_c6 VSS x_PM_SDFFS_X2%14_19 1.17636e-16
C_x_PM_SDFFS_X2%14_c7 VSS N_14_M42_g 1.28926e-16
C_x_PM_SDFFS_X2%14_c8 VSS x_PM_SDFFS_X2%14_10 5.20047e-18
C_x_PM_SDFFS_X2%14_c9 VSS x_PM_SDFFS_X2%14_9 6.49595e-17
C_x_PM_SDFFS_X2%14_c10 VSS N_14_M40_g 6.93963e-17
C_x_PM_SDFFS_X2%14_c11 VSS N_14_M19_g 5.00631e-17
R_x_PM_SDFFS_X2%14_r12 x_PM_SDFFS_X2%14_40 x_PM_SDFFS_X2%14_39 3.12
R_x_PM_SDFFS_X2%14_r13 x_PM_SDFFS_X2%14_39 x_PM_SDFFS_X2%14_37 1.3
R_x_PM_SDFFS_X2%14_r14 x_PM_SDFFS_X2%14_37 x_PM_SDFFS_X2%14_33 25.0012
R_x_PM_SDFFS_X2%14_r15 x_PM_SDFFS_X2%14_36 x_PM_SDFFS_X2%14_31 0.0418175
R_x_PM_SDFFS_X2%14_r16 x_PM_SDFFS_X2%14_33 x_PM_SDFFS_X2%14_31 2.755
R_x_PM_SDFFS_X2%14_r17 x_PM_SDFFS_X2%14_36 x_PM_SDFFS_X2%14_29 0.160909
R_x_PM_SDFFS_X2%14_r18 x_PM_SDFFS_X2%14_30 x_PM_SDFFS_X2%14_29 0.597143
R_x_PM_SDFFS_X2%14_r19 x_PM_SDFFS_X2%14_36 x_PM_SDFFS_X2%14_28 0.160909
R_x_PM_SDFFS_X2%14_r20 x_PM_SDFFS_X2%14_28 x_PM_SDFFS_X2%14_27 1.62857
R_x_PM_SDFFS_X2%14_r21 x_PM_SDFFS_X2%14_30 x_PM_SDFFS_X2%14_23 0.212317
R_x_PM_SDFFS_X2%14_r22 N_14_M15_d x_PM_SDFFS_X2%14_23 0.773571
R_x_PM_SDFFS_X2%14_r23 x_PM_SDFFS_X2%14_27 x_PM_SDFFS_X2%14_19 0.212317
R_x_PM_SDFFS_X2%14_r24 N_14_M36_d x_PM_SDFFS_X2%14_19 0.800714
R_x_PM_SDFFS_X2%14_r25 N_14_M21_g N_14_M42_g 124.02
R_x_PM_SDFFS_X2%14_r26 N_14_M21_g x_PM_SDFFS_X2%14_11 40.56
R_x_PM_SDFFS_X2%14_r27 x_PM_SDFFS_X2%14_11 x_PM_SDFFS_X2%14_9 4.35808
R_x_PM_SDFFS_X2%14_r28 x_PM_SDFFS_X2%14_10 x_PM_SDFFS_X2%14_9 83.46
R_x_PM_SDFFS_X2%14_r29 x_PM_SDFFS_X2%14_40 x_PM_SDFFS_X2%14_5 1.95
R_x_PM_SDFFS_X2%14_r30 N_14_M40_g x_PM_SDFFS_X2%14_5 67.08
R_x_PM_SDFFS_X2%14_r31 x_PM_SDFFS_X2%14_10 x_PM_SDFFS_X2%14_2 4.35808
R_x_PM_SDFFS_X2%14_r32 N_14_M19_g x_PM_SDFFS_X2%14_2 26.52
R_x_PM_SDFFS_X2%14_r33 x_PM_SDFFS_X2%14_39 x_PM_SDFFS_X2%14_VSS 1.95
R_x_PM_SDFFS_X2%14_r34 N_14_M19_g x_PM_SDFFS_X2%14_VSS 45.24
C_x_PM_SDFFS_X2%15_c0 VSS x_PM_SDFFS_X2%15_35 8.93455e-17
C_x_PM_SDFFS_X2%15_c1 VSS x_PM_SDFFS_X2%15_32 1.40855e-17
C_x_PM_SDFFS_X2%15_c2 VSS N_15_M40_d 6.23163e-17
C_x_PM_SDFFS_X2%15_c3 VSS x_PM_SDFFS_X2%15_24 8.68536e-18
C_x_PM_SDFFS_X2%15_c4 VSS x_PM_SDFFS_X2%15_21 1.63095e-16
C_x_PM_SDFFS_X2%15_c5 VSS x_PM_SDFFS_X2%15_18 5.00671e-18
C_x_PM_SDFFS_X2%15_c6 VSS x_PM_SDFFS_X2%15_17 2.96655e-17
C_x_PM_SDFFS_X2%15_c7 VSS N_15_M20_g 6.91477e-17
C_x_PM_SDFFS_X2%15_c8 VSS N_15_M41_g 5.1244e-17
C_x_PM_SDFFS_X2%15_c9 VSS N_15_M38_g 6.7856e-17
C_x_PM_SDFFS_X2%15_c10 VSS N_15_M17_g 2.43445e-17
R_x_PM_SDFFS_X2%15_r11 x_PM_SDFFS_X2%15_38 x_PM_SDFFS_X2%15_35 25.0012
R_x_PM_SDFFS_X2%15_r12 x_PM_SDFFS_X2%15_35 x_PM_SDFFS_X2%15_33 1.805
R_x_PM_SDFFS_X2%15_r13 x_PM_SDFFS_X2%15_35 x_PM_SDFFS_X2%15_32 0.393571
R_x_PM_SDFFS_X2%15_r14 x_PM_SDFFS_X2%15_32 x_PM_SDFFS_X2%15_28 0.247769
R_x_PM_SDFFS_X2%15_r15 N_15_M40_d x_PM_SDFFS_X2%15_28 0.0330435
R_x_PM_SDFFS_X2%15_r16 x_PM_SDFFS_X2%15_42 x_PM_SDFFS_X2%15_24 4.7687
R_x_PM_SDFFS_X2%15_r17 x_PM_SDFFS_X2%15_41 x_PM_SDFFS_X2%15_24 4.7687
R_x_PM_SDFFS_X2%15_r18 x_PM_SDFFS_X2%15_24 x_PM_SDFFS_X2%15_22 25.0012
R_x_PM_SDFFS_X2%15_r19 N_15_M18_d x_PM_SDFFS_X2%15_22 1.49286
R_x_PM_SDFFS_X2%15_r20 x_PM_SDFFS_X2%15_33 x_PM_SDFFS_X2%15_21 0.212317
R_x_PM_SDFFS_X2%15_r21 N_15_M18_d x_PM_SDFFS_X2%15_21 1.34357
R_x_PM_SDFFS_X2%15_r22 x_PM_SDFFS_X2%15_38 x_PM_SDFFS_X2%15_17 20.54
R_x_PM_SDFFS_X2%15_r23 x_PM_SDFFS_X2%15_18 x_PM_SDFFS_X2%15_17 0.043368
R_x_PM_SDFFS_X2%15_r24 x_PM_SDFFS_X2%15_18 x_PM_SDFFS_X2%15_13 4.56151
R_x_PM_SDFFS_X2%15_r25 N_15_M20_g x_PM_SDFFS_X2%15_13 67.08
R_x_PM_SDFFS_X2%15_r26 x_PM_SDFFS_X2%15_18 x_PM_SDFFS_X2%15_9 4.56151
R_x_PM_SDFFS_X2%15_r27 N_15_M41_g x_PM_SDFFS_X2%15_9 45.24
R_x_PM_SDFFS_X2%15_r28 N_15_M38_g x_PM_SDFFS_X2%15_41 74.1
R_x_PM_SDFFS_X2%15_r29 N_15_M17_g x_PM_SDFFS_X2%15_42 24.18
C_x_PM_SDFFS_X2%QN_c0 VSS QN 4.07827e-17
C_x_PM_SDFFS_X2%QN_c1 VSS N_QN_M20_s 1.01129e-16
C_x_PM_SDFFS_X2%QN_c2 VSS N_QN_M41_s 7.30492e-17
R_x_PM_SDFFS_X2%QN_r3 x_PM_SDFFS_X2%QN_14 QN 0.295654
R_x_PM_SDFFS_X2%QN_r4 x_PM_SDFFS_X2%QN_13 QN 0.295654
R_x_PM_SDFFS_X2%QN_r5 N_QN_M20_s x_PM_SDFFS_X2%QN_14 2.13071
R_x_PM_SDFFS_X2%QN_r6 N_QN_M41_s x_PM_SDFFS_X2%QN_13 1.09929
C_x_PM_SDFFS_X2%Q_c0 VSS x_PM_SDFFS_X2%Q_15 1.68521e-17
C_x_PM_SDFFS_X2%Q_c1 VSS Q 3.82003e-17
C_x_PM_SDFFS_X2%Q_c2 VSS x_PM_SDFFS_X2%Q_7 5.17282e-18
C_x_PM_SDFFS_X2%Q_c3 VSS N_Q_M42_d 4.6639e-17
R_x_PM_SDFFS_X2%Q_r4 x_PM_SDFFS_X2%Q_15 N_Q_M21_d 0.11963
R_x_PM_SDFFS_X2%Q_r5 x_PM_SDFFS_X2%Q_15 x_PM_SDFFS_X2%Q_8 0.095
R_x_PM_SDFFS_X2%Q_r6 Q x_PM_SDFFS_X2%Q_8 1.38429
R_x_PM_SDFFS_X2%Q_r7 Q x_PM_SDFFS_X2%Q_7 1.54714
R_x_PM_SDFFS_X2%Q_r8 x_PM_SDFFS_X2%Q_7 x_PM_SDFFS_X2%Q_3 0.240055
R_x_PM_SDFFS_X2%Q_r9 N_Q_M42_d x_PM_SDFFS_X2%Q_3 0.250455
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X1 VSS VDD Q QN CK SI D SE
*.PININFO VSS:B VDD:B Q:O QN:O CK:I SI:I D:I SE:I
M_M19 N_VDD_M0_d N_6_M0_g N_Q_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M20 N_QN_M1_d N_5_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M21 N_VDD_M2_d N_6_M2_g N_5_M2_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M22 17 N_5_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M23 N_6_M4_d N_7_M4_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 18 N_10_M5_g N_6_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M6_d N_9_M6_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_7_M7_d N_10_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M27 N_VDD_M8_d N_9_M8_g N_8_M8_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 19 N_8_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_9_M10_d N_10_M10_g 19 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M30 20 N_7_M11_g N_9_M10_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M31 N_VDD_M12_d N_11_M12_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M32 N_10_M13_d N_CK_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M33 21 N_SI_M14_g N_VDD_M14_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M34 N_11_M15_d N_15_M15_g 21 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M35 22 N_SE_M16_g N_11_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M36 N_VDD_M17_d N_D_M17_g 22 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M37 N_15_M18_d N_SE_M18_g N_VDD_M17_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M19_d N_6_M19_g N_Q_M19_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_QN_M20_d N_5_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_VSS_M21_d N_6_M21_g N_5_M21_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M3 23 N_5_M22_g N_VSS_M21_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_6_M23_d N_10_M23_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 24 N_7_M24_g N_6_M23_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M25_d N_9_M25_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_7_M26_d N_10_M26_g N_VSS_M25_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_VSS_M27_d N_9_M27_g N_8_M27_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 25 N_8_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_9_M29_d N_7_M29_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 26 N_10_M30_g N_9_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M12 N_VSS_M31_d N_11_M31_g 26 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M13 N_10_M32_d N_CK_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M14 27 N_D_M33_g N_VSS_M33_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_11_M34_d N_15_M34_g 27 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M16 28 N_SE_M35_g N_11_M34_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_VSS_M36_d N_SI_M36_g 28 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 N_15_M37_d N_SE_M37_g N_VSS_M36_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFF_X1%VSS_c0 VSS x_PM_SDFF_X1%VSS_59 3.74194e-17
C_x_PM_SDFF_X1%VSS_c1 VSS x_PM_SDFF_X1%VSS_58 3.97675e-17
C_x_PM_SDFF_X1%VSS_c2 VSS x_PM_SDFF_X1%VSS_54 2.92438e-18
C_x_PM_SDFF_X1%VSS_c3 VSS x_PM_SDFF_X1%VSS_53 4.62343e-18
C_x_PM_SDFF_X1%VSS_c4 VSS x_PM_SDFF_X1%VSS_52 4.64531e-18
C_x_PM_SDFF_X1%VSS_c5 VSS x_PM_SDFF_X1%VSS_51 5.44551e-18
C_x_PM_SDFF_X1%VSS_c6 VSS x_PM_SDFF_X1%VSS_50 3.47634e-17
C_x_PM_SDFF_X1%VSS_c7 VSS N_VSS_M36_d 1.70401e-17
C_x_PM_SDFF_X1%VSS_c8 VSS x_PM_SDFF_X1%VSS_42 7.86669e-17
C_x_PM_SDFF_X1%VSS_c9 VSS x_PM_SDFF_X1%VSS_40 2.55333e-17
C_x_PM_SDFF_X1%VSS_c10 VSS N_VSS_M31_d 2.27301e-17
C_x_PM_SDFF_X1%VSS_c11 VSS x_PM_SDFF_X1%VSS_34 6.48505e-17
C_x_PM_SDFF_X1%VSS_c12 VSS VSS 3.47502e-17
C_x_PM_SDFF_X1%VSS_c13 VSS x_PM_SDFF_X1%VSS_26 4.9589e-17
C_x_PM_SDFF_X1%VSS_c14 VSS N_VSS_M25_d 3.63644e-17
C_x_PM_SDFF_X1%VSS_c15 VSS x_PM_SDFF_X1%VSS_20 5.77475e-17
C_x_PM_SDFF_X1%VSS_c16 VSS N_VSS_M21_d 8.10786e-17
C_x_PM_SDFF_X1%VSS_c17 VSS x_PM_SDFF_X1%VSS_14 6.59336e-17
C_x_PM_SDFF_X1%VSS_c18 VSS N_VSS_M19_d 3.46298e-17
R_x_PM_SDFF_X1%VSS_r19 x_PM_SDFF_X1%VSS_58 N_VSS_M33_s 0.140674
R_x_PM_SDFF_X1%VSS_r20 x_PM_SDFF_X1%VSS_59 x_PM_SDFF_X1%VSS_44 0.145286
R_x_PM_SDFF_X1%VSS_r21 N_VSS_M36_d x_PM_SDFF_X1%VSS_44 0.230714
R_x_PM_SDFF_X1%VSS_r22 x_PM_SDFF_X1%VSS_59 x_PM_SDFF_X1%VSS_42 0.0731438
R_x_PM_SDFF_X1%VSS_r23 x_PM_SDFF_X1%VSS_58 x_PM_SDFF_X1%VSS_42 1.46412
R_x_PM_SDFF_X1%VSS_r24 x_PM_SDFF_X1%VSS_54 x_PM_SDFF_X1%VSS_41 0.0731438
R_x_PM_SDFF_X1%VSS_r25 x_PM_SDFF_X1%VSS_40 N_VSS_M33_s 0.140674
R_x_PM_SDFF_X1%VSS_r26 x_PM_SDFF_X1%VSS_41 x_PM_SDFF_X1%VSS_40 0.637059
R_x_PM_SDFF_X1%VSS_r27 x_PM_SDFF_X1%VSS_54 x_PM_SDFF_X1%VSS_36 0.145286
R_x_PM_SDFF_X1%VSS_r28 N_VSS_M31_d x_PM_SDFF_X1%VSS_36 0.692143
R_x_PM_SDFF_X1%VSS_r29 x_PM_SDFF_X1%VSS_53 x_PM_SDFF_X1%VSS_35 0.0731438
R_x_PM_SDFF_X1%VSS_r30 x_PM_SDFF_X1%VSS_54 x_PM_SDFF_X1%VSS_34 0.0731438
R_x_PM_SDFF_X1%VSS_r31 x_PM_SDFF_X1%VSS_35 x_PM_SDFF_X1%VSS_34 1.54235
R_x_PM_SDFF_X1%VSS_r32 N_VSS_M27_d VSS 0.665
R_x_PM_SDFF_X1%VSS_r33 x_PM_SDFF_X1%VSS_53 x_PM_SDFF_X1%VSS_28 0.145286
R_x_PM_SDFF_X1%VSS_r34 VSS x_PM_SDFF_X1%VSS_28 0.515714
R_x_PM_SDFF_X1%VSS_r35 x_PM_SDFF_X1%VSS_52 x_PM_SDFF_X1%VSS_27 0.0731438
R_x_PM_SDFF_X1%VSS_r36 x_PM_SDFF_X1%VSS_53 x_PM_SDFF_X1%VSS_26 0.0731438
R_x_PM_SDFF_X1%VSS_r37 x_PM_SDFF_X1%VSS_27 x_PM_SDFF_X1%VSS_26 1.02824
R_x_PM_SDFF_X1%VSS_r38 x_PM_SDFF_X1%VSS_52 x_PM_SDFF_X1%VSS_22 0.145286
R_x_PM_SDFF_X1%VSS_r39 N_VSS_M25_d x_PM_SDFF_X1%VSS_22 1.58786
R_x_PM_SDFF_X1%VSS_r40 x_PM_SDFF_X1%VSS_51 x_PM_SDFF_X1%VSS_21 0.132285
R_x_PM_SDFF_X1%VSS_r41 x_PM_SDFF_X1%VSS_52 x_PM_SDFF_X1%VSS_20 0.0731438
R_x_PM_SDFF_X1%VSS_r42 x_PM_SDFF_X1%VSS_21 x_PM_SDFF_X1%VSS_20 1.52
R_x_PM_SDFF_X1%VSS_r43 x_PM_SDFF_X1%VSS_51 x_PM_SDFF_X1%VSS_16 0.0680382
R_x_PM_SDFF_X1%VSS_r44 N_VSS_M21_d x_PM_SDFF_X1%VSS_16 0.823333
R_x_PM_SDFF_X1%VSS_r45 x_PM_SDFF_X1%VSS_50 x_PM_SDFF_X1%VSS_15 0.0731438
R_x_PM_SDFF_X1%VSS_r46 x_PM_SDFF_X1%VSS_51 x_PM_SDFF_X1%VSS_14 0.132285
R_x_PM_SDFF_X1%VSS_r47 x_PM_SDFF_X1%VSS_15 x_PM_SDFF_X1%VSS_14 1.14
R_x_PM_SDFF_X1%VSS_r48 x_PM_SDFF_X1%VSS_50 x_PM_SDFF_X1%VSS_10 0.145286
R_x_PM_SDFF_X1%VSS_r49 N_VSS_M19_d x_PM_SDFF_X1%VSS_10 0.909286
C_x_PM_SDFF_X1%VDD_c0 VSS x_PM_SDFF_X1%VDD_58 3.02148e-17
C_x_PM_SDFF_X1%VDD_c1 VSS x_PM_SDFF_X1%VDD_57 2.71388e-18
C_x_PM_SDFF_X1%VDD_c2 VSS x_PM_SDFF_X1%VDD_56 2.84978e-18
C_x_PM_SDFF_X1%VDD_c3 VSS x_PM_SDFF_X1%VDD_55 4.6069e-18
C_x_PM_SDFF_X1%VDD_c4 VSS x_PM_SDFF_X1%VDD_54 4.63549e-18
C_x_PM_SDFF_X1%VDD_c5 VSS x_PM_SDFF_X1%VDD_53 5.64357e-18
C_x_PM_SDFF_X1%VDD_c6 VSS x_PM_SDFF_X1%VDD_52 2.59324e-17
C_x_PM_SDFF_X1%VDD_c7 VSS N_VDD_M17_d 1.56275e-17
C_x_PM_SDFF_X1%VDD_c8 VSS x_PM_SDFF_X1%VDD_44 6.97515e-17
C_x_PM_SDFF_X1%VDD_c9 VSS N_VDD_M14_s 1.75498e-17
C_x_PM_SDFF_X1%VDD_c10 VSS x_PM_SDFF_X1%VDD_38 2.82215e-17
C_x_PM_SDFF_X1%VDD_c11 VSS N_VDD_M12_d 1.80881e-17
C_x_PM_SDFF_X1%VDD_c12 VSS x_PM_SDFF_X1%VDD_32 7.50931e-17
C_x_PM_SDFF_X1%VDD_c13 VSS N_VDD_M8_d 3.63995e-17
C_x_PM_SDFF_X1%VDD_c14 VSS x_PM_SDFF_X1%VDD_24 4.89214e-17
C_x_PM_SDFF_X1%VDD_c15 VSS N_VDD_M6_d 3.23704e-17
C_x_PM_SDFF_X1%VDD_c16 VSS x_PM_SDFF_X1%VDD_18 7.4529e-17
C_x_PM_SDFF_X1%VDD_c17 VSS x_PM_SDFF_X1%VDD_17 5.97678e-17
C_x_PM_SDFF_X1%VDD_c18 VSS x_PM_SDFF_X1%VDD_14 3.45766e-17
C_x_PM_SDFF_X1%VDD_c19 VSS N_VDD_M0_d 3.68375e-17
R_x_PM_SDFF_X1%VDD_r20 x_PM_SDFF_X1%VDD_58 x_PM_SDFF_X1%VDD_46 0.145286
R_x_PM_SDFF_X1%VDD_r21 N_VDD_M17_d x_PM_SDFF_X1%VDD_46 0.230714
R_x_PM_SDFF_X1%VDD_r22 x_PM_SDFF_X1%VDD_57 x_PM_SDFF_X1%VDD_45 0.0731438
R_x_PM_SDFF_X1%VDD_r23 x_PM_SDFF_X1%VDD_58 x_PM_SDFF_X1%VDD_44 0.0731438
R_x_PM_SDFF_X1%VDD_r24 x_PM_SDFF_X1%VDD_45 x_PM_SDFF_X1%VDD_44 1.53118
R_x_PM_SDFF_X1%VDD_r25 x_PM_SDFF_X1%VDD_57 x_PM_SDFF_X1%VDD_40 0.145286
R_x_PM_SDFF_X1%VDD_r26 N_VDD_M14_s x_PM_SDFF_X1%VDD_40 0.230714
R_x_PM_SDFF_X1%VDD_r27 x_PM_SDFF_X1%VDD_56 x_PM_SDFF_X1%VDD_39 0.0731438
R_x_PM_SDFF_X1%VDD_r28 x_PM_SDFF_X1%VDD_57 x_PM_SDFF_X1%VDD_38 0.0731438
R_x_PM_SDFF_X1%VDD_r29 x_PM_SDFF_X1%VDD_39 x_PM_SDFF_X1%VDD_38 0.704118
R_x_PM_SDFF_X1%VDD_r30 x_PM_SDFF_X1%VDD_56 x_PM_SDFF_X1%VDD_34 0.145286
R_x_PM_SDFF_X1%VDD_r31 N_VDD_M12_d x_PM_SDFF_X1%VDD_34 0.420714
R_x_PM_SDFF_X1%VDD_r32 x_PM_SDFF_X1%VDD_55 x_PM_SDFF_X1%VDD_33 0.0731438
R_x_PM_SDFF_X1%VDD_r33 x_PM_SDFF_X1%VDD_56 x_PM_SDFF_X1%VDD_32 0.0731438
R_x_PM_SDFF_X1%VDD_r34 x_PM_SDFF_X1%VDD_33 x_PM_SDFF_X1%VDD_32 1.54235
R_x_PM_SDFF_X1%VDD_r35 VDD N_VDD_M8_d 0.38
R_x_PM_SDFF_X1%VDD_r36 x_PM_SDFF_X1%VDD_55 x_PM_SDFF_X1%VDD_26 0.145286
R_x_PM_SDFF_X1%VDD_r37 VDD x_PM_SDFF_X1%VDD_26 0.529286
R_x_PM_SDFF_X1%VDD_r38 x_PM_SDFF_X1%VDD_54 x_PM_SDFF_X1%VDD_25 0.0731438
R_x_PM_SDFF_X1%VDD_r39 x_PM_SDFF_X1%VDD_55 x_PM_SDFF_X1%VDD_24 0.0731438
R_x_PM_SDFF_X1%VDD_r40 x_PM_SDFF_X1%VDD_25 x_PM_SDFF_X1%VDD_24 1.01706
R_x_PM_SDFF_X1%VDD_r41 x_PM_SDFF_X1%VDD_54 x_PM_SDFF_X1%VDD_20 0.145286
R_x_PM_SDFF_X1%VDD_r42 N_VDD_M6_d x_PM_SDFF_X1%VDD_20 1.39786
R_x_PM_SDFF_X1%VDD_r43 x_PM_SDFF_X1%VDD_53 x_PM_SDFF_X1%VDD_19 0.132285
R_x_PM_SDFF_X1%VDD_r44 x_PM_SDFF_X1%VDD_54 x_PM_SDFF_X1%VDD_18 0.0731438
R_x_PM_SDFF_X1%VDD_r45 x_PM_SDFF_X1%VDD_19 x_PM_SDFF_X1%VDD_18 1.74353
R_x_PM_SDFF_X1%VDD_r46 x_PM_SDFF_X1%VDD_53 x_PM_SDFF_X1%VDD_17 0.0680382
R_x_PM_SDFF_X1%VDD_r47 x_PM_SDFF_X1%VDD_17 N_VDD_M2_d 0.403583
R_x_PM_SDFF_X1%VDD_r48 x_PM_SDFF_X1%VDD_52 x_PM_SDFF_X1%VDD_15 0.0731438
R_x_PM_SDFF_X1%VDD_r49 x_PM_SDFF_X1%VDD_53 x_PM_SDFF_X1%VDD_14 0.132285
R_x_PM_SDFF_X1%VDD_r50 x_PM_SDFF_X1%VDD_15 x_PM_SDFF_X1%VDD_14 0.938824
R_x_PM_SDFF_X1%VDD_r51 x_PM_SDFF_X1%VDD_52 x_PM_SDFF_X1%VDD_10 0.145286
R_x_PM_SDFF_X1%VDD_r52 N_VDD_M0_d x_PM_SDFF_X1%VDD_10 1.615
C_x_PM_SDFF_X1%Q_c0 VSS N_Q_M19_s 8.62723e-17
R_x_PM_SDFF_X1%Q_r1 N_Q_M0_s Q 1.65933
R_x_PM_SDFF_X1%Q_r2 Q N_Q_M19_s 1.83667
C_x_PM_SDFF_X1%QN_c0 VSS x_PM_SDFF_X1%QN_13 8.17528e-18
C_x_PM_SDFF_X1%QN_c1 VSS N_QN_M1_d 1.11333e-16
C_x_PM_SDFF_X1%QN_c2 VSS N_QN_M20_d 5.08051e-17
R_x_PM_SDFF_X1%QN_r3 N_QN_M1_d x_PM_SDFF_X1%QN_13 2.91786
R_x_PM_SDFF_X1%QN_r4 QN N_QN_M20_d 0.391875
R_x_PM_SDFF_X1%QN_r5 x_PM_SDFF_X1%QN_13 x_PM_SDFF_X1%QN_3 0.196927
R_x_PM_SDFF_X1%QN_r6 QN x_PM_SDFF_X1%QN_3 0.1425
C_x_PM_SDFF_X1%5_c0 VSS N_5_M21_s 1.00383e-16
C_x_PM_SDFF_X1%5_c1 VSS N_5_M2_s 3.67663e-17
C_x_PM_SDFF_X1%5_c2 VSS x_PM_SDFF_X1%5_30 1.19601e-16
C_x_PM_SDFF_X1%5_c3 VSS x_PM_SDFF_X1%5_21 1.65031e-17
C_x_PM_SDFF_X1%5_c4 VSS x_PM_SDFF_X1%5_19 4.60438e-17
C_x_PM_SDFF_X1%5_c5 VSS x_PM_SDFF_X1%5_18 4.75553e-18
C_x_PM_SDFF_X1%5_c6 VSS N_5_M22_g 4.51074e-17
C_x_PM_SDFF_X1%5_c7 VSS N_5_M3_g 5.17071e-17
C_x_PM_SDFF_X1%5_c8 VSS N_5_M1_g 3.66518e-17
C_x_PM_SDFF_X1%5_c9 VSS N_5_M20_g 6.43056e-17
R_x_PM_SDFF_X1%5_r10 x_PM_SDFF_X1%5_39 x_PM_SDFF_X1%5_30 25.0012
R_x_PM_SDFF_X1%5_r11 x_PM_SDFF_X1%5_28 N_5_M2_s 0.30478
R_x_PM_SDFF_X1%5_r12 x_PM_SDFF_X1%5_30 x_PM_SDFF_X1%5_28 1.77786
R_x_PM_SDFF_X1%5_r13 x_PM_SDFF_X1%5_27 N_5_M21_s 0.278882
R_x_PM_SDFF_X1%5_r14 x_PM_SDFF_X1%5_30 x_PM_SDFF_X1%5_27 1.56071
R_x_PM_SDFF_X1%5_r15 x_PM_SDFF_X1%5_21 x_PM_SDFF_X1%5_20 8.775
R_x_PM_SDFF_X1%5_r16 x_PM_SDFF_X1%5_39 x_PM_SDFF_X1%5_19 23.6437
R_x_PM_SDFF_X1%5_r17 x_PM_SDFF_X1%5_20 x_PM_SDFF_X1%5_19 2.4375
R_x_PM_SDFF_X1%5_r18 x_PM_SDFF_X1%5_39 x_PM_SDFF_X1%5_17 22.1812
R_x_PM_SDFF_X1%5_r19 x_PM_SDFF_X1%5_18 x_PM_SDFF_X1%5_17 0.179698
R_x_PM_SDFF_X1%5_r20 x_PM_SDFF_X1%5_21 x_PM_SDFF_X1%5_13 1.95
R_x_PM_SDFF_X1%5_r21 N_5_M22_g x_PM_SDFF_X1%5_13 49.92
R_x_PM_SDFF_X1%5_r22 x_PM_SDFF_X1%5_20 x_PM_SDFF_X1%5_9 1.95
R_x_PM_SDFF_X1%5_r23 N_5_M3_g x_PM_SDFF_X1%5_9 55.38
R_x_PM_SDFF_X1%5_r24 x_PM_SDFF_X1%5_18 x_PM_SDFF_X1%5_5 4.78783
R_x_PM_SDFF_X1%5_r25 N_5_M1_g x_PM_SDFF_X1%5_5 31.59
R_x_PM_SDFF_X1%5_r26 x_PM_SDFF_X1%5_18 x_PM_SDFF_X1%5_VSS 4.78783
R_x_PM_SDFF_X1%5_r27 N_5_M20_g x_PM_SDFF_X1%5_VSS 69.42
C_x_PM_SDFF_X1%6_c0 VSS x_PM_SDFF_X1%6_41 1.99852e-17
C_x_PM_SDFF_X1%6_c1 VSS x_PM_SDFF_X1%6_40 1.44355e-17
C_x_PM_SDFF_X1%6_c2 VSS x_PM_SDFF_X1%6_38 7.60935e-17
C_x_PM_SDFF_X1%6_c3 VSS x_PM_SDFF_X1%6_35 1.71131e-17
C_x_PM_SDFF_X1%6_c4 VSS N_6_M4_d 2.02196e-17
C_x_PM_SDFF_X1%6_c5 VSS x_PM_SDFF_X1%6_23 5.684e-17
C_x_PM_SDFF_X1%6_c6 VSS x_PM_SDFF_X1%6_21 2.71079e-17
C_x_PM_SDFF_X1%6_c7 VSS x_PM_SDFF_X1%6_20 4.78823e-17
C_x_PM_SDFF_X1%6_c8 VSS x_PM_SDFF_X1%6_19 1.71688e-17
C_x_PM_SDFF_X1%6_c9 VSS N_6_M23_d 2.26826e-17
C_x_PM_SDFF_X1%6_c10 VSS N_6_M21_g 4.9274e-17
C_x_PM_SDFF_X1%6_c11 VSS N_6_M2_g 2.506e-17
C_x_PM_SDFF_X1%6_c12 VSS x_PM_SDFF_X1%6_8 6.40728e-18
C_x_PM_SDFF_X1%6_c13 VSS x_PM_SDFF_X1%6_7 7.20934e-17
C_x_PM_SDFF_X1%6_c14 VSS N_6_M19_g 1.15735e-16
R_x_PM_SDFF_X1%6_r15 x_PM_SDFF_X1%6_43 x_PM_SDFF_X1%6_41 0.624286
R_x_PM_SDFF_X1%6_r16 x_PM_SDFF_X1%6_40 x_PM_SDFF_X1%6_49 3.9
R_x_PM_SDFF_X1%6_r17 x_PM_SDFF_X1%6_40 x_PM_SDFF_X1%6_39 25.0012
R_x_PM_SDFF_X1%6_r18 x_PM_SDFF_X1%6_38 x_PM_SDFF_X1%6_37 0.186267
R_x_PM_SDFF_X1%6_r19 x_PM_SDFF_X1%6_35 x_PM_SDFF_X1%6_45 5.46
R_x_PM_SDFF_X1%6_r20 x_PM_SDFF_X1%6_35 x_PM_SDFF_X1%6_33 25.0012
R_x_PM_SDFF_X1%6_r21 x_PM_SDFF_X1%6_37 x_PM_SDFF_X1%6_33 0.218148
R_x_PM_SDFF_X1%6_r22 x_PM_SDFF_X1%6_41 x_PM_SDFF_X1%6_29 0.095
R_x_PM_SDFF_X1%6_r23 N_6_M4_d x_PM_SDFF_X1%6_25 0.447857
R_x_PM_SDFF_X1%6_r24 x_PM_SDFF_X1%6_25 x_PM_SDFF_X1%6_23 0.212317
R_x_PM_SDFF_X1%6_r25 x_PM_SDFF_X1%6_38 x_PM_SDFF_X1%6_23 1.46571
R_x_PM_SDFF_X1%6_r26 x_PM_SDFF_X1%6_39 x_PM_SDFF_X1%6_22 0.198162
R_x_PM_SDFF_X1%6_r27 x_PM_SDFF_X1%6_43 x_PM_SDFF_X1%6_21 0.095
R_x_PM_SDFF_X1%6_r28 x_PM_SDFF_X1%6_22 x_PM_SDFF_X1%6_21 1.16714
R_x_PM_SDFF_X1%6_r29 x_PM_SDFF_X1%6_37 x_PM_SDFF_X1%6_20 0.095
R_x_PM_SDFF_X1%6_r30 x_PM_SDFF_X1%6_39 x_PM_SDFF_X1%6_19 0.0141545
R_x_PM_SDFF_X1%6_r31 x_PM_SDFF_X1%6_20 x_PM_SDFF_X1%6_19 2.00857
R_x_PM_SDFF_X1%6_r32 N_6_M23_d x_PM_SDFF_X1%6_29 0.773571
R_x_PM_SDFF_X1%6_r33 x_PM_SDFF_X1%6_49 x_PM_SDFF_X1%6_14 1.95
R_x_PM_SDFF_X1%6_r34 N_6_M21_g x_PM_SDFF_X1%6_14 32.76
R_x_PM_SDFF_X1%6_r35 N_6_M21_g x_PM_SDFF_X1%6_13 31.98
R_x_PM_SDFF_X1%6_r36 x_PM_SDFF_X1%6_45 x_PM_SDFF_X1%6_9 1.95
R_x_PM_SDFF_X1%6_r37 N_6_M2_g x_PM_SDFF_X1%6_9 18.72
R_x_PM_SDFF_X1%6_r38 x_PM_SDFF_X1%6_13 x_PM_SDFF_X1%6_7 4.35808
R_x_PM_SDFF_X1%6_r39 x_PM_SDFF_X1%6_8 x_PM_SDFF_X1%6_7 87.36
R_x_PM_SDFF_X1%6_r40 N_6_M0_g N_6_M19_g 113.49
R_x_PM_SDFF_X1%6_r41 x_PM_SDFF_X1%6_8 x_PM_SDFF_X1%6_VSS 4.35808
R_x_PM_SDFF_X1%6_r42 N_6_M19_g x_PM_SDFF_X1%6_VSS 26.52
C_x_PM_SDFF_X1%7_c0 VSS x_PM_SDFF_X1%7_46 8.9038e-18
C_x_PM_SDFF_X1%7_c1 VSS x_PM_SDFF_X1%7_42 1.83834e-17
C_x_PM_SDFF_X1%7_c2 VSS N_7_M7_d 7.65414e-17
C_x_PM_SDFF_X1%7_c3 VSS N_7_M26_d 4.64194e-17
C_x_PM_SDFF_X1%7_c4 VSS x_PM_SDFF_X1%7_30 3.04428e-17
C_x_PM_SDFF_X1%7_c5 VSS x_PM_SDFF_X1%7_29 1.12275e-17
C_x_PM_SDFF_X1%7_c6 VSS x_PM_SDFF_X1%7_28 5.84521e-18
C_x_PM_SDFF_X1%7_c7 VSS x_PM_SDFF_X1%7_26 9.8252e-18
C_x_PM_SDFF_X1%7_c8 VSS x_PM_SDFF_X1%7_23 5.85074e-17
C_x_PM_SDFF_X1%7_c9 VSS N_7_M11_g 6.59756e-17
C_x_PM_SDFF_X1%7_c10 VSS x_PM_SDFF_X1%7_16 5.85603e-18
C_x_PM_SDFF_X1%7_c11 VSS x_PM_SDFF_X1%7_15 2.11619e-17
C_x_PM_SDFF_X1%7_c12 VSS N_7_M29_g 6.49391e-17
C_x_PM_SDFF_X1%7_c13 VSS x_PM_SDFF_X1%7_10 6.61843e-18
C_x_PM_SDFF_X1%7_c14 VSS x_PM_SDFF_X1%7_9 1.38626e-16
C_x_PM_SDFF_X1%7_c15 VSS N_7_M24_g 4.76485e-17
C_x_PM_SDFF_X1%7_c16 VSS N_7_M4_g 3.68561e-17
R_x_PM_SDFF_X1%7_r17 x_PM_SDFF_X1%7_46 x_PM_SDFF_X1%7_40 25.0012
R_x_PM_SDFF_X1%7_r18 x_PM_SDFF_X1%7_42 x_PM_SDFF_X1%7_36 0.160909
R_x_PM_SDFF_X1%7_r19 N_7_M7_d x_PM_SDFF_X1%7_36 1.50643
R_x_PM_SDFF_X1%7_r20 x_PM_SDFF_X1%7_42 x_PM_SDFF_X1%7_32 0.160909
R_x_PM_SDFF_X1%7_r21 N_7_M26_d x_PM_SDFF_X1%7_32 0.665
R_x_PM_SDFF_X1%7_r22 x_PM_SDFF_X1%7_40 x_PM_SDFF_X1%7_31 0.0141545
R_x_PM_SDFF_X1%7_r23 x_PM_SDFF_X1%7_42 x_PM_SDFF_X1%7_30 0.0418175
R_x_PM_SDFF_X1%7_r24 x_PM_SDFF_X1%7_31 x_PM_SDFF_X1%7_30 2.28
R_x_PM_SDFF_X1%7_r25 x_PM_SDFF_X1%7_40 x_PM_SDFF_X1%7_28 0.198162
R_x_PM_SDFF_X1%7_r26 x_PM_SDFF_X1%7_29 x_PM_SDFF_X1%7_28 0.922857
R_x_PM_SDFF_X1%7_r27 x_PM_SDFF_X1%7_45 x_PM_SDFF_X1%7_26 4.7687
R_x_PM_SDFF_X1%7_r28 x_PM_SDFF_X1%7_26 x_PM_SDFF_X1%7_24 25.0012
R_x_PM_SDFF_X1%7_r29 x_PM_SDFF_X1%7_29 x_PM_SDFF_X1%7_23 0.212317
R_x_PM_SDFF_X1%7_r30 x_PM_SDFF_X1%7_24 x_PM_SDFF_X1%7_23 1.34357
R_x_PM_SDFF_X1%7_r31 N_7_M11_g x_PM_SDFF_X1%7_17 70.2
R_x_PM_SDFF_X1%7_r32 x_PM_SDFF_X1%7_17 x_PM_SDFF_X1%7_15 4.35808
R_x_PM_SDFF_X1%7_r33 x_PM_SDFF_X1%7_16 x_PM_SDFF_X1%7_15 21.84
R_x_PM_SDFF_X1%7_r34 x_PM_SDFF_X1%7_16 x_PM_SDFF_X1%7_12 4.35808
R_x_PM_SDFF_X1%7_r35 N_7_M29_g x_PM_SDFF_X1%7_12 58.5
R_x_PM_SDFF_X1%7_r36 N_7_M29_g x_PM_SDFF_X1%7_11 34.32
R_x_PM_SDFF_X1%7_r37 x_PM_SDFF_X1%7_11 x_PM_SDFF_X1%7_9 4.35808
R_x_PM_SDFF_X1%7_r38 x_PM_SDFF_X1%7_10 x_PM_SDFF_X1%7_9 163.8
R_x_PM_SDFF_X1%7_r39 x_PM_SDFF_X1%7_6 x_PM_SDFF_X1%7_46 4.7687
R_x_PM_SDFF_X1%7_r40 N_7_M24_g x_PM_SDFF_X1%7_6 33.54
R_x_PM_SDFF_X1%7_r41 x_PM_SDFF_X1%7_10 x_PM_SDFF_X1%7_5 4.35808
R_x_PM_SDFF_X1%7_r42 N_7_M24_g x_PM_SDFF_X1%7_5 46.02
R_x_PM_SDFF_X1%7_r43 N_7_M4_g x_PM_SDFF_X1%7_45 34.32
C_x_PM_SDFF_X1%8_c0 VSS x_PM_SDFF_X1%8_25 1.00198e-17
C_x_PM_SDFF_X1%8_c1 VSS x_PM_SDFF_X1%8_22 3.2211e-17
C_x_PM_SDFF_X1%8_c2 VSS x_PM_SDFF_X1%8_21 6.30172e-17
C_x_PM_SDFF_X1%8_c3 VSS N_8_M8_s 1.2844e-16
C_x_PM_SDFF_X1%8_c4 VSS N_8_M27_s 6.34831e-17
C_x_PM_SDFF_X1%8_c5 VSS N_8_M9_g 6.53112e-17
C_x_PM_SDFF_X1%8_c6 VSS N_8_M28_g 3.80284e-17
R_x_PM_SDFF_X1%8_r7 x_PM_SDFF_X1%8_25 x_PM_SDFF_X1%8_23 3.38
R_x_PM_SDFF_X1%8_r8 x_PM_SDFF_X1%8_22 x_PM_SDFF_X1%8_21 0.0021128
R_x_PM_SDFF_X1%8_r9 x_PM_SDFF_X1%8_21 x_PM_SDFF_X1%8_19 0.544324
R_x_PM_SDFF_X1%8_r10 x_PM_SDFF_X1%8_23 x_PM_SDFF_X1%8_19 25.0012
R_x_PM_SDFF_X1%8_r11 x_PM_SDFF_X1%8_22 x_PM_SDFF_X1%8_15 0.222227
R_x_PM_SDFF_X1%8_r12 N_8_M8_s x_PM_SDFF_X1%8_15 1.84722
R_x_PM_SDFF_X1%8_r13 x_PM_SDFF_X1%8_22 x_PM_SDFF_X1%8_11 0.222227
R_x_PM_SDFF_X1%8_r14 N_8_M27_s x_PM_SDFF_X1%8_11 1.02389
R_x_PM_SDFF_X1%8_r15 x_PM_SDFF_X1%8_25 x_PM_SDFF_X1%8_5 1.95
R_x_PM_SDFF_X1%8_r16 N_8_M9_g x_PM_SDFF_X1%8_5 74.1
R_x_PM_SDFF_X1%8_r17 x_PM_SDFF_X1%8_25 x_PM_SDFF_X1%8_VSS 1.95
R_x_PM_SDFF_X1%8_r18 N_8_M28_g x_PM_SDFF_X1%8_VSS 43.68
C_x_PM_SDFF_X1%9_c0 VSS x_PM_SDFF_X1%9_34 3.1947e-17
C_x_PM_SDFF_X1%9_c1 VSS N_9_M10_d 5.06835e-17
C_x_PM_SDFF_X1%9_c2 VSS x_PM_SDFF_X1%9_30 1.5714e-17
C_x_PM_SDFF_X1%9_c3 VSS x_PM_SDFF_X1%9_26 1.28219e-17
C_x_PM_SDFF_X1%9_c4 VSS x_PM_SDFF_X1%9_25 2.29393e-17
C_x_PM_SDFF_X1%9_c5 VSS x_PM_SDFF_X1%9_23 1.15821e-16
C_x_PM_SDFF_X1%9_c6 VSS x_PM_SDFF_X1%9_21 6.62511e-17
C_x_PM_SDFF_X1%9_c7 VSS x_PM_SDFF_X1%9_20 1.22296e-17
C_x_PM_SDFF_X1%9_c8 VSS N_9_M29_d 4.45891e-17
C_x_PM_SDFF_X1%9_c9 VSS N_9_M8_g 3.54712e-17
C_x_PM_SDFF_X1%9_c10 VSS N_9_M27_g 7.69648e-17
C_x_PM_SDFF_X1%9_c11 VSS x_PM_SDFF_X1%9_8 6.25353e-18
C_x_PM_SDFF_X1%9_c12 VSS x_PM_SDFF_X1%9_7 6.32964e-17
C_x_PM_SDFF_X1%9_c13 VSS N_9_M25_g 1.07135e-16
R_x_PM_SDFF_X1%9_r14 N_9_M10_d x_PM_SDFF_X1%9_30 0.800714
R_x_PM_SDFF_X1%9_r15 x_PM_SDFF_X1%9_30 x_PM_SDFF_X1%9_25 0.212317
R_x_PM_SDFF_X1%9_r16 x_PM_SDFF_X1%9_34 x_PM_SDFF_X1%9_24 0.266978
R_x_PM_SDFF_X1%9_r17 x_PM_SDFF_X1%9_25 x_PM_SDFF_X1%9_24 0.76
R_x_PM_SDFF_X1%9_r18 x_PM_SDFF_X1%9_34 x_PM_SDFF_X1%9_23 0.266978
R_x_PM_SDFF_X1%9_r19 x_PM_SDFF_X1%9_26 x_PM_SDFF_X1%9_22 0.212317
R_x_PM_SDFF_X1%9_r20 x_PM_SDFF_X1%9_23 x_PM_SDFF_X1%9_22 2.71429
R_x_PM_SDFF_X1%9_r21 x_PM_SDFF_X1%9_34 x_PM_SDFF_X1%9_21 0.0272847
R_x_PM_SDFF_X1%9_r22 x_PM_SDFF_X1%9_20 x_PM_SDFF_X1%9_35 3.9
R_x_PM_SDFF_X1%9_r23 x_PM_SDFF_X1%9_21 x_PM_SDFF_X1%9_19 0.544324
R_x_PM_SDFF_X1%9_r24 x_PM_SDFF_X1%9_20 x_PM_SDFF_X1%9_19 25.0012
R_x_PM_SDFF_X1%9_r25 N_9_M29_d x_PM_SDFF_X1%9_26 0.800714
R_x_PM_SDFF_X1%9_r26 x_PM_SDFF_X1%9_35 x_PM_SDFF_X1%9_13 1.95
R_x_PM_SDFF_X1%9_r27 N_9_M8_g x_PM_SDFF_X1%9_13 30.42
R_x_PM_SDFF_X1%9_r28 x_PM_SDFF_X1%9_35 x_PM_SDFF_X1%9_10 1.95
R_x_PM_SDFF_X1%9_r29 N_9_M27_g x_PM_SDFF_X1%9_10 87.36
R_x_PM_SDFF_X1%9_r30 N_9_M27_g x_PM_SDFF_X1%9_9 14.82
R_x_PM_SDFF_X1%9_r31 x_PM_SDFF_X1%9_9 x_PM_SDFF_X1%9_7 4.35808
R_x_PM_SDFF_X1%9_r32 x_PM_SDFF_X1%9_8 x_PM_SDFF_X1%9_7 74.88
R_x_PM_SDFF_X1%9_r33 N_9_M6_g N_9_M25_g 103.74
R_x_PM_SDFF_X1%9_r34 x_PM_SDFF_X1%9_8 x_PM_SDFF_X1%9_VSS 4.35808
R_x_PM_SDFF_X1%9_r35 N_9_M25_g x_PM_SDFF_X1%9_VSS 26.52
C_x_PM_SDFF_X1%10_c0 VSS x_PM_SDFF_X1%10_49 4.18578e-17
C_x_PM_SDFF_X1%10_c1 VSS x_PM_SDFF_X1%10_48 1.33729e-17
C_x_PM_SDFF_X1%10_c2 VSS x_PM_SDFF_X1%10_41 6.1344e-17
C_x_PM_SDFF_X1%10_c3 VSS x_PM_SDFF_X1%10_40 9.96576e-18
C_x_PM_SDFF_X1%10_c4 VSS x_PM_SDFF_X1%10_37 4.13641e-17
C_x_PM_SDFF_X1%10_c5 VSS x_PM_SDFF_X1%10_36 1.02916e-16
C_x_PM_SDFF_X1%10_c6 VSS x_PM_SDFF_X1%10_35 1.69531e-16
C_x_PM_SDFF_X1%10_c7 VSS N_10_M32_d 3.97385e-17
C_x_PM_SDFF_X1%10_c8 VSS x_PM_SDFF_X1%10_31 3.5943e-18
C_x_PM_SDFF_X1%10_c9 VSS x_PM_SDFF_X1%10_29 1.50711e-17
C_x_PM_SDFF_X1%10_c10 VSS N_10_M30_g 2.9923e-17
C_x_PM_SDFF_X1%10_c11 VSS N_10_M10_g 3.12613e-17
C_x_PM_SDFF_X1%10_c12 VSS x_PM_SDFF_X1%10_17 8.76707e-17
C_x_PM_SDFF_X1%10_c13 VSS N_10_M26_g 1.1814e-16
C_x_PM_SDFF_X1%10_c14 VSS x_PM_SDFF_X1%10_10 6.55442e-18
C_x_PM_SDFF_X1%10_c15 VSS x_PM_SDFF_X1%10_9 5.2066e-17
C_x_PM_SDFF_X1%10_c16 VSS N_10_M5_g 5.77798e-17
C_x_PM_SDFF_X1%10_c17 VSS N_10_M23_g 4.51562e-17
R_x_PM_SDFF_X1%10_r18 N_10_M13_d x_PM_SDFF_X1%10_49 0.176429
R_x_PM_SDFF_X1%10_r19 x_PM_SDFF_X1%10_48 x_PM_SDFF_X1%10_54 4.42
R_x_PM_SDFF_X1%10_r20 x_PM_SDFF_X1%10_48 x_PM_SDFF_X1%10_47 25.0012
R_x_PM_SDFF_X1%10_r21 x_PM_SDFF_X1%10_47 x_PM_SDFF_X1%10_42 0.198162
R_x_PM_SDFF_X1%10_r22 x_PM_SDFF_X1%10_49 x_PM_SDFF_X1%10_41 0.095
R_x_PM_SDFF_X1%10_r23 x_PM_SDFF_X1%10_42 x_PM_SDFF_X1%10_41 2.95857
R_x_PM_SDFF_X1%10_r24 x_PM_SDFF_X1%10_59 x_PM_SDFF_X1%10_40 4.7687
R_x_PM_SDFF_X1%10_r25 x_PM_SDFF_X1%10_40 x_PM_SDFF_X1%10_38 25.0012
R_x_PM_SDFF_X1%10_r26 x_PM_SDFF_X1%10_38 x_PM_SDFF_X1%10_37 0.529286
R_x_PM_SDFF_X1%10_r27 x_PM_SDFF_X1%10_43 x_PM_SDFF_X1%10_36 0.212317
R_x_PM_SDFF_X1%10_r28 x_PM_SDFF_X1%10_38 x_PM_SDFF_X1%10_36 2.42929
R_x_PM_SDFF_X1%10_r29 x_PM_SDFF_X1%10_47 x_PM_SDFF_X1%10_35 0.0141545
R_x_PM_SDFF_X1%10_r30 x_PM_SDFF_X1%10_37 x_PM_SDFF_X1%10_34 0.212317
R_x_PM_SDFF_X1%10_r31 x_PM_SDFF_X1%10_35 x_PM_SDFF_X1%10_34 2.74143
R_x_PM_SDFF_X1%10_r32 N_10_M32_d x_PM_SDFF_X1%10_43 0.475
R_x_PM_SDFF_X1%10_r33 x_PM_SDFF_X1%10_29 x_PM_SDFF_X1%10_27 10.92
R_x_PM_SDFF_X1%10_r34 N_10_M30_g x_PM_SDFF_X1%10_59 21.84
R_x_PM_SDFF_X1%10_r35 N_10_M10_g x_PM_SDFF_X1%10_20 26.52
R_x_PM_SDFF_X1%10_r36 x_PM_SDFF_X1%10_54 x_PM_SDFF_X1%10_19 1.95
R_x_PM_SDFF_X1%10_r37 N_10_M10_g x_PM_SDFF_X1%10_19 18.72
R_x_PM_SDFF_X1%10_r38 x_PM_SDFF_X1%10_31 x_PM_SDFF_X1%10_18 3.30287
R_x_PM_SDFF_X1%10_r39 x_PM_SDFF_X1%10_20 x_PM_SDFF_X1%10_17 4.35808
R_x_PM_SDFF_X1%10_r40 x_PM_SDFF_X1%10_18 x_PM_SDFF_X1%10_17 104.52
R_x_PM_SDFF_X1%10_r41 N_10_M7_g N_10_M26_g 89.7
R_x_PM_SDFF_X1%10_r42 x_PM_SDFF_X1%10_31 x_PM_SDFF_X1%10_11 0.858359
R_x_PM_SDFF_X1%10_r43 N_10_M7_g x_PM_SDFF_X1%10_11 47.58
R_x_PM_SDFF_X1%10_r44 x_PM_SDFF_X1%10_31 x_PM_SDFF_X1%10_9 3.30287
R_x_PM_SDFF_X1%10_r45 x_PM_SDFF_X1%10_10 x_PM_SDFF_X1%10_9 70.2
R_x_PM_SDFF_X1%10_r46 x_PM_SDFF_X1%10_10 x_PM_SDFF_X1%10_6 4.35808
R_x_PM_SDFF_X1%10_r47 N_10_M5_g x_PM_SDFF_X1%10_6 40.56
R_x_PM_SDFF_X1%10_r48 x_PM_SDFF_X1%10_29 x_PM_SDFF_X1%10_5 1.95
R_x_PM_SDFF_X1%10_r49 N_10_M5_g x_PM_SDFF_X1%10_5 46.02
R_x_PM_SDFF_X1%10_r50 x_PM_SDFF_X1%10_27 x_PM_SDFF_X1%10_VSS 1.95
R_x_PM_SDFF_X1%10_r51 N_10_M23_g x_PM_SDFF_X1%10_VSS 49.92
C_x_PM_SDFF_X1%11_c0 VSS x_PM_SDFF_X1%11_29 6.70037e-17
C_x_PM_SDFF_X1%11_c1 VSS x_PM_SDFF_X1%11_26 3.5619e-18
C_x_PM_SDFF_X1%11_c2 VSS N_11_M15_d 8.93175e-17
C_x_PM_SDFF_X1%11_c3 VSS x_PM_SDFF_X1%11_22 2.39994e-17
C_x_PM_SDFF_X1%11_c4 VSS x_PM_SDFF_X1%11_21 2.8289e-17
C_x_PM_SDFF_X1%11_c5 VSS x_PM_SDFF_X1%11_19 7.77333e-17
C_x_PM_SDFF_X1%11_c6 VSS x_PM_SDFF_X1%11_17 6.38717e-17
C_x_PM_SDFF_X1%11_c7 VSS x_PM_SDFF_X1%11_14 7.79398e-18
C_x_PM_SDFF_X1%11_c8 VSS x_PM_SDFF_X1%11_11 8.25181e-17
C_x_PM_SDFF_X1%11_c9 VSS N_11_M34_d 4.36951e-17
C_x_PM_SDFF_X1%11_c10 VSS N_11_M12_g 7.10911e-17
C_x_PM_SDFF_X1%11_c11 VSS N_11_M31_g 4.69857e-17
R_x_PM_SDFF_X1%11_r12 N_11_M15_d x_PM_SDFF_X1%11_22 2.185
R_x_PM_SDFF_X1%11_r13 x_PM_SDFF_X1%11_21 x_PM_SDFF_X1%11_29 1.81857
R_x_PM_SDFF_X1%11_r14 x_PM_SDFF_X1%11_22 x_PM_SDFF_X1%11_19 0.212317
R_x_PM_SDFF_X1%11_r15 x_PM_SDFF_X1%11_26 x_PM_SDFF_X1%11_18 0.160909
R_x_PM_SDFF_X1%11_r16 x_PM_SDFF_X1%11_19 x_PM_SDFF_X1%11_18 2.25286
R_x_PM_SDFF_X1%11_r17 x_PM_SDFF_X1%11_26 x_PM_SDFF_X1%11_17 0.160909
R_x_PM_SDFF_X1%11_r18 x_PM_SDFF_X1%11_21 x_PM_SDFF_X1%11_16 0.212317
R_x_PM_SDFF_X1%11_r19 x_PM_SDFF_X1%11_17 x_PM_SDFF_X1%11_16 1.46571
R_x_PM_SDFF_X1%11_r20 x_PM_SDFF_X1%11_33 x_PM_SDFF_X1%11_14 4.7687
R_x_PM_SDFF_X1%11_r21 x_PM_SDFF_X1%11_32 x_PM_SDFF_X1%11_14 4.7687
R_x_PM_SDFF_X1%11_r22 x_PM_SDFF_X1%11_14 x_PM_SDFF_X1%11_12 25.0012
R_x_PM_SDFF_X1%11_r23 x_PM_SDFF_X1%11_26 x_PM_SDFF_X1%11_11 0.0418175
R_x_PM_SDFF_X1%11_r24 x_PM_SDFF_X1%11_12 x_PM_SDFF_X1%11_11 1.995
R_x_PM_SDFF_X1%11_r25 x_PM_SDFF_X1%11_29 N_11_M34_d 0.297071
R_x_PM_SDFF_X1%11_r26 N_11_M12_g x_PM_SDFF_X1%11_33 85.8
R_x_PM_SDFF_X1%11_r27 N_11_M31_g x_PM_SDFF_X1%11_32 46.02
C_x_PM_SDFF_X1%CK_c0 VSS CK 6.54691e-17
C_x_PM_SDFF_X1%CK_c1 VSS x_PM_SDFF_X1%CK_11 8.53361e-18
C_x_PM_SDFF_X1%CK_c2 VSS N_CK_M13_g 5.79339e-17
C_x_PM_SDFF_X1%CK_c3 VSS N_CK_M32_g 7.19601e-17
R_x_PM_SDFF_X1%CK_r4 x_PM_SDFF_X1%CK_18 x_PM_SDFF_X1%CK_11 4.7687
R_x_PM_SDFF_X1%CK_r5 x_PM_SDFF_X1%CK_17 x_PM_SDFF_X1%CK_11 4.7687
R_x_PM_SDFF_X1%CK_r6 x_PM_SDFF_X1%CK_11 x_PM_SDFF_X1%CK_9 25.0012
R_x_PM_SDFF_X1%CK_r7 CK x_PM_SDFF_X1%CK_9 0.2375
R_x_PM_SDFF_X1%CK_r8 N_CK_M13_g x_PM_SDFF_X1%CK_18 52.26
R_x_PM_SDFF_X1%CK_r9 N_CK_M32_g x_PM_SDFF_X1%CK_17 72.54
C_x_PM_SDFF_X1%SI_c0 VSS x_PM_SDFF_X1%SI_28 1.23786e-17
C_x_PM_SDFF_X1%SI_c1 VSS x_PM_SDFF_X1%SI_19 1.61339e-16
C_x_PM_SDFF_X1%SI_c2 VSS x_PM_SDFF_X1%SI_18 2.28512e-17
C_x_PM_SDFF_X1%SI_c3 VSS SI 2.76784e-17
C_x_PM_SDFF_X1%SI_c4 VSS x_PM_SDFF_X1%SI_12 9.9879e-18
C_x_PM_SDFF_X1%SI_c5 VSS x_PM_SDFF_X1%SI_9 5.43069e-17
C_x_PM_SDFF_X1%SI_c6 VSS N_SI_M36_g 6.59501e-17
C_x_PM_SDFF_X1%SI_c7 VSS N_SI_M14_g 4.41008e-17
R_x_PM_SDFF_X1%SI_r8 x_PM_SDFF_X1%SI_28 x_PM_SDFF_X1%SI_21 1.82
R_x_PM_SDFF_X1%SI_r9 x_PM_SDFF_X1%SI_21 x_PM_SDFF_X1%SI_19 25.0012
R_x_PM_SDFF_X1%SI_r10 x_PM_SDFF_X1%SI_19 x_PM_SDFF_X1%SI_18 2.40214
R_x_PM_SDFF_X1%SI_r11 SI x_PM_SDFF_X1%SI_15 0.787143
R_x_PM_SDFF_X1%SI_r12 x_PM_SDFF_X1%SI_18 x_PM_SDFF_X1%SI_14 0.212317
R_x_PM_SDFF_X1%SI_r13 SI x_PM_SDFF_X1%SI_14 0.38
R_x_PM_SDFF_X1%SI_r14 x_PM_SDFF_X1%SI_25 x_PM_SDFF_X1%SI_12 4.7687
R_x_PM_SDFF_X1%SI_r15 x_PM_SDFF_X1%SI_12 x_PM_SDFF_X1%SI_10 25.0012
R_x_PM_SDFF_X1%SI_r16 x_PM_SDFF_X1%SI_15 x_PM_SDFF_X1%SI_9 0.212317
R_x_PM_SDFF_X1%SI_r17 x_PM_SDFF_X1%SI_10 x_PM_SDFF_X1%SI_9 0.149286
R_x_PM_SDFF_X1%SI_r18 x_PM_SDFF_X1%SI_28 x_PM_SDFF_X1%SI_5 1.95
R_x_PM_SDFF_X1%SI_r19 N_SI_M36_g x_PM_SDFF_X1%SI_5 69.42
R_x_PM_SDFF_X1%SI_r20 N_SI_M14_g x_PM_SDFF_X1%SI_25 28.86
C_x_PM_SDFF_X1%D_c0 VSS x_PM_SDFF_X1%D_23 1.11863e-17
C_x_PM_SDFF_X1%D_c1 VSS x_PM_SDFF_X1%D_20 7.44788e-17
C_x_PM_SDFF_X1%D_c2 VSS D 1.09394e-16
C_x_PM_SDFF_X1%D_c3 VSS x_PM_SDFF_X1%D_15 1.53662e-17
C_x_PM_SDFF_X1%D_c4 VSS x_PM_SDFF_X1%D_14 2.44974e-16
C_x_PM_SDFF_X1%D_c5 VSS x_PM_SDFF_X1%D_12 1.1071e-17
C_x_PM_SDFF_X1%D_c6 VSS x_PM_SDFF_X1%D_10 3.12505e-17
C_x_PM_SDFF_X1%D_c7 VSS N_D_M17_g 3.81566e-17
C_x_PM_SDFF_X1%D_c8 VSS N_D_M33_g 4.25756e-17
R_x_PM_SDFF_X1%D_r9 x_PM_SDFF_X1%D_30 x_PM_SDFF_X1%D_23 4.7687
R_x_PM_SDFF_X1%D_r10 x_PM_SDFF_X1%D_23 x_PM_SDFF_X1%D_21 25.0012
R_x_PM_SDFF_X1%D_r11 x_PM_SDFF_X1%D_21 D 0.0787805
R_x_PM_SDFF_X1%D_r12 x_PM_SDFF_X1%D_20 D 0.435519
R_x_PM_SDFF_X1%D_r13 x_PM_SDFF_X1%D_20 x_PM_SDFF_X1%D_16 1.11286
R_x_PM_SDFF_X1%D_r14 x_PM_SDFF_X1%D_16 x_PM_SDFF_X1%D_14 0.212317
R_x_PM_SDFF_X1%D_r15 x_PM_SDFF_X1%D_15 x_PM_SDFF_X1%D_14 3.44714
R_x_PM_SDFF_X1%D_r16 x_PM_SDFF_X1%D_26 x_PM_SDFF_X1%D_12 4.7687
R_x_PM_SDFF_X1%D_r17 x_PM_SDFF_X1%D_12 x_PM_SDFF_X1%D_10 25.0012
R_x_PM_SDFF_X1%D_r18 x_PM_SDFF_X1%D_15 x_PM_SDFF_X1%D_9 0.212317
R_x_PM_SDFF_X1%D_r19 x_PM_SDFF_X1%D_10 x_PM_SDFF_X1%D_9 0.312143
R_x_PM_SDFF_X1%D_r20 N_D_M17_g x_PM_SDFF_X1%D_30 28.86
R_x_PM_SDFF_X1%D_r21 N_D_M33_g x_PM_SDFF_X1%D_26 34.32
C_x_PM_SDFF_X1%15_c0 VSS x_PM_SDFF_X1%15_24 2.24689e-18
C_x_PM_SDFF_X1%15_c1 VSS N_15_M18_d 1.25241e-16
C_x_PM_SDFF_X1%15_c2 VSS x_PM_SDFF_X1%15_14 8.73715e-18
C_x_PM_SDFF_X1%15_c3 VSS x_PM_SDFF_X1%15_11 1.81547e-16
C_x_PM_SDFF_X1%15_c4 VSS N_15_M37_d 3.24104e-17
C_x_PM_SDFF_X1%15_c5 VSS N_15_M15_g 1.07011e-16
C_x_PM_SDFF_X1%15_c6 VSS N_15_M34_g 3.67665e-17
R_x_PM_SDFF_X1%15_r7 x_PM_SDFF_X1%15_24 x_PM_SDFF_X1%15_20 0.151873
R_x_PM_SDFF_X1%15_r8 N_15_M18_d x_PM_SDFF_X1%15_20 3.28067
R_x_PM_SDFF_X1%15_r9 x_PM_SDFF_X1%15_24 x_PM_SDFF_X1%15_16 0.151873
R_x_PM_SDFF_X1%15_r10 x_PM_SDFF_X1%15_27 x_PM_SDFF_X1%15_14 4.7687
R_x_PM_SDFF_X1%15_r11 x_PM_SDFF_X1%15_26 x_PM_SDFF_X1%15_14 4.7687
R_x_PM_SDFF_X1%15_r12 x_PM_SDFF_X1%15_14 x_PM_SDFF_X1%15_12 25.0012
R_x_PM_SDFF_X1%15_r13 x_PM_SDFF_X1%15_24 x_PM_SDFF_X1%15_11 0.0495914
R_x_PM_SDFF_X1%15_r14 x_PM_SDFF_X1%15_12 x_PM_SDFF_X1%15_11 3.35214
R_x_PM_SDFF_X1%15_r15 N_15_M37_d x_PM_SDFF_X1%15_16 0.646
R_x_PM_SDFF_X1%15_r16 N_15_M15_g x_PM_SDFF_X1%15_27 116.22
R_x_PM_SDFF_X1%15_r17 N_15_M34_g x_PM_SDFF_X1%15_26 27.3
C_x_PM_SDFF_X1%SE_c0 VSS x_PM_SDFF_X1%SE_27 7.28091e-18
C_x_PM_SDFF_X1%SE_c1 VSS x_PM_SDFF_X1%SE_23 1.06107e-16
C_x_PM_SDFF_X1%SE_c2 VSS x_PM_SDFF_X1%SE_19 6.53217e-18
C_x_PM_SDFF_X1%SE_c3 VSS N_SE_M18_g 5.98911e-17
C_x_PM_SDFF_X1%SE_c4 VSS N_SE_M37_g 9.01821e-17
C_x_PM_SDFF_X1%SE_c5 VSS x_PM_SDFF_X1%SE_9 3.52494e-17
C_x_PM_SDFF_X1%SE_c6 VSS N_SE_M16_g 4.76839e-17
C_x_PM_SDFF_X1%SE_c7 VSS N_SE_M35_g 8.34491e-17
R_x_PM_SDFF_X1%SE_r8 x_PM_SDFF_X1%SE_28 x_PM_SDFF_X1%SE_27 4.2487
R_x_PM_SDFF_X1%SE_r9 x_PM_SDFF_X1%SE_30 x_PM_SDFF_X1%SE_25 4.7687
R_x_PM_SDFF_X1%SE_r10 x_PM_SDFF_X1%SE_25 x_PM_SDFF_X1%SE_27 2.6
R_x_PM_SDFF_X1%SE_r11 x_PM_SDFF_X1%SE_25 x_PM_SDFF_X1%SE_23 25.0012
R_x_PM_SDFF_X1%SE_r12 x_PM_SDFF_X1%SE_23 SE 0.225349
R_x_PM_SDFF_X1%SE_r13 x_PM_SDFF_X1%SE_19 x_PM_SDFF_X1%SE_15 4.08464
R_x_PM_SDFF_X1%SE_r14 N_SE_M18_g x_PM_SDFF_X1%SE_15 52.26
R_x_PM_SDFF_X1%SE_r15 x_PM_SDFF_X1%SE_19 x_PM_SDFF_X1%SE_11 4.08464
R_x_PM_SDFF_X1%SE_r16 N_SE_M37_g x_PM_SDFF_X1%SE_11 92.82
R_x_PM_SDFF_X1%SE_r17 x_PM_SDFF_X1%SE_27 x_PM_SDFF_X1%SE_10 1.95
R_x_PM_SDFF_X1%SE_r18 x_PM_SDFF_X1%SE_19 x_PM_SDFF_X1%SE_9 0.266723
R_x_PM_SDFF_X1%SE_r19 x_PM_SDFF_X1%SE_10 x_PM_SDFF_X1%SE_9 36.6
R_x_PM_SDFF_X1%SE_r20 N_SE_M16_g x_PM_SDFF_X1%SE_30 47.58
R_x_PM_SDFF_X1%SE_r21 N_SE_M35_g x_PM_SDFF_X1%SE_28 92.82
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   SDFF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT SDFF_X2 VSS VDD Q QN CK SI D SE
*.PININFO VSS:B VDD:B Q:O QN:O CK:I D:I SI:I SE:I
M_M19 N_VDD_M0_d N_6_M0_g N_Q_M0_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M20 N_QN_M1_d N_5_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M21 N_VDD_M2_d N_6_M2_g N_5_M2_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M22 17 N_5_M3_g N_VDD_M2_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M23 N_6_M4_d N_7_M4_g 17 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M24 18 N_10_M5_g N_6_M4_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M25 N_VDD_M6_d N_9_M6_g 18 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M26 N_7_M7_d N_10_M7_g N_VDD_M6_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M27 N_VDD_M8_d N_9_M8_g N_8_M8_s VDD PMOS_VTL W=0.090000U L=0.050000U
M_M28 19 N_8_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.090000U L=0.050000U
M_M29 N_9_M10_d N_10_M10_g 19 VDD PMOS_VTL W=0.090000U L=0.050000U
M_M30 20 N_7_M11_g N_9_M10_d VDD PMOS_VTL W=0.180000U L=0.050000U
M_M31 N_VDD_M12_d N_11_M12_g 20 VDD PMOS_VTL W=0.180000U L=0.050000U
M_M32 N_10_M13_d N_CK_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M33 21 N_SI_M14_g N_VDD_M14_s VDD PMOS_VTL W=0.270000U L=0.050000U
M_M34 N_11_M15_d N_15_M15_g 21 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M35 22 N_SE_M16_g N_11_M15_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M36 N_VDD_M17_d N_D_M17_g 22 VDD PMOS_VTL W=0.270000U L=0.050000U
M_M37 N_15_M18_d N_SE_M18_g N_VDD_M17_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M0 N_VSS_M19_d N_6_M19_g N_Q_M19_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_QN_M20_d N_5_M20_g N_VSS_M19_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 N_VSS_M21_d N_6_M21_g N_5_M21_s VSS NMOS_VTL W=0.270000U L=0.050000U
M_M3 23 N_5_M22_g N_VSS_M21_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M4 N_6_M23_d N_10_M23_g 23 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M5 24 N_7_M24_g N_6_M23_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M6 N_VSS_M25_d N_9_M25_g 24 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_7_M26_d N_10_M26_g N_VSS_M25_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 N_VSS_M27_d N_9_M27_g N_8_M27_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M9 25 N_8_M28_g N_VSS_M27_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M10 N_9_M29_d N_7_M29_g 25 VSS NMOS_VTL W=0.090000U L=0.050000U
M_M11 26 N_10_M30_g N_9_M29_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M12 N_VSS_M31_d N_11_M31_g 26 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M13 N_10_M32_d N_CK_M32_g N_VSS_M31_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M14 27 N_D_M33_g N_VSS_M33_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M15 N_11_M34_d N_15_M34_g 27 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M16 28 N_SE_M35_g N_11_M34_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M17 N_VSS_M36_d N_SI_M36_g 28 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M18 N_15_M37_d N_SE_M37_g N_VSS_M36_d VSS NMOS_VTL W=0.180000U L=0.050000U
C_x_PM_SDFF_X2%VSS_c0 VSS N_VSS_M36_d 5.77754e-17
C_x_PM_SDFF_X2%VSS_c1 VSS x_PM_SDFF_X2%VSS_55 2.71388e-18
C_x_PM_SDFF_X2%VSS_c2 VSS x_PM_SDFF_X2%VSS_54 5.61267e-18
C_x_PM_SDFF_X2%VSS_c3 VSS x_PM_SDFF_X2%VSS_53 8.89467e-18
C_x_PM_SDFF_X2%VSS_c4 VSS x_PM_SDFF_X2%VSS_52 8.93987e-18
C_x_PM_SDFF_X2%VSS_c5 VSS x_PM_SDFF_X2%VSS_51 6.2876e-18
C_x_PM_SDFF_X2%VSS_c6 VSS x_PM_SDFF_X2%VSS_50 3.11681e-17
C_x_PM_SDFF_X2%VSS_c7 VSS x_PM_SDFF_X2%VSS_46 1.05004e-16
C_x_PM_SDFF_X2%VSS_c8 VSS N_VSS_M33_s 1.57142e-17
C_x_PM_SDFF_X2%VSS_c9 VSS x_PM_SDFF_X2%VSS_40 2.45162e-17
C_x_PM_SDFF_X2%VSS_c10 VSS N_VSS_M31_d 3.89437e-17
C_x_PM_SDFF_X2%VSS_c11 VSS x_PM_SDFF_X2%VSS_34 5.96802e-17
C_x_PM_SDFF_X2%VSS_c12 VSS VSS 5.16492e-17
C_x_PM_SDFF_X2%VSS_c13 VSS x_PM_SDFF_X2%VSS_26 4.59647e-17
C_x_PM_SDFF_X2%VSS_c14 VSS N_VSS_M25_d 5.46177e-17
C_x_PM_SDFF_X2%VSS_c15 VSS x_PM_SDFF_X2%VSS_20 5.53711e-17
C_x_PM_SDFF_X2%VSS_c16 VSS N_VSS_M21_d 2.54531e-17
C_x_PM_SDFF_X2%VSS_c17 VSS x_PM_SDFF_X2%VSS_14 4.79644e-17
C_x_PM_SDFF_X2%VSS_c18 VSS N_VSS_M19_d 2.89115e-17
R_x_PM_SDFF_X2%VSS_r19 x_PM_SDFF_X2%VSS_55 x_PM_SDFF_X2%VSS_47 0.0731438
R_x_PM_SDFF_X2%VSS_r20 x_PM_SDFF_X2%VSS_46 N_VSS_M36_d 0.140674
R_x_PM_SDFF_X2%VSS_r21 x_PM_SDFF_X2%VSS_47 x_PM_SDFF_X2%VSS_46 1.47529
R_x_PM_SDFF_X2%VSS_r22 x_PM_SDFF_X2%VSS_55 x_PM_SDFF_X2%VSS_42 0.145286
R_x_PM_SDFF_X2%VSS_r23 N_VSS_M33_s x_PM_SDFF_X2%VSS_42 0.230714
R_x_PM_SDFF_X2%VSS_r24 x_PM_SDFF_X2%VSS_54 x_PM_SDFF_X2%VSS_41 0.132285
R_x_PM_SDFF_X2%VSS_r25 x_PM_SDFF_X2%VSS_55 x_PM_SDFF_X2%VSS_40 0.0731438
R_x_PM_SDFF_X2%VSS_r26 x_PM_SDFF_X2%VSS_41 x_PM_SDFF_X2%VSS_40 0.614706
R_x_PM_SDFF_X2%VSS_r27 x_PM_SDFF_X2%VSS_54 x_PM_SDFF_X2%VSS_36 0.0680382
R_x_PM_SDFF_X2%VSS_r28 N_VSS_M31_d x_PM_SDFF_X2%VSS_36 0.358889
R_x_PM_SDFF_X2%VSS_r29 x_PM_SDFF_X2%VSS_53 x_PM_SDFF_X2%VSS_35 0.132285
R_x_PM_SDFF_X2%VSS_r30 x_PM_SDFF_X2%VSS_54 x_PM_SDFF_X2%VSS_34 0.132285
R_x_PM_SDFF_X2%VSS_r31 x_PM_SDFF_X2%VSS_35 x_PM_SDFF_X2%VSS_34 1.43059
R_x_PM_SDFF_X2%VSS_r32 N_VSS_M27_d VSS 0.394074
R_x_PM_SDFF_X2%VSS_r33 x_PM_SDFF_X2%VSS_53 x_PM_SDFF_X2%VSS_28 0.0680382
R_x_PM_SDFF_X2%VSS_r34 VSS x_PM_SDFF_X2%VSS_28 0.218148
R_x_PM_SDFF_X2%VSS_r35 x_PM_SDFF_X2%VSS_52 x_PM_SDFF_X2%VSS_27 0.132285
R_x_PM_SDFF_X2%VSS_r36 x_PM_SDFF_X2%VSS_53 x_PM_SDFF_X2%VSS_26 0.132285
R_x_PM_SDFF_X2%VSS_r37 x_PM_SDFF_X2%VSS_27 x_PM_SDFF_X2%VSS_26 0.961176
R_x_PM_SDFF_X2%VSS_r38 x_PM_SDFF_X2%VSS_52 x_PM_SDFF_X2%VSS_22 0.0680382
R_x_PM_SDFF_X2%VSS_r39 N_VSS_M25_d x_PM_SDFF_X2%VSS_22 0.823333
R_x_PM_SDFF_X2%VSS_r40 x_PM_SDFF_X2%VSS_51 x_PM_SDFF_X2%VSS_21 0.132285
R_x_PM_SDFF_X2%VSS_r41 x_PM_SDFF_X2%VSS_52 x_PM_SDFF_X2%VSS_20 0.132285
R_x_PM_SDFF_X2%VSS_r42 x_PM_SDFF_X2%VSS_21 x_PM_SDFF_X2%VSS_20 1.46412
R_x_PM_SDFF_X2%VSS_r43 x_PM_SDFF_X2%VSS_51 x_PM_SDFF_X2%VSS_16 0.0680382
R_x_PM_SDFF_X2%VSS_r44 N_VSS_M21_d x_PM_SDFF_X2%VSS_16 0.316667
R_x_PM_SDFF_X2%VSS_r45 x_PM_SDFF_X2%VSS_50 x_PM_SDFF_X2%VSS_15 0.0731438
R_x_PM_SDFF_X2%VSS_r46 x_PM_SDFF_X2%VSS_51 x_PM_SDFF_X2%VSS_14 0.132285
R_x_PM_SDFF_X2%VSS_r47 x_PM_SDFF_X2%VSS_15 x_PM_SDFF_X2%VSS_14 0.961176
R_x_PM_SDFF_X2%VSS_r48 x_PM_SDFF_X2%VSS_50 x_PM_SDFF_X2%VSS_10 0.145286
R_x_PM_SDFF_X2%VSS_r49 N_VSS_M19_d x_PM_SDFF_X2%VSS_10 0.909286
C_x_PM_SDFF_X2%VDD_c0 VSS x_PM_SDFF_X2%VDD_54 4.0711e-17
C_x_PM_SDFF_X2%VDD_c1 VSS N_VDD_M14_s 3.30005e-17
C_x_PM_SDFF_X2%VDD_c2 VSS x_PM_SDFF_X2%VDD_48 5.79633e-18
C_x_PM_SDFF_X2%VDD_c3 VSS x_PM_SDFF_X2%VDD_47 8.86015e-18
C_x_PM_SDFF_X2%VDD_c4 VSS x_PM_SDFF_X2%VDD_46 8.86015e-18
C_x_PM_SDFF_X2%VDD_c5 VSS x_PM_SDFF_X2%VDD_45 5.64357e-18
C_x_PM_SDFF_X2%VDD_c6 VSS x_PM_SDFF_X2%VDD_44 2.86332e-17
C_x_PM_SDFF_X2%VDD_c7 VSS N_VDD_M17_d 6.5332e-17
C_x_PM_SDFF_X2%VDD_c8 VSS x_PM_SDFF_X2%VDD_36 6.0133e-17
C_x_PM_SDFF_X2%VDD_c9 VSS x_PM_SDFF_X2%VDD_34 2.05323e-17
C_x_PM_SDFF_X2%VDD_c10 VSS x_PM_SDFF_X2%VDD_33 2.97988e-17
C_x_PM_SDFF_X2%VDD_c11 VSS x_PM_SDFF_X2%VDD_30 6.18128e-17
C_x_PM_SDFF_X2%VDD_c12 VSS N_VDD_M8_d 5.63434e-17
C_x_PM_SDFF_X2%VDD_c13 VSS x_PM_SDFF_X2%VDD_22 4.94635e-17
C_x_PM_SDFF_X2%VDD_c14 VSS x_PM_SDFF_X2%VDD_21 2.36161e-17
C_x_PM_SDFF_X2%VDD_c15 VSS x_PM_SDFF_X2%VDD_18 5.43052e-17
C_x_PM_SDFF_X2%VDD_c16 VSS x_PM_SDFF_X2%VDD_17 4.51117e-17
C_x_PM_SDFF_X2%VDD_c17 VSS x_PM_SDFF_X2%VDD_14 4.57219e-17
C_x_PM_SDFF_X2%VDD_c18 VSS N_VDD_M0_d 5.25793e-17
R_x_PM_SDFF_X2%VDD_r19 x_PM_SDFF_X2%VDD_52 N_VDD_M14_s 0.457407
R_x_PM_SDFF_X2%VDD_r20 x_PM_SDFF_X2%VDD_54 x_PM_SDFF_X2%VDD_38 0.0680382
R_x_PM_SDFF_X2%VDD_r21 N_VDD_M17_d x_PM_SDFF_X2%VDD_38 0.218148
R_x_PM_SDFF_X2%VDD_r22 x_PM_SDFF_X2%VDD_52 x_PM_SDFF_X2%VDD_37 0.095
R_x_PM_SDFF_X2%VDD_r23 x_PM_SDFF_X2%VDD_54 x_PM_SDFF_X2%VDD_36 0.132285
R_x_PM_SDFF_X2%VDD_r24 x_PM_SDFF_X2%VDD_37 x_PM_SDFF_X2%VDD_36 1.39706
R_x_PM_SDFF_X2%VDD_r25 x_PM_SDFF_X2%VDD_48 x_PM_SDFF_X2%VDD_35 0.132285
R_x_PM_SDFF_X2%VDD_r26 x_PM_SDFF_X2%VDD_52 x_PM_SDFF_X2%VDD_34 0.095
R_x_PM_SDFF_X2%VDD_r27 x_PM_SDFF_X2%VDD_35 x_PM_SDFF_X2%VDD_34 0.525294
R_x_PM_SDFF_X2%VDD_r28 x_PM_SDFF_X2%VDD_48 x_PM_SDFF_X2%VDD_33 0.0680382
R_x_PM_SDFF_X2%VDD_r29 x_PM_SDFF_X2%VDD_33 N_VDD_M12_d 0.403583
R_x_PM_SDFF_X2%VDD_r30 x_PM_SDFF_X2%VDD_47 x_PM_SDFF_X2%VDD_31 0.132285
R_x_PM_SDFF_X2%VDD_r31 x_PM_SDFF_X2%VDD_48 x_PM_SDFF_X2%VDD_30 0.132285
R_x_PM_SDFF_X2%VDD_r32 x_PM_SDFF_X2%VDD_31 x_PM_SDFF_X2%VDD_30 1.39706
R_x_PM_SDFF_X2%VDD_r33 VDD N_VDD_M8_d 0.358889
R_x_PM_SDFF_X2%VDD_r34 x_PM_SDFF_X2%VDD_47 x_PM_SDFF_X2%VDD_24 0.0680382
R_x_PM_SDFF_X2%VDD_r35 VDD x_PM_SDFF_X2%VDD_24 0.112593
R_x_PM_SDFF_X2%VDD_r36 x_PM_SDFF_X2%VDD_46 x_PM_SDFF_X2%VDD_23 0.132285
R_x_PM_SDFF_X2%VDD_r37 x_PM_SDFF_X2%VDD_47 x_PM_SDFF_X2%VDD_22 0.132285
R_x_PM_SDFF_X2%VDD_r38 x_PM_SDFF_X2%VDD_23 x_PM_SDFF_X2%VDD_22 1.01706
R_x_PM_SDFF_X2%VDD_r39 x_PM_SDFF_X2%VDD_46 x_PM_SDFF_X2%VDD_21 0.0680382
R_x_PM_SDFF_X2%VDD_r40 x_PM_SDFF_X2%VDD_21 N_VDD_M6_d 0.403583
R_x_PM_SDFF_X2%VDD_r41 x_PM_SDFF_X2%VDD_45 x_PM_SDFF_X2%VDD_19 0.132285
R_x_PM_SDFF_X2%VDD_r42 x_PM_SDFF_X2%VDD_46 x_PM_SDFF_X2%VDD_18 0.132285
R_x_PM_SDFF_X2%VDD_r43 x_PM_SDFF_X2%VDD_19 x_PM_SDFF_X2%VDD_18 1.43059
R_x_PM_SDFF_X2%VDD_r44 x_PM_SDFF_X2%VDD_45 x_PM_SDFF_X2%VDD_17 0.0680382
R_x_PM_SDFF_X2%VDD_r45 x_PM_SDFF_X2%VDD_17 N_VDD_M2_d 0.403583
R_x_PM_SDFF_X2%VDD_r46 x_PM_SDFF_X2%VDD_44 x_PM_SDFF_X2%VDD_15 0.132285
R_x_PM_SDFF_X2%VDD_r47 x_PM_SDFF_X2%VDD_45 x_PM_SDFF_X2%VDD_14 0.132285
R_x_PM_SDFF_X2%VDD_r48 x_PM_SDFF_X2%VDD_15 x_PM_SDFF_X2%VDD_14 0.905294
R_x_PM_SDFF_X2%VDD_r49 x_PM_SDFF_X2%VDD_44 x_PM_SDFF_X2%VDD_10 0.0680382
R_x_PM_SDFF_X2%VDD_r50 N_VDD_M0_d x_PM_SDFF_X2%VDD_10 0.218148
C_x_PM_SDFF_X2%Q_c0 VSS N_Q_M19_s 8.24998e-17
R_x_PM_SDFF_X2%Q_r1 N_Q_M0_s Q 1.95938
R_x_PM_SDFF_X2%Q_r2 Q N_Q_M19_s 1.29437
C_x_PM_SDFF_X2%QN_c0 VSS x_PM_SDFF_X2%QN_13 1.00706e-17
C_x_PM_SDFF_X2%QN_c1 VSS N_QN_M1_d 1.78943e-16
C_x_PM_SDFF_X2%QN_c2 VSS N_QN_M20_d 2.97701e-17
R_x_PM_SDFF_X2%QN_r3 N_QN_M1_d x_PM_SDFF_X2%QN_13 4.13929
R_x_PM_SDFF_X2%QN_r4 QN N_QN_M20_d 0.0111765
R_x_PM_SDFF_X2%QN_r5 x_PM_SDFF_X2%QN_13 x_PM_SDFF_X2%QN_3 0.202958
R_x_PM_SDFF_X2%QN_r6 QN x_PM_SDFF_X2%QN_3 0.122941
C_x_PM_SDFF_X2%5_c0 VSS N_5_M2_s 3.74423e-17
C_x_PM_SDFF_X2%5_c1 VSS x_PM_SDFF_X2%5_30 9.07045e-18
C_x_PM_SDFF_X2%5_c2 VSS N_5_M21_s 2.48484e-16
C_x_PM_SDFF_X2%5_c3 VSS x_PM_SDFF_X2%5_20 3.94915e-18
C_x_PM_SDFF_X2%5_c4 VSS x_PM_SDFF_X2%5_19 4.98585e-17
C_x_PM_SDFF_X2%5_c5 VSS x_PM_SDFF_X2%5_18 4.36208e-18
C_x_PM_SDFF_X2%5_c6 VSS N_5_M3_g 5.24614e-17
C_x_PM_SDFF_X2%5_c7 VSS N_5_M22_g 4.29335e-17
C_x_PM_SDFF_X2%5_c8 VSS N_5_M1_g 6.47591e-17
C_x_PM_SDFF_X2%5_c9 VSS N_5_M20_g 5.81856e-17
R_x_PM_SDFF_X2%5_r10 N_5_M2_s x_PM_SDFF_X2%5_30 0.111765
R_x_PM_SDFF_X2%5_r11 x_PM_SDFF_X2%5_35 x_PM_SDFF_X2%5_28 25.0012
R_x_PM_SDFF_X2%5_r12 x_PM_SDFF_X2%5_28 N_5_M21_s 1.73714
R_x_PM_SDFF_X2%5_r13 x_PM_SDFF_X2%5_23 x_PM_SDFF_X2%5_30 0.202958
R_x_PM_SDFF_X2%5_r14 x_PM_SDFF_X2%5_28 x_PM_SDFF_X2%5_23 1.995
R_x_PM_SDFF_X2%5_r15 x_PM_SDFF_X2%5_35 x_PM_SDFF_X2%5_19 28.86
R_x_PM_SDFF_X2%5_r16 x_PM_SDFF_X2%5_20 x_PM_SDFF_X2%5_19 0.043368
R_x_PM_SDFF_X2%5_r17 x_PM_SDFF_X2%5_35 x_PM_SDFF_X2%5_17 22.62
R_x_PM_SDFF_X2%5_r18 x_PM_SDFF_X2%5_18 x_PM_SDFF_X2%5_17 0.043368
R_x_PM_SDFF_X2%5_r19 x_PM_SDFF_X2%5_20 x_PM_SDFF_X2%5_13 4.56151
R_x_PM_SDFF_X2%5_r20 N_5_M3_g x_PM_SDFF_X2%5_13 60.84
R_x_PM_SDFF_X2%5_r21 x_PM_SDFF_X2%5_20 x_PM_SDFF_X2%5_9 4.56151
R_x_PM_SDFF_X2%5_r22 N_5_M22_g x_PM_SDFF_X2%5_9 45.24
R_x_PM_SDFF_X2%5_r23 x_PM_SDFF_X2%5_18 x_PM_SDFF_X2%5_5 4.56151
R_x_PM_SDFF_X2%5_r24 N_5_M1_g x_PM_SDFF_X2%5_5 60.84
R_x_PM_SDFF_X2%5_r25 x_PM_SDFF_X2%5_18 x_PM_SDFF_X2%5_VSS 4.56151
R_x_PM_SDFF_X2%5_r26 N_5_M20_g x_PM_SDFF_X2%5_VSS 57.72
C_x_PM_SDFF_X2%6_c0 VSS x_PM_SDFF_X2%6_33 1.25244e-17
C_x_PM_SDFF_X2%6_c1 VSS N_6_M4_d 6.60014e-17
C_x_PM_SDFF_X2%6_c2 VSS x_PM_SDFF_X2%6_24 2.44249e-17
C_x_PM_SDFF_X2%6_c3 VSS x_PM_SDFF_X2%6_23 1.4836e-17
C_x_PM_SDFF_X2%6_c4 VSS x_PM_SDFF_X2%6_21 1.29765e-16
C_x_PM_SDFF_X2%6_c5 VSS x_PM_SDFF_X2%6_20 2.51606e-17
C_x_PM_SDFF_X2%6_c6 VSS N_6_M23_d 4.38822e-17
C_x_PM_SDFF_X2%6_c7 VSS N_6_M2_g 2.76499e-17
C_x_PM_SDFF_X2%6_c8 VSS N_6_M21_g 4.16694e-17
C_x_PM_SDFF_X2%6_c9 VSS x_PM_SDFF_X2%6_8 6.74557e-18
C_x_PM_SDFF_X2%6_c10 VSS x_PM_SDFF_X2%6_7 6.11774e-17
C_x_PM_SDFF_X2%6_c11 VSS N_6_M19_g 1.36109e-16
R_x_PM_SDFF_X2%6_r12 x_PM_SDFF_X2%6_33 x_PM_SDFF_X2%6_38 2.34
R_x_PM_SDFF_X2%6_r13 x_PM_SDFF_X2%6_33 x_PM_SDFF_X2%6_32 25.0012
R_x_PM_SDFF_X2%6_r14 x_PM_SDFF_X2%6_32 x_PM_SDFF_X2%6_28 0.198162
R_x_PM_SDFF_X2%6_r15 N_6_M4_d x_PM_SDFF_X2%6_28 2.34786
R_x_PM_SDFF_X2%6_r16 x_PM_SDFF_X2%6_23 x_PM_SDFF_X2%6_34 3.9
R_x_PM_SDFF_X2%6_r17 x_PM_SDFF_X2%6_23 x_PM_SDFF_X2%6_21 25.0012
R_x_PM_SDFF_X2%6_r18 x_PM_SDFF_X2%6_32 x_PM_SDFF_X2%6_20 0.0141545
R_x_PM_SDFF_X2%6_r19 x_PM_SDFF_X2%6_21 x_PM_SDFF_X2%6_20 2.375
R_x_PM_SDFF_X2%6_r20 x_PM_SDFF_X2%6_24 x_PM_SDFF_X2%6_19 0.212317
R_x_PM_SDFF_X2%6_r21 x_PM_SDFF_X2%6_21 x_PM_SDFF_X2%6_19 0.475
R_x_PM_SDFF_X2%6_r22 N_6_M23_d x_PM_SDFF_X2%6_24 2.23929
R_x_PM_SDFF_X2%6_r23 x_PM_SDFF_X2%6_38 x_PM_SDFF_X2%6_13 1.95
R_x_PM_SDFF_X2%6_r24 N_6_M2_g x_PM_SDFF_X2%6_13 22.62
R_x_PM_SDFF_X2%6_r25 x_PM_SDFF_X2%6_34 x_PM_SDFF_X2%6_10 1.95
R_x_PM_SDFF_X2%6_r26 N_6_M21_g x_PM_SDFF_X2%6_10 28.86
R_x_PM_SDFF_X2%6_r27 N_6_M21_g x_PM_SDFF_X2%6_9 31.98
R_x_PM_SDFF_X2%6_r28 x_PM_SDFF_X2%6_9 x_PM_SDFF_X2%6_7 4.35808
R_x_PM_SDFF_X2%6_r29 x_PM_SDFF_X2%6_8 x_PM_SDFF_X2%6_7 74.88
R_x_PM_SDFF_X2%6_r30 N_6_M0_g N_6_M19_g 130.26
R_x_PM_SDFF_X2%6_r31 x_PM_SDFF_X2%6_8 x_PM_SDFF_X2%6_VSS 4.35808
R_x_PM_SDFF_X2%6_r32 N_6_M19_g x_PM_SDFF_X2%6_VSS 33.54
C_x_PM_SDFF_X2%7_c0 VSS x_PM_SDFF_X2%7_44 1.48924e-17
C_x_PM_SDFF_X2%7_c1 VSS x_PM_SDFF_X2%7_38 2.15223e-17
C_x_PM_SDFF_X2%7_c2 VSS x_PM_SDFF_X2%7_36 5.83639e-17
C_x_PM_SDFF_X2%7_c3 VSS x_PM_SDFF_X2%7_34 7.29486e-17
C_x_PM_SDFF_X2%7_c4 VSS x_PM_SDFF_X2%7_33 3.74651e-17
C_x_PM_SDFF_X2%7_c5 VSS x_PM_SDFF_X2%7_28 3.50669e-17
C_x_PM_SDFF_X2%7_c6 VSS x_PM_SDFF_X2%7_26 1.18084e-17
C_x_PM_SDFF_X2%7_c7 VSS x_PM_SDFF_X2%7_23 6.78415e-17
C_x_PM_SDFF_X2%7_c8 VSS N_7_M11_g 7.72796e-17
C_x_PM_SDFF_X2%7_c9 VSS x_PM_SDFF_X2%7_16 6.49759e-18
C_x_PM_SDFF_X2%7_c10 VSS x_PM_SDFF_X2%7_15 2.3879e-17
C_x_PM_SDFF_X2%7_c11 VSS N_7_M29_g 5.20953e-17
C_x_PM_SDFF_X2%7_c12 VSS x_PM_SDFF_X2%7_10 6.53967e-18
C_x_PM_SDFF_X2%7_c13 VSS x_PM_SDFF_X2%7_9 1.39982e-16
C_x_PM_SDFF_X2%7_c14 VSS N_7_M24_g 3.73267e-17
C_x_PM_SDFF_X2%7_c15 VSS N_7_M4_g 4.02755e-17
R_x_PM_SDFF_X2%7_r16 x_PM_SDFF_X2%7_44 x_PM_SDFF_X2%7_42 5.46
R_x_PM_SDFF_X2%7_r17 x_PM_SDFF_X2%7_38 x_PM_SDFF_X2%7_36 0.090477
R_x_PM_SDFF_X2%7_r18 x_PM_SDFF_X2%7_36 N_7_M7_d 0.431731
R_x_PM_SDFF_X2%7_r19 x_PM_SDFF_X2%7_38 x_PM_SDFF_X2%7_34 0.090477
R_x_PM_SDFF_X2%7_r20 N_7_M26_d x_PM_SDFF_X2%7_33 0.10081
R_x_PM_SDFF_X2%7_r21 x_PM_SDFF_X2%7_34 x_PM_SDFF_X2%7_33 0.647407
R_x_PM_SDFF_X2%7_r22 x_PM_SDFF_X2%7_44 x_PM_SDFF_X2%7_30 25.0012
R_x_PM_SDFF_X2%7_r23 N_7_M26_d x_PM_SDFF_X2%7_28 0.140523
R_x_PM_SDFF_X2%7_r24 x_PM_SDFF_X2%7_30 x_PM_SDFF_X2%7_28 1.91357
R_x_PM_SDFF_X2%7_r25 x_PM_SDFF_X2%7_41 x_PM_SDFF_X2%7_26 4.7687
R_x_PM_SDFF_X2%7_r26 x_PM_SDFF_X2%7_26 x_PM_SDFF_X2%7_24 25.0012
R_x_PM_SDFF_X2%7_r27 x_PM_SDFF_X2%7_38 x_PM_SDFF_X2%7_23 0.117887
R_x_PM_SDFF_X2%7_r28 x_PM_SDFF_X2%7_24 x_PM_SDFF_X2%7_23 3.24357
R_x_PM_SDFF_X2%7_r29 N_7_M11_g x_PM_SDFF_X2%7_17 76.44
R_x_PM_SDFF_X2%7_r30 x_PM_SDFF_X2%7_17 x_PM_SDFF_X2%7_15 4.35808
R_x_PM_SDFF_X2%7_r31 x_PM_SDFF_X2%7_16 x_PM_SDFF_X2%7_15 24.96
R_x_PM_SDFF_X2%7_r32 x_PM_SDFF_X2%7_16 x_PM_SDFF_X2%7_12 4.35808
R_x_PM_SDFF_X2%7_r33 N_7_M29_g x_PM_SDFF_X2%7_12 38.22
R_x_PM_SDFF_X2%7_r34 N_7_M29_g x_PM_SDFF_X2%7_11 34.32
R_x_PM_SDFF_X2%7_r35 x_PM_SDFF_X2%7_11 x_PM_SDFF_X2%7_9 4.35808
R_x_PM_SDFF_X2%7_r36 x_PM_SDFF_X2%7_10 x_PM_SDFF_X2%7_9 169.26
R_x_PM_SDFF_X2%7_r37 x_PM_SDFF_X2%7_42 x_PM_SDFF_X2%7_6 1.95
R_x_PM_SDFF_X2%7_r38 N_7_M24_g x_PM_SDFF_X2%7_6 17.16
R_x_PM_SDFF_X2%7_r39 x_PM_SDFF_X2%7_10 x_PM_SDFF_X2%7_5 4.35808
R_x_PM_SDFF_X2%7_r40 N_7_M24_g x_PM_SDFF_X2%7_5 46.02
R_x_PM_SDFF_X2%7_r41 N_7_M4_g x_PM_SDFF_X2%7_41 42.12
C_x_PM_SDFF_X2%8_c0 VSS x_PM_SDFF_X2%8_26 9.82669e-18
C_x_PM_SDFF_X2%8_c1 VSS x_PM_SDFF_X2%8_18 7.15343e-17
C_x_PM_SDFF_X2%8_c2 VSS x_PM_SDFF_X2%8_17 7.34378e-17
C_x_PM_SDFF_X2%8_c3 VSS N_8_M27_s 1.49571e-16
C_x_PM_SDFF_X2%8_c4 VSS N_8_M9_g 2.31786e-17
C_x_PM_SDFF_X2%8_c5 VSS N_8_M28_g 7.99807e-17
R_x_PM_SDFF_X2%8_r6 x_PM_SDFF_X2%8_26 x_PM_SDFF_X2%8_25 2.08
R_x_PM_SDFF_X2%8_r7 x_PM_SDFF_X2%8_25 x_PM_SDFF_X2%8_23 0.26
R_x_PM_SDFF_X2%8_r8 N_8_M8_s x_PM_SDFF_X2%8_18 0.436296
R_x_PM_SDFF_X2%8_r9 x_PM_SDFF_X2%8_19 x_PM_SDFF_X2%8_18 0.252561
R_x_PM_SDFF_X2%8_r10 x_PM_SDFF_X2%8_18 x_PM_SDFF_X2%8_17 0.095
R_x_PM_SDFF_X2%8_r11 x_PM_SDFF_X2%8_17 x_PM_SDFF_X2%8_15 0.502102
R_x_PM_SDFF_X2%8_r12 x_PM_SDFF_X2%8_23 x_PM_SDFF_X2%8_15 25.0012
R_x_PM_SDFF_X2%8_r13 N_8_M27_s x_PM_SDFF_X2%8_19 2.81437
R_x_PM_SDFF_X2%8_r14 x_PM_SDFF_X2%8_26 x_PM_SDFF_X2%8_5 1.95
R_x_PM_SDFF_X2%8_r15 N_8_M9_g x_PM_SDFF_X2%8_5 19.5
R_x_PM_SDFF_X2%8_r16 x_PM_SDFF_X2%8_25 x_PM_SDFF_X2%8_VSS 1.95
R_x_PM_SDFF_X2%8_r17 N_8_M28_g x_PM_SDFF_X2%8_VSS 98.28
C_x_PM_SDFF_X2%9_c0 VSS x_PM_SDFF_X2%9_32 1.03185e-17
C_x_PM_SDFF_X2%9_c1 VSS x_PM_SDFF_X2%9_31 5.17476e-17
C_x_PM_SDFF_X2%9_c2 VSS x_PM_SDFF_X2%9_26 1.17175e-17
C_x_PM_SDFF_X2%9_c3 VSS x_PM_SDFF_X2%9_25 8.43463e-17
C_x_PM_SDFF_X2%9_c4 VSS x_PM_SDFF_X2%9_23 4.94141e-18
C_x_PM_SDFF_X2%9_c5 VSS x_PM_SDFF_X2%9_21 7.03708e-17
C_x_PM_SDFF_X2%9_c6 VSS x_PM_SDFF_X2%9_20 1.17621e-17
C_x_PM_SDFF_X2%9_c7 VSS N_9_M29_d 2.791e-17
C_x_PM_SDFF_X2%9_c8 VSS N_9_M8_g 8.55569e-17
C_x_PM_SDFF_X2%9_c9 VSS N_9_M27_g 2.47758e-17
C_x_PM_SDFF_X2%9_c10 VSS x_PM_SDFF_X2%9_8 7.99517e-18
C_x_PM_SDFF_X2%9_c11 VSS x_PM_SDFF_X2%9_7 6.59719e-17
C_x_PM_SDFF_X2%9_c12 VSS N_9_M25_g 1.06321e-16
R_x_PM_SDFF_X2%9_r13 x_PM_SDFF_X2%9_35 x_PM_SDFF_X2%9_33 1.56
R_x_PM_SDFF_X2%9_r14 x_PM_SDFF_X2%9_31 N_9_M10_d 0.570339
R_x_PM_SDFF_X2%9_r15 x_PM_SDFF_X2%9_31 x_PM_SDFF_X2%9_25 0.212317
R_x_PM_SDFF_X2%9_r16 x_PM_SDFF_X2%9_32 x_PM_SDFF_X2%9_24 0.266978
R_x_PM_SDFF_X2%9_r17 x_PM_SDFF_X2%9_25 x_PM_SDFF_X2%9_24 2.93143
R_x_PM_SDFF_X2%9_r18 x_PM_SDFF_X2%9_32 x_PM_SDFF_X2%9_23 0.266978
R_x_PM_SDFF_X2%9_r19 x_PM_SDFF_X2%9_26 x_PM_SDFF_X2%9_22 0.212317
R_x_PM_SDFF_X2%9_r20 x_PM_SDFF_X2%9_23 x_PM_SDFF_X2%9_22 0.352857
R_x_PM_SDFF_X2%9_r21 x_PM_SDFF_X2%9_32 x_PM_SDFF_X2%9_21 0.0272847
R_x_PM_SDFF_X2%9_r22 x_PM_SDFF_X2%9_20 x_PM_SDFF_X2%9_35 1.3
R_x_PM_SDFF_X2%9_r23 x_PM_SDFF_X2%9_21 x_PM_SDFF_X2%9_19 0.656916
R_x_PM_SDFF_X2%9_r24 x_PM_SDFF_X2%9_20 x_PM_SDFF_X2%9_19 25.0012
R_x_PM_SDFF_X2%9_r25 N_9_M29_d x_PM_SDFF_X2%9_26 0.637857
R_x_PM_SDFF_X2%9_r26 x_PM_SDFF_X2%9_35 x_PM_SDFF_X2%9_13 1.95
R_x_PM_SDFF_X2%9_r27 N_9_M8_g x_PM_SDFF_X2%9_13 95.94
R_x_PM_SDFF_X2%9_r28 x_PM_SDFF_X2%9_33 x_PM_SDFF_X2%9_10 1.95
R_x_PM_SDFF_X2%9_r29 N_9_M27_g x_PM_SDFF_X2%9_10 21.84
R_x_PM_SDFF_X2%9_r30 N_9_M27_g x_PM_SDFF_X2%9_9 14.82
R_x_PM_SDFF_X2%9_r31 x_PM_SDFF_X2%9_9 x_PM_SDFF_X2%9_7 4.35808
R_x_PM_SDFF_X2%9_r32 x_PM_SDFF_X2%9_8 x_PM_SDFF_X2%9_7 80.34
R_x_PM_SDFF_X2%9_r33 N_9_M6_g N_9_M25_g 103.74
R_x_PM_SDFF_X2%9_r34 x_PM_SDFF_X2%9_8 x_PM_SDFF_X2%9_VSS 4.35808
R_x_PM_SDFF_X2%9_r35 N_9_M25_g x_PM_SDFF_X2%9_VSS 26.52
C_x_PM_SDFF_X2%10_c0 VSS x_PM_SDFF_X2%10_48 6.81324e-18
C_x_PM_SDFF_X2%10_c1 VSS N_10_M13_d 2.67375e-17
C_x_PM_SDFF_X2%10_c2 VSS x_PM_SDFF_X2%10_42 7.05063e-17
C_x_PM_SDFF_X2%10_c3 VSS x_PM_SDFF_X2%10_41 1.50978e-17
C_x_PM_SDFF_X2%10_c4 VSS x_PM_SDFF_X2%10_40 5.09044e-17
C_x_PM_SDFF_X2%10_c5 VSS x_PM_SDFF_X2%10_39 1.48761e-17
C_x_PM_SDFF_X2%10_c6 VSS x_PM_SDFF_X2%10_37 5.01815e-17
C_x_PM_SDFF_X2%10_c7 VSS x_PM_SDFF_X2%10_34 7.74536e-17
C_x_PM_SDFF_X2%10_c8 VSS x_PM_SDFF_X2%10_33 1.41697e-17
C_x_PM_SDFF_X2%10_c9 VSS N_10_M32_d 2.48219e-17
C_x_PM_SDFF_X2%10_c10 VSS x_PM_SDFF_X2%10_29 3.01228e-18
C_x_PM_SDFF_X2%10_c11 VSS N_10_M30_g 2.83723e-17
C_x_PM_SDFF_X2%10_c12 VSS N_10_M10_g 3.72035e-17
C_x_PM_SDFF_X2%10_c13 VSS x_PM_SDFF_X2%10_19 9.29635e-17
C_x_PM_SDFF_X2%10_c14 VSS N_10_M26_g 1.21331e-16
C_x_PM_SDFF_X2%10_c15 VSS x_PM_SDFF_X2%10_12 6.58214e-18
C_x_PM_SDFF_X2%10_c16 VSS x_PM_SDFF_X2%10_11 3.53154e-17
C_x_PM_SDFF_X2%10_c17 VSS N_10_M5_g 5.75536e-17
C_x_PM_SDFF_X2%10_c18 VSS x_PM_SDFF_X2%10_6 6.05434e-18
C_x_PM_SDFF_X2%10_c19 VSS x_PM_SDFF_X2%10_5 2.31552e-17
C_x_PM_SDFF_X2%10_c20 VSS N_10_M23_g 4.12188e-17
R_x_PM_SDFF_X2%10_r21 N_10_M13_d x_PM_SDFF_X2%10_44 0.203571
R_x_PM_SDFF_X2%10_r22 x_PM_SDFF_X2%10_48 x_PM_SDFF_X2%10_43 0.106697
R_x_PM_SDFF_X2%10_r23 x_PM_SDFF_X2%10_44 x_PM_SDFF_X2%10_42 0.212317
R_x_PM_SDFF_X2%10_r24 x_PM_SDFF_X2%10_43 x_PM_SDFF_X2%10_42 1.9
R_x_PM_SDFF_X2%10_r25 x_PM_SDFF_X2%10_52 x_PM_SDFF_X2%10_40 0.095
R_x_PM_SDFF_X2%10_r26 x_PM_SDFF_X2%10_41 x_PM_SDFF_X2%10_40 1.87286
R_x_PM_SDFF_X2%10_r27 x_PM_SDFF_X2%10_39 x_PM_SDFF_X2%10_58 5.46
R_x_PM_SDFF_X2%10_r28 x_PM_SDFF_X2%10_39 x_PM_SDFF_X2%10_37 25.0012
R_x_PM_SDFF_X2%10_r29 x_PM_SDFF_X2%10_48 x_PM_SDFF_X2%10_36 0.0964027
R_x_PM_SDFF_X2%10_r30 x_PM_SDFF_X2%10_37 x_PM_SDFF_X2%10_36 2.21214
R_x_PM_SDFF_X2%10_r31 x_PM_SDFF_X2%10_41 x_PM_SDFF_X2%10_35 0.212317
R_x_PM_SDFF_X2%10_r32 x_PM_SDFF_X2%10_37 x_PM_SDFF_X2%10_35 0.312143
R_x_PM_SDFF_X2%10_r33 x_PM_SDFF_X2%10_48 x_PM_SDFF_X2%10_34 0.106697
R_x_PM_SDFF_X2%10_r34 x_PM_SDFF_X2%10_33 x_PM_SDFF_X2%10_54 5.46
R_x_PM_SDFF_X2%10_r35 x_PM_SDFF_X2%10_34 x_PM_SDFF_X2%10_32 0.325251
R_x_PM_SDFF_X2%10_r36 x_PM_SDFF_X2%10_33 x_PM_SDFF_X2%10_32 25.0012
R_x_PM_SDFF_X2%10_r37 x_PM_SDFF_X2%10_52 N_10_M32_d 0.176429
R_x_PM_SDFF_X2%10_r38 x_PM_SDFF_X2%10_58 x_PM_SDFF_X2%10_25 1.95
R_x_PM_SDFF_X2%10_r39 N_10_M30_g x_PM_SDFF_X2%10_25 21.84
R_x_PM_SDFF_X2%10_r40 N_10_M10_g x_PM_SDFF_X2%10_22 26.52
R_x_PM_SDFF_X2%10_r41 x_PM_SDFF_X2%10_54 x_PM_SDFF_X2%10_21 1.95
R_x_PM_SDFF_X2%10_r42 N_10_M10_g x_PM_SDFF_X2%10_21 28.86
R_x_PM_SDFF_X2%10_r43 x_PM_SDFF_X2%10_29 x_PM_SDFF_X2%10_20 3.30287
R_x_PM_SDFF_X2%10_r44 x_PM_SDFF_X2%10_22 x_PM_SDFF_X2%10_19 4.35808
R_x_PM_SDFF_X2%10_r45 x_PM_SDFF_X2%10_20 x_PM_SDFF_X2%10_19 113.1
R_x_PM_SDFF_X2%10_r46 N_10_M7_g N_10_M26_g 103.74
R_x_PM_SDFF_X2%10_r47 x_PM_SDFF_X2%10_29 x_PM_SDFF_X2%10_13 0.858359
R_x_PM_SDFF_X2%10_r48 N_10_M7_g x_PM_SDFF_X2%10_13 33.54
R_x_PM_SDFF_X2%10_r49 x_PM_SDFF_X2%10_29 x_PM_SDFF_X2%10_11 3.30287
R_x_PM_SDFF_X2%10_r50 x_PM_SDFF_X2%10_12 x_PM_SDFF_X2%10_11 51.48
R_x_PM_SDFF_X2%10_r51 x_PM_SDFF_X2%10_12 x_PM_SDFF_X2%10_8 4.35808
R_x_PM_SDFF_X2%10_r52 N_10_M5_g x_PM_SDFF_X2%10_8 40.56
R_x_PM_SDFF_X2%10_r53 N_10_M5_g x_PM_SDFF_X2%10_7 51.48
R_x_PM_SDFF_X2%10_r54 x_PM_SDFF_X2%10_7 x_PM_SDFF_X2%10_5 4.35808
R_x_PM_SDFF_X2%10_r55 x_PM_SDFF_X2%10_6 x_PM_SDFF_X2%10_5 24.18
R_x_PM_SDFF_X2%10_r56 x_PM_SDFF_X2%10_6 x_PM_SDFF_X2%10_VSS 4.35808
R_x_PM_SDFF_X2%10_r57 N_10_M23_g x_PM_SDFF_X2%10_VSS 44.46
C_x_PM_SDFF_X2%11_c0 VSS x_PM_SDFF_X2%11_34 1.03845e-17
C_x_PM_SDFF_X2%11_c1 VSS x_PM_SDFF_X2%11_32 7.55894e-18
C_x_PM_SDFF_X2%11_c2 VSS x_PM_SDFF_X2%11_28 2.2523e-17
C_x_PM_SDFF_X2%11_c3 VSS x_PM_SDFF_X2%11_27 1.56378e-17
C_x_PM_SDFF_X2%11_c4 VSS N_11_M15_d 8.70997e-17
C_x_PM_SDFF_X2%11_c5 VSS x_PM_SDFF_X2%11_22 2.76397e-17
C_x_PM_SDFF_X2%11_c6 VSS x_PM_SDFF_X2%11_21 1.45744e-17
C_x_PM_SDFF_X2%11_c7 VSS x_PM_SDFF_X2%11_20 3.82638e-17
C_x_PM_SDFF_X2%11_c8 VSS x_PM_SDFF_X2%11_19 7.99733e-17
C_x_PM_SDFF_X2%11_c9 VSS x_PM_SDFF_X2%11_17 1.67025e-17
C_x_PM_SDFF_X2%11_c10 VSS x_PM_SDFF_X2%11_11 7.56477e-17
C_x_PM_SDFF_X2%11_c11 VSS N_11_M34_d 7.62637e-17
C_x_PM_SDFF_X2%11_c12 VSS N_11_M12_g 6.18064e-17
C_x_PM_SDFF_X2%11_c13 VSS N_11_M31_g 4.77792e-17
R_x_PM_SDFF_X2%11_r14 x_PM_SDFF_X2%11_34 x_PM_SDFF_X2%11_33 0.539419
R_x_PM_SDFF_X2%11_r15 x_PM_SDFF_X2%11_28 x_PM_SDFF_X2%11_26 0.212317
R_x_PM_SDFF_X2%11_r16 x_PM_SDFF_X2%11_27 x_PM_SDFF_X2%11_26 0.597143
R_x_PM_SDFF_X2%11_r17 N_11_M15_d x_PM_SDFF_X2%11_22 2.13071
R_x_PM_SDFF_X2%11_r18 x_PM_SDFF_X2%11_27 x_PM_SDFF_X2%11_20 0.212317
R_x_PM_SDFF_X2%11_r19 x_PM_SDFF_X2%11_21 x_PM_SDFF_X2%11_20 0.624286
R_x_PM_SDFF_X2%11_r20 x_PM_SDFF_X2%11_22 x_PM_SDFF_X2%11_19 0.212317
R_x_PM_SDFF_X2%11_r21 x_PM_SDFF_X2%11_32 x_PM_SDFF_X2%11_18 0.160909
R_x_PM_SDFF_X2%11_r22 x_PM_SDFF_X2%11_19 x_PM_SDFF_X2%11_18 2.25286
R_x_PM_SDFF_X2%11_r23 x_PM_SDFF_X2%11_32 x_PM_SDFF_X2%11_17 0.160909
R_x_PM_SDFF_X2%11_r24 x_PM_SDFF_X2%11_21 x_PM_SDFF_X2%11_16 0.212317
R_x_PM_SDFF_X2%11_r25 x_PM_SDFF_X2%11_17 x_PM_SDFF_X2%11_16 0.814286
R_x_PM_SDFF_X2%11_r26 x_PM_SDFF_X2%11_14 x_PM_SDFF_X2%11_34 2.9668
R_x_PM_SDFF_X2%11_r27 x_PM_SDFF_X2%11_14 x_PM_SDFF_X2%11_12 25.0012
R_x_PM_SDFF_X2%11_r28 x_PM_SDFF_X2%11_32 x_PM_SDFF_X2%11_11 0.0418175
R_x_PM_SDFF_X2%11_r29 x_PM_SDFF_X2%11_12 x_PM_SDFF_X2%11_11 1.91357
R_x_PM_SDFF_X2%11_r30 N_11_M34_d x_PM_SDFF_X2%11_28 1.12643
R_x_PM_SDFF_X2%11_r31 x_PM_SDFF_X2%11_34 x_PM_SDFF_X2%11_5 2.02282
R_x_PM_SDFF_X2%11_r32 N_11_M12_g x_PM_SDFF_X2%11_5 71.76
R_x_PM_SDFF_X2%11_r33 x_PM_SDFF_X2%11_33 x_PM_SDFF_X2%11_VSS 2.02282
R_x_PM_SDFF_X2%11_r34 N_11_M31_g x_PM_SDFF_X2%11_VSS 46.02
C_x_PM_SDFF_X2%CK_c0 VSS x_PM_SDFF_X2%CK_14 8.71927e-18
C_x_PM_SDFF_X2%CK_c1 VSS x_PM_SDFF_X2%CK_12 7.44259e-17
C_x_PM_SDFF_X2%CK_c2 VSS N_CK_M13_g 6.14316e-17
C_x_PM_SDFF_X2%CK_c3 VSS N_CK_M32_g 6.90923e-17
R_x_PM_SDFF_X2%CK_r4 x_PM_SDFF_X2%CK_18 x_PM_SDFF_X2%CK_14 4.7687
R_x_PM_SDFF_X2%CK_r5 x_PM_SDFF_X2%CK_17 x_PM_SDFF_X2%CK_14 4.7687
R_x_PM_SDFF_X2%CK_r6 x_PM_SDFF_X2%CK_14 x_PM_SDFF_X2%CK_12 25.0012
R_x_PM_SDFF_X2%CK_r7 x_PM_SDFF_X2%CK_12 CK 0.196786
R_x_PM_SDFF_X2%CK_r8 N_CK_M13_g x_PM_SDFF_X2%CK_18 57.72
R_x_PM_SDFF_X2%CK_r9 N_CK_M32_g x_PM_SDFF_X2%CK_17 67.08
C_x_PM_SDFF_X2%D_c0 VSS x_PM_SDFF_X2%D_28 6.81608e-17
C_x_PM_SDFF_X2%D_c1 VSS x_PM_SDFF_X2%D_26 1.20169e-17
C_x_PM_SDFF_X2%D_c2 VSS x_PM_SDFF_X2%D_20 2.62249e-17
C_x_PM_SDFF_X2%D_c3 VSS D 6.19146e-17
C_x_PM_SDFF_X2%D_c4 VSS x_PM_SDFF_X2%D_14 8.15124e-17
C_x_PM_SDFF_X2%D_c5 VSS x_PM_SDFF_X2%D_12 1.11127e-17
C_x_PM_SDFF_X2%D_c6 VSS x_PM_SDFF_X2%D_9 9.3763e-17
C_x_PM_SDFF_X2%D_c7 VSS N_D_M17_g 3.81068e-17
C_x_PM_SDFF_X2%D_c8 VSS N_D_M33_g 5.93978e-17
R_x_PM_SDFF_X2%D_r9 x_PM_SDFF_X2%D_36 x_PM_SDFF_X2%D_26 4.7687
R_x_PM_SDFF_X2%D_r10 x_PM_SDFF_X2%D_26 x_PM_SDFF_X2%D_24 25.0012
R_x_PM_SDFF_X2%D_r11 x_PM_SDFF_X2%D_28 x_PM_SDFF_X2%D_24 0.358889
R_x_PM_SDFF_X2%D_r12 x_PM_SDFF_X2%D_22 x_PM_SDFF_X2%D_20 0.217143
R_x_PM_SDFF_X2%D_r13 x_PM_SDFF_X2%D_28 x_PM_SDFF_X2%D_17 0.095
R_x_PM_SDFF_X2%D_r14 D x_PM_SDFF_X2%D_17 1.19429
R_x_PM_SDFF_X2%D_r15 D x_PM_SDFF_X2%D_16 0.461429
R_x_PM_SDFF_X2%D_r16 x_PM_SDFF_X2%D_20 x_PM_SDFF_X2%D_15 0.095
R_x_PM_SDFF_X2%D_r17 x_PM_SDFF_X2%D_16 x_PM_SDFF_X2%D_14 0.212317
R_x_PM_SDFF_X2%D_r18 x_PM_SDFF_X2%D_15 x_PM_SDFF_X2%D_14 1.43857
R_x_PM_SDFF_X2%D_r19 x_PM_SDFF_X2%D_12 x_PM_SDFF_X2%D_30 2.34
R_x_PM_SDFF_X2%D_r20 x_PM_SDFF_X2%D_12 x_PM_SDFF_X2%D_10 25.0012
R_x_PM_SDFF_X2%D_r21 x_PM_SDFF_X2%D_22 x_PM_SDFF_X2%D_9 0.095
R_x_PM_SDFF_X2%D_r22 x_PM_SDFF_X2%D_10 x_PM_SDFF_X2%D_9 1.58786
R_x_PM_SDFF_X2%D_r23 N_D_M17_g x_PM_SDFF_X2%D_36 28.86
R_x_PM_SDFF_X2%D_r24 x_PM_SDFF_X2%D_30 x_PM_SDFF_X2%D_VSS 1.95
R_x_PM_SDFF_X2%D_r25 N_D_M33_g x_PM_SDFF_X2%D_VSS 51.48
C_x_PM_SDFF_X2%SI_c0 VSS x_PM_SDFF_X2%SI_32 1.95632e-17
C_x_PM_SDFF_X2%SI_c1 VSS x_PM_SDFF_X2%SI_21 6.08989e-17
C_x_PM_SDFF_X2%SI_c2 VSS x_PM_SDFF_X2%SI_19 8.94283e-17
C_x_PM_SDFF_X2%SI_c3 VSS x_PM_SDFF_X2%SI_17 1.13746e-17
C_x_PM_SDFF_X2%SI_c4 VSS x_PM_SDFF_X2%SI_14 2.12939e-17
C_x_PM_SDFF_X2%SI_c5 VSS x_PM_SDFF_X2%SI_13 9.16521e-17
C_x_PM_SDFF_X2%SI_c6 VSS SI 1.73739e-17
C_x_PM_SDFF_X2%SI_c7 VSS N_SI_M36_g 6.44692e-17
C_x_PM_SDFF_X2%SI_c8 VSS N_SI_M14_g 4.31428e-17
R_x_PM_SDFF_X2%SI_r9 x_PM_SDFF_X2%SI_32 x_PM_SDFF_X2%SI_23 5.46
R_x_PM_SDFF_X2%SI_r10 x_PM_SDFF_X2%SI_23 x_PM_SDFF_X2%SI_21 25.0012
R_x_PM_SDFF_X2%SI_r11 x_PM_SDFF_X2%SI_25 x_PM_SDFF_X2%SI_21 0.11963
R_x_PM_SDFF_X2%SI_r12 x_PM_SDFF_X2%SI_29 x_PM_SDFF_X2%SI_17 4.7687
R_x_PM_SDFF_X2%SI_r13 x_PM_SDFF_X2%SI_17 x_PM_SDFF_X2%SI_15 25.0012
R_x_PM_SDFF_X2%SI_r14 x_PM_SDFF_X2%SI_19 x_PM_SDFF_X2%SI_15 0.358889
R_x_PM_SDFF_X2%SI_r15 x_PM_SDFF_X2%SI_25 x_PM_SDFF_X2%SI_13 0.095
R_x_PM_SDFF_X2%SI_r16 x_PM_SDFF_X2%SI_14 x_PM_SDFF_X2%SI_13 1.62857
R_x_PM_SDFF_X2%SI_r17 x_PM_SDFF_X2%SI_19 x_PM_SDFF_X2%SI_10 0.095
R_x_PM_SDFF_X2%SI_r18 SI x_PM_SDFF_X2%SI_10 0.434286
R_x_PM_SDFF_X2%SI_r19 x_PM_SDFF_X2%SI_14 x_PM_SDFF_X2%SI_9 0.212317
R_x_PM_SDFF_X2%SI_r20 SI x_PM_SDFF_X2%SI_9 0.271429
R_x_PM_SDFF_X2%SI_r21 x_PM_SDFF_X2%SI_32 x_PM_SDFF_X2%SI_5 1.95
R_x_PM_SDFF_X2%SI_r22 N_SI_M36_g x_PM_SDFF_X2%SI_5 66.3
R_x_PM_SDFF_X2%SI_r23 N_SI_M14_g x_PM_SDFF_X2%SI_29 28.86
C_x_PM_SDFF_X2%15_c0 VSS x_PM_SDFF_X2%15_27 2.18894e-18
C_x_PM_SDFF_X2%15_c1 VSS x_PM_SDFF_X2%15_25 8.74688e-18
C_x_PM_SDFF_X2%15_c2 VSS x_PM_SDFF_X2%15_21 4.82445e-17
C_x_PM_SDFF_X2%15_c3 VSS N_15_M18_d 1.29932e-16
C_x_PM_SDFF_X2%15_c4 VSS x_PM_SDFF_X2%15_11 1.0211e-16
C_x_PM_SDFF_X2%15_c5 VSS N_15_M37_d 2.60324e-17
C_x_PM_SDFF_X2%15_c6 VSS N_15_M15_g 1.04132e-16
C_x_PM_SDFF_X2%15_c7 VSS N_15_M34_g 3.42333e-17
R_x_PM_SDFF_X2%15_r8 x_PM_SDFF_X2%15_30 x_PM_SDFF_X2%15_25 4.7687
R_x_PM_SDFF_X2%15_r9 x_PM_SDFF_X2%15_29 x_PM_SDFF_X2%15_25 4.7687
R_x_PM_SDFF_X2%15_r10 x_PM_SDFF_X2%15_25 x_PM_SDFF_X2%15_23 25.0012
R_x_PM_SDFF_X2%15_r11 x_PM_SDFF_X2%15_23 x_PM_SDFF_X2%15_21 0.176429
R_x_PM_SDFF_X2%15_r12 x_PM_SDFF_X2%15_27 x_PM_SDFF_X2%15_17 0.160909
R_x_PM_SDFF_X2%15_r13 N_15_M18_d x_PM_SDFF_X2%15_17 4.38357
R_x_PM_SDFF_X2%15_r14 x_PM_SDFF_X2%15_27 x_PM_SDFF_X2%15_13 0.160909
R_x_PM_SDFF_X2%15_r15 x_PM_SDFF_X2%15_21 x_PM_SDFF_X2%15_12 0.095
R_x_PM_SDFF_X2%15_r16 x_PM_SDFF_X2%15_27 x_PM_SDFF_X2%15_11 0.0418175
R_x_PM_SDFF_X2%15_r17 x_PM_SDFF_X2%15_12 x_PM_SDFF_X2%15_11 3.25714
R_x_PM_SDFF_X2%15_r18 N_15_M37_d x_PM_SDFF_X2%15_13 0.393571
R_x_PM_SDFF_X2%15_r19 N_15_M15_g x_PM_SDFF_X2%15_30 113.88
R_x_PM_SDFF_X2%15_r20 N_15_M34_g x_PM_SDFF_X2%15_29 24.18
C_x_PM_SDFF_X2%SE_c0 VSS x_PM_SDFF_X2%SE_27 7.28068e-18
C_x_PM_SDFF_X2%SE_c1 VSS x_PM_SDFF_X2%SE_20 1.08852e-16
C_x_PM_SDFF_X2%SE_c2 VSS x_PM_SDFF_X2%SE_19 4.45005e-18
C_x_PM_SDFF_X2%SE_c3 VSS N_SE_M18_g 6.18954e-17
C_x_PM_SDFF_X2%SE_c4 VSS N_SE_M37_g 8.61666e-17
C_x_PM_SDFF_X2%SE_c5 VSS x_PM_SDFF_X2%SE_9 3.34759e-17
C_x_PM_SDFF_X2%SE_c6 VSS N_SE_M16_g 4.58525e-17
C_x_PM_SDFF_X2%SE_c7 VSS N_SE_M35_g 8.39242e-17
R_x_PM_SDFF_X2%SE_r8 x_PM_SDFF_X2%SE_28 x_PM_SDFF_X2%SE_27 3.4687
R_x_PM_SDFF_X2%SE_r9 x_PM_SDFF_X2%SE_30 x_PM_SDFF_X2%SE_22 4.7687
R_x_PM_SDFF_X2%SE_r10 x_PM_SDFF_X2%SE_22 x_PM_SDFF_X2%SE_27 3.9
R_x_PM_SDFF_X2%SE_r11 x_PM_SDFF_X2%SE_22 x_PM_SDFF_X2%SE_20 25.0012
R_x_PM_SDFF_X2%SE_r12 SE x_PM_SDFF_X2%SE_20 0.156222
R_x_PM_SDFF_X2%SE_r13 x_PM_SDFF_X2%SE_19 x_PM_SDFF_X2%SE_15 3.30287
R_x_PM_SDFF_X2%SE_r14 N_SE_M18_g x_PM_SDFF_X2%SE_15 52.26
R_x_PM_SDFF_X2%SE_r15 x_PM_SDFF_X2%SE_19 x_PM_SDFF_X2%SE_11 3.30287
R_x_PM_SDFF_X2%SE_r16 N_SE_M37_g x_PM_SDFF_X2%SE_11 89.7
R_x_PM_SDFF_X2%SE_r17 x_PM_SDFF_X2%SE_27 x_PM_SDFF_X2%SE_10 1.95
R_x_PM_SDFF_X2%SE_r18 x_PM_SDFF_X2%SE_19 x_PM_SDFF_X2%SE_9 0.858359
R_x_PM_SDFF_X2%SE_r19 x_PM_SDFF_X2%SE_10 x_PM_SDFF_X2%SE_9 47.58
R_x_PM_SDFF_X2%SE_r20 N_SE_M16_g x_PM_SDFF_X2%SE_30 44.46
R_x_PM_SDFF_X2%SE_r21 N_SE_M35_g x_PM_SDFF_X2%SE_28 89.7
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X1 VSS VDD A Z EN
*.PININFO VSS:B VDD:B A:I Z:O EN:I
M_M4 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 8 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_Z_M2_d N_EN_M2_g 8 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_VDD_M3_d N_EN_M3_g N_6_M3_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M4_d N_A_M4_g N_3_M4_s VSS NMOS_VTL W=0.095000U L=0.050000U
M_M1 9 N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_Z_M6_d N_6_M6_g 9 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_VSS_M7_d N_EN_M7_g N_6_M7_s VSS NMOS_VTL W=0.095000U L=0.050000U
C_x_PM_TBUF_X1%VSS_c0 VSS x_PM_TBUF_X1%VSS_17 3.8236e-17
C_x_PM_TBUF_X1%VSS_c1 VSS N_VSS_M7_d 1.88587e-17
C_x_PM_TBUF_X1%VSS_c2 VSS x_PM_TBUF_X1%VSS_9 1.02535e-16
C_x_PM_TBUF_X1%VSS_c3 VSS N_VSS_M4_d 2.76134e-17
R_x_PM_TBUF_X1%VSS_r4 N_VSS_M7_d x_PM_TBUF_X1%VSS_13 0.420714
R_x_PM_TBUF_X1%VSS_r5 x_PM_TBUF_X1%VSS_17 x_PM_TBUF_X1%VSS_10 0.0731438
R_x_PM_TBUF_X1%VSS_r6 VSS x_PM_TBUF_X1%VSS_10 0.614706
R_x_PM_TBUF_X1%VSS_r7 x_PM_TBUF_X1%VSS_13 x_PM_TBUF_X1%VSS_9 0.264221
R_x_PM_TBUF_X1%VSS_r8 VSS x_PM_TBUF_X1%VSS_9 0.938824
R_x_PM_TBUF_X1%VSS_r9 x_PM_TBUF_X1%VSS_17 x_PM_TBUF_X1%VSS_5 0.145286
R_x_PM_TBUF_X1%VSS_r10 N_VSS_M4_d x_PM_TBUF_X1%VSS_5 0.610714
C_x_PM_TBUF_X1%VDD_c0 VSS x_PM_TBUF_X1%VDD_20 3.00037e-17
C_x_PM_TBUF_X1%VDD_c1 VSS x_PM_TBUF_X1%VDD_19 2.75819e-18
C_x_PM_TBUF_X1%VDD_c2 VSS N_VDD_M3_d 5.83214e-17
C_x_PM_TBUF_X1%VDD_c3 VSS x_PM_TBUF_X1%VDD_11 4.32983e-17
C_x_PM_TBUF_X1%VDD_c4 VSS N_VDD_M0_d 2.09774e-17
C_x_PM_TBUF_X1%VDD_c5 VSS x_PM_TBUF_X1%VDD_3 2.90625e-17
R_x_PM_TBUF_X1%VDD_r6 x_PM_TBUF_X1%VDD_20 x_PM_TBUF_X1%VDD_13 0.145286
R_x_PM_TBUF_X1%VDD_r7 N_VDD_M3_d x_PM_TBUF_X1%VDD_13 2.10357
R_x_PM_TBUF_X1%VDD_r8 x_PM_TBUF_X1%VDD_19 x_PM_TBUF_X1%VDD_12 0.0731438
R_x_PM_TBUF_X1%VDD_r9 x_PM_TBUF_X1%VDD_20 x_PM_TBUF_X1%VDD_11 0.0731438
R_x_PM_TBUF_X1%VDD_r10 x_PM_TBUF_X1%VDD_12 x_PM_TBUF_X1%VDD_11 1.02824
R_x_PM_TBUF_X1%VDD_r11 x_PM_TBUF_X1%VDD_19 x_PM_TBUF_X1%VDD_7 0.145286
R_x_PM_TBUF_X1%VDD_r12 N_VDD_M0_d x_PM_TBUF_X1%VDD_7 0.556429
R_x_PM_TBUF_X1%VDD_r13 x_PM_TBUF_X1%VDD_19 x_PM_TBUF_X1%VDD_3 0.0731438
R_x_PM_TBUF_X1%VDD_r14 VDD x_PM_TBUF_X1%VDD_3 0.251471
C_x_PM_TBUF_X1%3_c0 VSS x_PM_TBUF_X1%3_30 1.53864e-17
C_x_PM_TBUF_X1%3_c1 VSS x_PM_TBUF_X1%3_26 2.21958e-18
C_x_PM_TBUF_X1%3_c2 VSS x_PM_TBUF_X1%3_23 5.51923e-17
C_x_PM_TBUF_X1%3_c3 VSS N_3_M0_s 2.37559e-17
C_x_PM_TBUF_X1%3_c4 VSS x_PM_TBUF_X1%3_17 2.84704e-18
C_x_PM_TBUF_X1%3_c5 VSS x_PM_TBUF_X1%3_16 6.01863e-17
C_x_PM_TBUF_X1%3_c6 VSS N_3_M4_s 4.75898e-17
C_x_PM_TBUF_X1%3_c7 VSS N_3_M1_g 9.36539e-17
C_x_PM_TBUF_X1%3_c8 VSS N_3_M5_g 3.29734e-17
R_x_PM_TBUF_X1%3_r9 x_PM_TBUF_X1%3_30 x_PM_TBUF_X1%3_28 5.46
R_x_PM_TBUF_X1%3_r10 x_PM_TBUF_X1%3_28 x_PM_TBUF_X1%3_23 25.0012
R_x_PM_TBUF_X1%3_r11 x_PM_TBUF_X1%3_26 x_PM_TBUF_X1%3_21 0.0457628
R_x_PM_TBUF_X1%3_r12 x_PM_TBUF_X1%3_23 x_PM_TBUF_X1%3_21 1.07214
R_x_PM_TBUF_X1%3_r13 N_3_M0_s x_PM_TBUF_X1%3_17 0.152
R_x_PM_TBUF_X1%3_r14 x_PM_TBUF_X1%3_16 x_PM_TBUF_X1%3_17 0.192227
R_x_PM_TBUF_X1%3_r15 x_PM_TBUF_X1%3_26 x_PM_TBUF_X1%3_15 0.156262
R_x_PM_TBUF_X1%3_r16 x_PM_TBUF_X1%3_16 x_PM_TBUF_X1%3_15 3.20286
R_x_PM_TBUF_X1%3_r17 x_PM_TBUF_X1%3_26 x_PM_TBUF_X1%3_11 0.156262
R_x_PM_TBUF_X1%3_r18 N_3_M4_s x_PM_TBUF_X1%3_11 1.05133
R_x_PM_TBUF_X1%3_r19 x_PM_TBUF_X1%3_30 x_PM_TBUF_X1%3_5 1.95
R_x_PM_TBUF_X1%3_r20 N_3_M1_g x_PM_TBUF_X1%3_5 111.15
R_x_PM_TBUF_X1%3_r21 x_PM_TBUF_X1%3_30 x_PM_TBUF_X1%3_VSS 1.95
R_x_PM_TBUF_X1%3_r22 N_3_M5_g x_PM_TBUF_X1%3_VSS 31.2
C_x_PM_TBUF_X1%A_c0 VSS A 7.298e-17
C_x_PM_TBUF_X1%A_c1 VSS x_PM_TBUF_X1%A_11 1.21885e-17
C_x_PM_TBUF_X1%A_c2 VSS N_A_M0_g 7.30889e-17
C_x_PM_TBUF_X1%A_c3 VSS N_A_M4_g 6.08811e-17
R_x_PM_TBUF_X1%A_r4 x_PM_TBUF_X1%A_11 x_PM_TBUF_X1%A_16 3.38
R_x_PM_TBUF_X1%A_r5 x_PM_TBUF_X1%A_11 x_PM_TBUF_X1%A_9 25.0012
R_x_PM_TBUF_X1%A_r6 A x_PM_TBUF_X1%A_9 0.223929
R_x_PM_TBUF_X1%A_r7 x_PM_TBUF_X1%A_16 x_PM_TBUF_X1%A_5 1.95
R_x_PM_TBUF_X1%A_r8 N_A_M0_g x_PM_TBUF_X1%A_5 79.95
R_x_PM_TBUF_X1%A_r9 x_PM_TBUF_X1%A_16 x_PM_TBUF_X1%A_VSS 1.95
R_x_PM_TBUF_X1%A_r10 N_A_M4_g x_PM_TBUF_X1%A_VSS 60.45
C_x_PM_TBUF_X1%Z_c0 VSS N_Z_M2_d 3.50986e-17
C_x_PM_TBUF_X1%Z_c1 VSS x_PM_TBUF_X1%Z_10 7.83948e-18
C_x_PM_TBUF_X1%Z_c2 VSS x_PM_TBUF_X1%Z_9 3.90222e-17
C_x_PM_TBUF_X1%Z_c3 VSS x_PM_TBUF_X1%Z_8 7.39467e-17
C_x_PM_TBUF_X1%Z_c4 VSS Z 1.50266e-16
R_x_PM_TBUF_X1%Z_r5 N_Z_M2_d x_PM_TBUF_X1%Z_11 0.447857
R_x_PM_TBUF_X1%Z_r6 x_PM_TBUF_X1%Z_11 x_PM_TBUF_X1%Z_9 0.212317
R_x_PM_TBUF_X1%Z_r7 x_PM_TBUF_X1%Z_10 x_PM_TBUF_X1%Z_9 0.515714
R_x_PM_TBUF_X1%Z_r8 x_PM_TBUF_X1%Z_8 N_Z_M6_d 0.543196
R_x_PM_TBUF_X1%Z_r9 x_PM_TBUF_X1%Z_10 x_PM_TBUF_X1%Z_4 0.212317
R_x_PM_TBUF_X1%Z_r10 Z x_PM_TBUF_X1%Z_4 1.24857
R_x_PM_TBUF_X1%Z_r11 x_PM_TBUF_X1%Z_8 x_PM_TBUF_X1%Z_3 0.212317
R_x_PM_TBUF_X1%Z_r12 Z x_PM_TBUF_X1%Z_3 2.68714
C_x_PM_TBUF_X1%6_c0 VSS x_PM_TBUF_X1%6_17 9.85684e-18
C_x_PM_TBUF_X1%6_c1 VSS x_PM_TBUF_X1%6_15 6.45518e-17
C_x_PM_TBUF_X1%6_c2 VSS x_PM_TBUF_X1%6_12 3.53217e-17
C_x_PM_TBUF_X1%6_c3 VSS N_6_M3_s 1.4187e-16
C_x_PM_TBUF_X1%6_c4 VSS x_PM_TBUF_X1%6_8 3.64354e-17
C_x_PM_TBUF_X1%6_c5 VSS x_PM_TBUF_X1%6_5 6.72126e-18
C_x_PM_TBUF_X1%6_c6 VSS N_6_M6_g 2.76714e-17
R_x_PM_TBUF_X1%6_r7 x_PM_TBUF_X1%6_17 x_PM_TBUF_X1%6_16 25.0012
R_x_PM_TBUF_X1%6_r8 x_PM_TBUF_X1%6_16 x_PM_TBUF_X1%6_13 0.0151655
R_x_PM_TBUF_X1%6_r9 x_PM_TBUF_X1%6_15 x_PM_TBUF_X1%6_12 0.241334
R_x_PM_TBUF_X1%6_r10 x_PM_TBUF_X1%6_13 x_PM_TBUF_X1%6_12 0.705714
R_x_PM_TBUF_X1%6_r11 x_PM_TBUF_X1%6_16 x_PM_TBUF_X1%6_8 0.197151
R_x_PM_TBUF_X1%6_r12 N_6_M3_s x_PM_TBUF_X1%6_8 2.48357
R_x_PM_TBUF_X1%6_r13 x_PM_TBUF_X1%6_15 N_6_M7_s 0.375435
R_x_PM_TBUF_X1%6_r14 x_PM_TBUF_X1%6_17 x_PM_TBUF_X1%6_5 7.02
R_x_PM_TBUF_X1%6_r15 x_PM_TBUF_X1%6_5 x_PM_TBUF_X1%6_VSS 4.58872
R_x_PM_TBUF_X1%6_r16 N_6_M6_g x_PM_TBUF_X1%6_VSS 17.94
C_x_PM_TBUF_X1%EN_c0 VSS x_PM_TBUF_X1%EN_22 6.37648e-18
C_x_PM_TBUF_X1%EN_c1 VSS x_PM_TBUF_X1%EN_20 3.00002e-17
C_x_PM_TBUF_X1%EN_c2 VSS N_EN_M7_g 4.85121e-17
C_x_PM_TBUF_X1%EN_c3 VSS x_PM_TBUF_X1%EN_12 7.47378e-18
C_x_PM_TBUF_X1%EN_c4 VSS x_PM_TBUF_X1%EN_11 1.33081e-17
C_x_PM_TBUF_X1%EN_c5 VSS N_EN_M3_g 4.241e-17
C_x_PM_TBUF_X1%EN_c6 VSS x_PM_TBUF_X1%EN_6 5.52025e-18
C_x_PM_TBUF_X1%EN_c7 VSS x_PM_TBUF_X1%EN_5 1.86313e-17
C_x_PM_TBUF_X1%EN_c8 VSS N_EN_M2_g 3.67334e-17
R_x_PM_TBUF_X1%EN_r9 x_PM_TBUF_X1%EN_26 x_PM_TBUF_X1%EN_22 1.3
R_x_PM_TBUF_X1%EN_r10 x_PM_TBUF_X1%EN_25 x_PM_TBUF_X1%EN_22 4.7687
R_x_PM_TBUF_X1%EN_r11 x_PM_TBUF_X1%EN_22 x_PM_TBUF_X1%EN_20 25.0012
R_x_PM_TBUF_X1%EN_r12 x_PM_TBUF_X1%EN_20 EN 0.26037
R_x_PM_TBUF_X1%EN_r13 N_EN_M7_g x_PM_TBUF_X1%EN_25 60.45
R_x_PM_TBUF_X1%EN_r14 x_PM_TBUF_X1%EN_26 x_PM_TBUF_X1%EN_11 1.95
R_x_PM_TBUF_X1%EN_r15 x_PM_TBUF_X1%EN_12 x_PM_TBUF_X1%EN_11 28.86
R_x_PM_TBUF_X1%EN_r16 N_EN_M3_g x_PM_TBUF_X1%EN_8 18.33
R_x_PM_TBUF_X1%EN_r17 x_PM_TBUF_X1%EN_12 x_PM_TBUF_X1%EN_7 4.35808
R_x_PM_TBUF_X1%EN_r18 N_EN_M3_g x_PM_TBUF_X1%EN_7 40.95
R_x_PM_TBUF_X1%EN_r19 x_PM_TBUF_X1%EN_8 x_PM_TBUF_X1%EN_5 4.35808
R_x_PM_TBUF_X1%EN_r20 x_PM_TBUF_X1%EN_6 x_PM_TBUF_X1%EN_5 15.6
R_x_PM_TBUF_X1%EN_r21 x_PM_TBUF_X1%EN_6 x_PM_TBUF_X1%EN_VSS 4.35808
R_x_PM_TBUF_X1%EN_r22 N_EN_M2_g x_PM_TBUF_X1%EN_VSS 23.01
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X16.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X16 VSS VDD A Z EN
*.PININFO VSS:B VDD:B A:I Z:O EN:I
M_M18 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M19 8 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M20 N_Z_M2_d N_EN_M2_g 8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M21 9 N_EN_M3_g N_Z_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M22 N_VDD_M4_d N_3_M4_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M23 10 N_3_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M24 N_Z_M6_d N_EN_M6_g 10 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M25 11 N_EN_M7_g N_Z_M6_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M26 N_VDD_M8_d N_3_M8_g 11 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M27 12 N_3_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M28 N_Z_M10_d N_EN_M10_g 12 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M29 13 N_EN_M11_g N_Z_M10_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M30 N_VDD_M12_d N_3_M12_g 13 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M31 14 N_3_M13_g N_VDD_M12_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M32 N_Z_M14_d N_EN_M14_g 14 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M33 15 N_EN_M15_g N_Z_M14_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M34 N_VDD_M16_d N_3_M16_g 15 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M35 N_6_M17_d N_EN_M17_g N_VDD_M16_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M18_d N_A_M18_g N_3_M18_s VSS NMOS_VTL W=0.095000U L=0.050000U
M_M1 16 N_3_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_Z_M20_d N_6_M20_g 16 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 17 N_6_M21_g N_Z_M20_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M22_d N_3_M22_g 17 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 18 N_3_M23_g N_VSS_M22_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 N_Z_M24_d N_6_M24_g 18 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 19 N_6_M25_g N_Z_M24_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M8 N_VSS_M26_d N_3_M26_g 19 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M9 20 N_3_M27_g N_VSS_M26_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M10 N_Z_M28_d N_6_M28_g 20 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M11 21 N_6_M29_g N_Z_M28_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M12 N_VSS_M30_d N_3_M30_g 21 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M13 22 N_3_M31_g N_VSS_M30_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M14 N_Z_M32_d N_6_M32_g 22 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M15 23 N_6_M33_g N_Z_M32_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M16 N_VSS_M34_d N_3_M34_g 23 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M17 N_6_M35_d N_EN_M35_g N_VSS_M34_d VSS NMOS_VTL W=0.095000U L=0.050000U
C_x_PM_TBUF_X16%VSS_c0 VSS x_PM_TBUF_X16%VSS_44 4.35427e-17
C_x_PM_TBUF_X16%VSS_c1 VSS x_PM_TBUF_X16%VSS_43 2.64443e-18
C_x_PM_TBUF_X16%VSS_c2 VSS x_PM_TBUF_X16%VSS_42 2.64443e-18
C_x_PM_TBUF_X16%VSS_c3 VSS x_PM_TBUF_X16%VSS_41 2.64443e-18
C_x_PM_TBUF_X16%VSS_c4 VSS x_PM_TBUF_X16%VSS_40 2.97303e-17
C_x_PM_TBUF_X16%VSS_c5 VSS N_VSS_M34_d 2.81122e-17
C_x_PM_TBUF_X16%VSS_c6 VSS x_PM_TBUF_X16%VSS_32 7.34557e-17
C_x_PM_TBUF_X16%VSS_c7 VSS N_VSS_M30_d 2.28898e-17
C_x_PM_TBUF_X16%VSS_c8 VSS x_PM_TBUF_X16%VSS_26 7.84054e-17
C_x_PM_TBUF_X16%VSS_c9 VSS N_VSS_M26_d 2.28747e-17
C_x_PM_TBUF_X16%VSS_c10 VSS x_PM_TBUF_X16%VSS_18 7.84054e-17
C_x_PM_TBUF_X16%VSS_c11 VSS N_VSS_M22_d 2.28747e-17
C_x_PM_TBUF_X16%VSS_c12 VSS x_PM_TBUF_X16%VSS_12 7.26929e-17
C_x_PM_TBUF_X16%VSS_c13 VSS N_VSS_M18_d 4.68774e-17
R_x_PM_TBUF_X16%VSS_r14 x_PM_TBUF_X16%VSS_44 x_PM_TBUF_X16%VSS_34 0.145286
R_x_PM_TBUF_X16%VSS_r15 N_VSS_M34_d x_PM_TBUF_X16%VSS_34 0.610714
R_x_PM_TBUF_X16%VSS_r16 x_PM_TBUF_X16%VSS_43 x_PM_TBUF_X16%VSS_33 0.0731438
R_x_PM_TBUF_X16%VSS_r17 x_PM_TBUF_X16%VSS_44 x_PM_TBUF_X16%VSS_32 0.0731438
R_x_PM_TBUF_X16%VSS_r18 x_PM_TBUF_X16%VSS_33 x_PM_TBUF_X16%VSS_32 1.55353
R_x_PM_TBUF_X16%VSS_r19 x_PM_TBUF_X16%VSS_43 x_PM_TBUF_X16%VSS_28 0.145286
R_x_PM_TBUF_X16%VSS_r20 N_VSS_M30_d x_PM_TBUF_X16%VSS_28 0.230714
R_x_PM_TBUF_X16%VSS_r21 x_PM_TBUF_X16%VSS_42 x_PM_TBUF_X16%VSS_27 0.0731438
R_x_PM_TBUF_X16%VSS_r22 x_PM_TBUF_X16%VSS_43 x_PM_TBUF_X16%VSS_26 0.0731438
R_x_PM_TBUF_X16%VSS_r23 x_PM_TBUF_X16%VSS_27 x_PM_TBUF_X16%VSS_26 1.54235
R_x_PM_TBUF_X16%VSS_r24 VSS N_VSS_M26_d 0.0542857
R_x_PM_TBUF_X16%VSS_r25 x_PM_TBUF_X16%VSS_42 x_PM_TBUF_X16%VSS_20 0.145286
R_x_PM_TBUF_X16%VSS_r26 N_VSS_M26_d x_PM_TBUF_X16%VSS_20 0.230714
R_x_PM_TBUF_X16%VSS_r27 x_PM_TBUF_X16%VSS_41 x_PM_TBUF_X16%VSS_19 0.0731438
R_x_PM_TBUF_X16%VSS_r28 x_PM_TBUF_X16%VSS_42 x_PM_TBUF_X16%VSS_18 0.0731438
R_x_PM_TBUF_X16%VSS_r29 x_PM_TBUF_X16%VSS_19 x_PM_TBUF_X16%VSS_18 1.54235
R_x_PM_TBUF_X16%VSS_r30 x_PM_TBUF_X16%VSS_41 x_PM_TBUF_X16%VSS_14 0.145286
R_x_PM_TBUF_X16%VSS_r31 N_VSS_M22_d x_PM_TBUF_X16%VSS_14 0.230714
R_x_PM_TBUF_X16%VSS_r32 x_PM_TBUF_X16%VSS_40 x_PM_TBUF_X16%VSS_13 0.0731438
R_x_PM_TBUF_X16%VSS_r33 x_PM_TBUF_X16%VSS_41 x_PM_TBUF_X16%VSS_12 0.0731438
R_x_PM_TBUF_X16%VSS_r34 x_PM_TBUF_X16%VSS_13 x_PM_TBUF_X16%VSS_12 1.54235
R_x_PM_TBUF_X16%VSS_r35 x_PM_TBUF_X16%VSS_40 x_PM_TBUF_X16%VSS_8 0.145286
R_x_PM_TBUF_X16%VSS_r36 N_VSS_M18_d x_PM_TBUF_X16%VSS_8 1.12643
C_x_PM_TBUF_X16%VDD_c0 VSS x_PM_TBUF_X16%VDD_44 3.16057e-17
C_x_PM_TBUF_X16%VDD_c1 VSS x_PM_TBUF_X16%VDD_43 4.64934e-18
C_x_PM_TBUF_X16%VDD_c2 VSS x_PM_TBUF_X16%VDD_42 4.64934e-18
C_x_PM_TBUF_X16%VDD_c3 VSS x_PM_TBUF_X16%VDD_41 4.64934e-18
C_x_PM_TBUF_X16%VDD_c4 VSS x_PM_TBUF_X16%VDD_40 2.97312e-17
C_x_PM_TBUF_X16%VDD_c5 VSS N_VDD_M16_d 6.11808e-17
C_x_PM_TBUF_X16%VDD_c6 VSS x_PM_TBUF_X16%VDD_32 6.87981e-17
C_x_PM_TBUF_X16%VDD_c7 VSS N_VDD_M12_d 3.60751e-17
C_x_PM_TBUF_X16%VDD_c8 VSS x_PM_TBUF_X16%VDD_26 6.9041e-17
C_x_PM_TBUF_X16%VDD_c9 VSS N_VDD_M8_d 3.60751e-17
C_x_PM_TBUF_X16%VDD_c10 VSS x_PM_TBUF_X16%VDD_18 6.9041e-17
C_x_PM_TBUF_X16%VDD_c11 VSS N_VDD_M4_d 3.64533e-17
C_x_PM_TBUF_X16%VDD_c12 VSS x_PM_TBUF_X16%VDD_12 6.32045e-17
C_x_PM_TBUF_X16%VDD_c13 VSS N_VDD_M0_d 2.51612e-17
R_x_PM_TBUF_X16%VDD_r14 x_PM_TBUF_X16%VDD_44 x_PM_TBUF_X16%VDD_34 0.145286
R_x_PM_TBUF_X16%VDD_r15 N_VDD_M16_d x_PM_TBUF_X16%VDD_34 2.32071
R_x_PM_TBUF_X16%VDD_r16 x_PM_TBUF_X16%VDD_43 x_PM_TBUF_X16%VDD_33 0.0731438
R_x_PM_TBUF_X16%VDD_r17 x_PM_TBUF_X16%VDD_44 x_PM_TBUF_X16%VDD_32 0.0731438
R_x_PM_TBUF_X16%VDD_r18 x_PM_TBUF_X16%VDD_33 x_PM_TBUF_X16%VDD_32 1.54235
R_x_PM_TBUF_X16%VDD_r19 x_PM_TBUF_X16%VDD_43 x_PM_TBUF_X16%VDD_28 0.145286
R_x_PM_TBUF_X16%VDD_r20 N_VDD_M12_d x_PM_TBUF_X16%VDD_28 0.909286
R_x_PM_TBUF_X16%VDD_r21 x_PM_TBUF_X16%VDD_42 x_PM_TBUF_X16%VDD_27 0.0731438
R_x_PM_TBUF_X16%VDD_r22 x_PM_TBUF_X16%VDD_43 x_PM_TBUF_X16%VDD_26 0.0731438
R_x_PM_TBUF_X16%VDD_r23 x_PM_TBUF_X16%VDD_27 x_PM_TBUF_X16%VDD_26 1.54235
R_x_PM_TBUF_X16%VDD_r24 VDD N_VDD_M8_d 0.0271429
R_x_PM_TBUF_X16%VDD_r25 x_PM_TBUF_X16%VDD_42 x_PM_TBUF_X16%VDD_20 0.145286
R_x_PM_TBUF_X16%VDD_r26 VDD x_PM_TBUF_X16%VDD_20 0.882143
R_x_PM_TBUF_X16%VDD_r27 x_PM_TBUF_X16%VDD_41 x_PM_TBUF_X16%VDD_19 0.0731438
R_x_PM_TBUF_X16%VDD_r28 x_PM_TBUF_X16%VDD_42 x_PM_TBUF_X16%VDD_18 0.0731438
R_x_PM_TBUF_X16%VDD_r29 x_PM_TBUF_X16%VDD_19 x_PM_TBUF_X16%VDD_18 1.54235
R_x_PM_TBUF_X16%VDD_r30 x_PM_TBUF_X16%VDD_41 x_PM_TBUF_X16%VDD_14 0.145286
R_x_PM_TBUF_X16%VDD_r31 N_VDD_M4_d x_PM_TBUF_X16%VDD_14 0.909286
R_x_PM_TBUF_X16%VDD_r32 x_PM_TBUF_X16%VDD_40 x_PM_TBUF_X16%VDD_13 0.0731438
R_x_PM_TBUF_X16%VDD_r33 x_PM_TBUF_X16%VDD_41 x_PM_TBUF_X16%VDD_12 0.0731438
R_x_PM_TBUF_X16%VDD_r34 x_PM_TBUF_X16%VDD_13 x_PM_TBUF_X16%VDD_12 1.54235
R_x_PM_TBUF_X16%VDD_r35 x_PM_TBUF_X16%VDD_40 x_PM_TBUF_X16%VDD_8 0.145286
R_x_PM_TBUF_X16%VDD_r36 N_VDD_M0_d x_PM_TBUF_X16%VDD_8 0.909286
C_x_PM_TBUF_X16%3_c0 VSS x_PM_TBUF_X16%3_105 3.52582e-18
C_x_PM_TBUF_X16%3_c1 VSS x_PM_TBUF_X16%3_100 3.61136e-17
C_x_PM_TBUF_X16%3_c2 VSS x_PM_TBUF_X16%3_98 2.27401e-18
C_x_PM_TBUF_X16%3_c3 VSS x_PM_TBUF_X16%3_96 2.20663e-17
C_x_PM_TBUF_X16%3_c4 VSS N_3_M0_s 4.45591e-17
C_x_PM_TBUF_X16%3_c5 VSS N_3_M18_s 6.08812e-17
C_x_PM_TBUF_X16%3_c6 VSS x_PM_TBUF_X16%3_85 5.15289e-18
C_x_PM_TBUF_X16%3_c7 VSS x_PM_TBUF_X16%3_84 6.72026e-19
C_x_PM_TBUF_X16%3_c8 VSS x_PM_TBUF_X16%3_83 6.72026e-19
C_x_PM_TBUF_X16%3_c9 VSS x_PM_TBUF_X16%3_82 6.72026e-19
C_x_PM_TBUF_X16%3_c10 VSS x_PM_TBUF_X16%3_81 6.72026e-19
C_x_PM_TBUF_X16%3_c11 VSS x_PM_TBUF_X16%3_80 6.72026e-19
C_x_PM_TBUF_X16%3_c12 VSS x_PM_TBUF_X16%3_79 6.72026e-19
C_x_PM_TBUF_X16%3_c13 VSS N_3_M16_g 5.75646e-17
C_x_PM_TBUF_X16%3_c14 VSS N_3_M34_g 5.89468e-17
C_x_PM_TBUF_X16%3_c15 VSS x_PM_TBUF_X16%3_69 5.36191e-17
C_x_PM_TBUF_X16%3_c16 VSS N_3_M13_g 4.54935e-17
C_x_PM_TBUF_X16%3_c17 VSS N_3_M31_g 4.76566e-17
C_x_PM_TBUF_X16%3_c18 VSS x_PM_TBUF_X16%3_59 8.66644e-18
C_x_PM_TBUF_X16%3_c19 VSS N_3_M12_g 4.53277e-17
C_x_PM_TBUF_X16%3_c20 VSS N_3_M30_g 4.71504e-17
C_x_PM_TBUF_X16%3_c21 VSS x_PM_TBUF_X16%3_49 5.72639e-17
C_x_PM_TBUF_X16%3_c22 VSS N_3_M9_g 4.51983e-17
C_x_PM_TBUF_X16%3_c23 VSS N_3_M27_g 4.70991e-17
C_x_PM_TBUF_X16%3_c24 VSS x_PM_TBUF_X16%3_39 8.66644e-18
C_x_PM_TBUF_X16%3_c25 VSS N_3_M8_g 4.53173e-17
C_x_PM_TBUF_X16%3_c26 VSS N_3_M26_g 4.71205e-17
C_x_PM_TBUF_X16%3_c27 VSS x_PM_TBUF_X16%3_29 5.72639e-17
C_x_PM_TBUF_X16%3_c28 VSS N_3_M5_g 4.51983e-17
C_x_PM_TBUF_X16%3_c29 VSS N_3_M23_g 4.72452e-17
C_x_PM_TBUF_X16%3_c30 VSS x_PM_TBUF_X16%3_19 8.66644e-18
C_x_PM_TBUF_X16%3_c31 VSS N_3_M4_g 4.52978e-17
C_x_PM_TBUF_X16%3_c32 VSS N_3_M22_g 4.86178e-17
C_x_PM_TBUF_X16%3_c33 VSS x_PM_TBUF_X16%3_9 5.69381e-17
C_x_PM_TBUF_X16%3_c34 VSS N_3_M1_g 5.2968e-17
C_x_PM_TBUF_X16%3_c35 VSS N_3_M19_g 5.86071e-17
R_x_PM_TBUF_X16%3_r36 x_PM_TBUF_X16%3_103 x_PM_TBUF_X16%3_100 0.218148
R_x_PM_TBUF_X16%3_r37 x_PM_TBUF_X16%3_105 x_PM_TBUF_X16%3_100 25.0012
R_x_PM_TBUF_X16%3_r38 x_PM_TBUF_X16%3_98 x_PM_TBUF_X16%3_97 0.0766861
R_x_PM_TBUF_X16%3_r39 x_PM_TBUF_X16%3_103 x_PM_TBUF_X16%3_96 0.095
R_x_PM_TBUF_X16%3_r40 x_PM_TBUF_X16%3_97 x_PM_TBUF_X16%3_96 1.11286
R_x_PM_TBUF_X16%3_r41 x_PM_TBUF_X16%3_98 x_PM_TBUF_X16%3_92 0.123935
R_x_PM_TBUF_X16%3_r42 N_3_M0_s x_PM_TBUF_X16%3_92 1.39
R_x_PM_TBUF_X16%3_r43 x_PM_TBUF_X16%3_98 x_PM_TBUF_X16%3_88 0.123935
R_x_PM_TBUF_X16%3_r44 N_3_M18_s x_PM_TBUF_X16%3_88 1.43
R_x_PM_TBUF_X16%3_r45 x_PM_TBUF_X16%3_85 x_PM_TBUF_X16%3_75 4.56151
R_x_PM_TBUF_X16%3_r46 N_3_M16_g x_PM_TBUF_X16%3_75 50.7
R_x_PM_TBUF_X16%3_r47 x_PM_TBUF_X16%3_85 x_PM_TBUF_X16%3_71 4.56151
R_x_PM_TBUF_X16%3_r48 N_3_M34_g x_PM_TBUF_X16%3_71 57.72
R_x_PM_TBUF_X16%3_r49 x_PM_TBUF_X16%3_84 x_PM_TBUF_X16%3_70 1.95
R_x_PM_TBUF_X16%3_r50 x_PM_TBUF_X16%3_85 x_PM_TBUF_X16%3_69 0.043368
R_x_PM_TBUF_X16%3_r51 x_PM_TBUF_X16%3_70 x_PM_TBUF_X16%3_69 54.08
R_x_PM_TBUF_X16%3_r52 x_PM_TBUF_X16%3_84 x_PM_TBUF_X16%3_65 1.95
R_x_PM_TBUF_X16%3_r53 N_3_M13_g x_PM_TBUF_X16%3_65 50.7
R_x_PM_TBUF_X16%3_r54 x_PM_TBUF_X16%3_84 x_PM_TBUF_X16%3_61 1.95
R_x_PM_TBUF_X16%3_r55 N_3_M31_g x_PM_TBUF_X16%3_61 57.72
R_x_PM_TBUF_X16%3_r56 x_PM_TBUF_X16%3_83 x_PM_TBUF_X16%3_60 1.95
R_x_PM_TBUF_X16%3_r57 x_PM_TBUF_X16%3_84 x_PM_TBUF_X16%3_59 1.95
R_x_PM_TBUF_X16%3_r58 x_PM_TBUF_X16%3_60 x_PM_TBUF_X16%3_59 14.56
R_x_PM_TBUF_X16%3_r59 x_PM_TBUF_X16%3_83 x_PM_TBUF_X16%3_55 1.95
R_x_PM_TBUF_X16%3_r60 N_3_M12_g x_PM_TBUF_X16%3_55 50.7
R_x_PM_TBUF_X16%3_r61 x_PM_TBUF_X16%3_83 x_PM_TBUF_X16%3_51 1.95
R_x_PM_TBUF_X16%3_r62 N_3_M30_g x_PM_TBUF_X16%3_51 57.72
R_x_PM_TBUF_X16%3_r63 x_PM_TBUF_X16%3_82 x_PM_TBUF_X16%3_50 1.95
R_x_PM_TBUF_X16%3_r64 x_PM_TBUF_X16%3_83 x_PM_TBUF_X16%3_49 1.95
R_x_PM_TBUF_X16%3_r65 x_PM_TBUF_X16%3_50 x_PM_TBUF_X16%3_49 54.08
R_x_PM_TBUF_X16%3_r66 x_PM_TBUF_X16%3_82 x_PM_TBUF_X16%3_45 1.95
R_x_PM_TBUF_X16%3_r67 N_3_M9_g x_PM_TBUF_X16%3_45 50.7
R_x_PM_TBUF_X16%3_r68 x_PM_TBUF_X16%3_82 x_PM_TBUF_X16%3_41 1.95
R_x_PM_TBUF_X16%3_r69 N_3_M27_g x_PM_TBUF_X16%3_41 57.72
R_x_PM_TBUF_X16%3_r70 x_PM_TBUF_X16%3_81 x_PM_TBUF_X16%3_40 1.95
R_x_PM_TBUF_X16%3_r71 x_PM_TBUF_X16%3_82 x_PM_TBUF_X16%3_39 1.95
R_x_PM_TBUF_X16%3_r72 x_PM_TBUF_X16%3_40 x_PM_TBUF_X16%3_39 14.56
R_x_PM_TBUF_X16%3_r73 x_PM_TBUF_X16%3_81 x_PM_TBUF_X16%3_35 1.95
R_x_PM_TBUF_X16%3_r74 N_3_M8_g x_PM_TBUF_X16%3_35 50.7
R_x_PM_TBUF_X16%3_r75 x_PM_TBUF_X16%3_81 x_PM_TBUF_X16%3_31 1.95
R_x_PM_TBUF_X16%3_r76 N_3_M26_g x_PM_TBUF_X16%3_31 57.72
R_x_PM_TBUF_X16%3_r77 x_PM_TBUF_X16%3_80 x_PM_TBUF_X16%3_30 1.95
R_x_PM_TBUF_X16%3_r78 x_PM_TBUF_X16%3_81 x_PM_TBUF_X16%3_29 1.95
R_x_PM_TBUF_X16%3_r79 x_PM_TBUF_X16%3_30 x_PM_TBUF_X16%3_29 54.08
R_x_PM_TBUF_X16%3_r80 x_PM_TBUF_X16%3_80 x_PM_TBUF_X16%3_25 1.95
R_x_PM_TBUF_X16%3_r81 N_3_M5_g x_PM_TBUF_X16%3_25 50.7
R_x_PM_TBUF_X16%3_r82 x_PM_TBUF_X16%3_80 x_PM_TBUF_X16%3_21 1.95
R_x_PM_TBUF_X16%3_r83 N_3_M23_g x_PM_TBUF_X16%3_21 57.72
R_x_PM_TBUF_X16%3_r84 x_PM_TBUF_X16%3_79 x_PM_TBUF_X16%3_20 1.95
R_x_PM_TBUF_X16%3_r85 x_PM_TBUF_X16%3_80 x_PM_TBUF_X16%3_19 1.95
R_x_PM_TBUF_X16%3_r86 x_PM_TBUF_X16%3_20 x_PM_TBUF_X16%3_19 14.56
R_x_PM_TBUF_X16%3_r87 x_PM_TBUF_X16%3_79 x_PM_TBUF_X16%3_15 1.95
R_x_PM_TBUF_X16%3_r88 N_3_M4_g x_PM_TBUF_X16%3_15 50.7
R_x_PM_TBUF_X16%3_r89 x_PM_TBUF_X16%3_79 x_PM_TBUF_X16%3_11 1.95
R_x_PM_TBUF_X16%3_r90 N_3_M22_g x_PM_TBUF_X16%3_11 57.72
R_x_PM_TBUF_X16%3_r91 x_PM_TBUF_X16%3_105 x_PM_TBUF_X16%3_10 0.043368
R_x_PM_TBUF_X16%3_r92 x_PM_TBUF_X16%3_79 x_PM_TBUF_X16%3_9 1.95
R_x_PM_TBUF_X16%3_r93 x_PM_TBUF_X16%3_10 x_PM_TBUF_X16%3_9 54.08
R_x_PM_TBUF_X16%3_r94 x_PM_TBUF_X16%3_105 x_PM_TBUF_X16%3_5 4.56151
R_x_PM_TBUF_X16%3_r95 N_3_M1_g x_PM_TBUF_X16%3_5 50.7
R_x_PM_TBUF_X16%3_r96 x_PM_TBUF_X16%3_105 x_PM_TBUF_X16%3_VSS 4.56151
R_x_PM_TBUF_X16%3_r97 N_3_M19_g x_PM_TBUF_X16%3_VSS 57.72
C_x_PM_TBUF_X16%A_c0 VSS x_PM_TBUF_X16%A_11 1.3936e-17
C_x_PM_TBUF_X16%A_c1 VSS x_PM_TBUF_X16%A_9 5.79815e-17
C_x_PM_TBUF_X16%A_c2 VSS N_A_M0_g 8.32251e-17
C_x_PM_TBUF_X16%A_c3 VSS N_A_M18_g 3.05736e-17
R_x_PM_TBUF_X16%A_r4 x_PM_TBUF_X16%A_11 x_PM_TBUF_X16%A_14 4.94
R_x_PM_TBUF_X16%A_r5 x_PM_TBUF_X16%A_11 x_PM_TBUF_X16%A_9 25.0012
R_x_PM_TBUF_X16%A_r6 A x_PM_TBUF_X16%A_9 0.155872
R_x_PM_TBUF_X16%A_r7 x_PM_TBUF_X16%A_14 x_PM_TBUF_X16%A_5 1.95
R_x_PM_TBUF_X16%A_r8 N_A_M0_g x_PM_TBUF_X16%A_5 91.65
R_x_PM_TBUF_X16%A_r9 x_PM_TBUF_X16%A_14 x_PM_TBUF_X16%A_VSS 1.95
R_x_PM_TBUF_X16%A_r10 N_A_M18_g x_PM_TBUF_X16%A_VSS 23.79
C_x_PM_TBUF_X16%Z_c0 VSS x_PM_TBUF_X16%Z_47 4.45073e-18
C_x_PM_TBUF_X16%Z_c1 VSS x_PM_TBUF_X16%Z_45 1.81477e-17
C_x_PM_TBUF_X16%Z_c2 VSS N_Z_M14_d 2.68908e-17
C_x_PM_TBUF_X16%Z_c3 VSS x_PM_TBUF_X16%Z_39 7.22712e-17
C_x_PM_TBUF_X16%Z_c4 VSS N_Z_M10_d 2.5786e-17
C_x_PM_TBUF_X16%Z_c5 VSS x_PM_TBUF_X16%Z_33 6.41785e-17
C_x_PM_TBUF_X16%Z_c6 VSS N_Z_M6_d 2.5786e-17
C_x_PM_TBUF_X16%Z_c7 VSS Z 4.45073e-18
C_x_PM_TBUF_X16%Z_c8 VSS x_PM_TBUF_X16%Z_25 6.41788e-17
C_x_PM_TBUF_X16%Z_c9 VSS N_Z_M32_d 5.81171e-16
C_x_PM_TBUF_X16%Z_c10 VSS x_PM_TBUF_X16%Z_15 1.37009e-17
C_x_PM_TBUF_X16%Z_c11 VSS N_Z_M2_d 4.00686e-17
C_x_PM_TBUF_X16%Z_c12 VSS x_PM_TBUF_X16%Z_10 6.62609e-17
R_x_PM_TBUF_X16%Z_r13 N_Z_M14_d x_PM_TBUF_X16%Z_41 1.09929
R_x_PM_TBUF_X16%Z_r14 x_PM_TBUF_X16%Z_47 x_PM_TBUF_X16%Z_40 0.160909
R_x_PM_TBUF_X16%Z_r15 x_PM_TBUF_X16%Z_41 x_PM_TBUF_X16%Z_39 0.212317
R_x_PM_TBUF_X16%Z_r16 x_PM_TBUF_X16%Z_40 x_PM_TBUF_X16%Z_39 3.74571
R_x_PM_TBUF_X16%Z_r17 x_PM_TBUF_X16%Z_47 x_PM_TBUF_X16%Z_35 0.0418175
R_x_PM_TBUF_X16%Z_r18 N_Z_M10_d x_PM_TBUF_X16%Z_35 1.09929
R_x_PM_TBUF_X16%Z_r19 x_PM_TBUF_X16%Z_47 x_PM_TBUF_X16%Z_33 0.160909
R_x_PM_TBUF_X16%Z_r20 x_PM_TBUF_X16%Z_34 x_PM_TBUF_X16%Z_33 3.74571
R_x_PM_TBUF_X16%Z_r21 N_Z_M6_d Z 1.09929
R_x_PM_TBUF_X16%Z_r22 Z x_PM_TBUF_X16%Z_34 0.160909
R_x_PM_TBUF_X16%Z_r23 x_PM_TBUF_X16%Z_45 x_PM_TBUF_X16%Z_26 0.0989817
R_x_PM_TBUF_X16%Z_r24 Z x_PM_TBUF_X16%Z_25 0.160909
R_x_PM_TBUF_X16%Z_r25 x_PM_TBUF_X16%Z_26 x_PM_TBUF_X16%Z_25 3.74571
R_x_PM_TBUF_X16%Z_r26 N_Z_M32_d N_Z_M28_d 4.12571
R_x_PM_TBUF_X16%Z_r27 N_Z_M28_d N_Z_M24_d 4.12571
R_x_PM_TBUF_X16%Z_r28 N_Z_M24_d N_Z_M20_d 4.12571
R_x_PM_TBUF_X16%Z_r29 N_Z_M20_d x_PM_TBUF_X16%Z_15 0.285
R_x_PM_TBUF_X16%Z_r30 x_PM_TBUF_X16%Z_45 x_PM_TBUF_X16%Z_11 0.104615
R_x_PM_TBUF_X16%Z_r31 N_Z_M2_d x_PM_TBUF_X16%Z_11 0.480938
R_x_PM_TBUF_X16%Z_r32 x_PM_TBUF_X16%Z_45 x_PM_TBUF_X16%Z_10 0.104615
R_x_PM_TBUF_X16%Z_r33 x_PM_TBUF_X16%Z_15 x_PM_TBUF_X16%Z_9 0.212317
R_x_PM_TBUF_X16%Z_r34 x_PM_TBUF_X16%Z_10 x_PM_TBUF_X16%Z_9 1.98143
C_x_PM_TBUF_X16%6_c0 VSS x_PM_TBUF_X16%6_63 2.45047e-18
C_x_PM_TBUF_X16%6_c1 VSS N_6_M17_d 6.04912e-17
C_x_PM_TBUF_X16%6_c2 VSS x_PM_TBUF_X16%6_58 5.14819e-17
C_x_PM_TBUF_X16%6_c3 VSS x_PM_TBUF_X16%6_43 5.64526e-16
C_x_PM_TBUF_X16%6_c4 VSS N_6_M33_g 2.77946e-17
C_x_PM_TBUF_X16%6_c5 VSS x_PM_TBUF_X16%6_35 1.68306e-17
C_x_PM_TBUF_X16%6_c6 VSS N_6_M32_g 3.1659e-17
C_x_PM_TBUF_X16%6_c7 VSS x_PM_TBUF_X16%6_31 5.84874e-18
C_x_PM_TBUF_X16%6_c8 VSS N_6_M29_g 3.16288e-17
C_x_PM_TBUF_X16%6_c9 VSS x_PM_TBUF_X16%6_25 1.69938e-17
C_x_PM_TBUF_X16%6_c10 VSS N_6_M28_g 3.16238e-17
C_x_PM_TBUF_X16%6_c11 VSS x_PM_TBUF_X16%6_21 5.84874e-18
C_x_PM_TBUF_X16%6_c12 VSS N_6_M25_g 3.16288e-17
C_x_PM_TBUF_X16%6_c13 VSS x_PM_TBUF_X16%6_15 1.69938e-17
C_x_PM_TBUF_X16%6_c14 VSS N_6_M24_g 3.16238e-17
C_x_PM_TBUF_X16%6_c15 VSS x_PM_TBUF_X16%6_11 5.87166e-18
C_x_PM_TBUF_X16%6_c16 VSS N_6_M21_g 3.1769e-17
C_x_PM_TBUF_X16%6_c17 VSS x_PM_TBUF_X16%6_7 5.84874e-18
C_x_PM_TBUF_X16%6_c18 VSS x_PM_TBUF_X16%6_6 7.28939e-18
C_x_PM_TBUF_X16%6_c19 VSS x_PM_TBUF_X16%6_5 1.41637e-17
C_x_PM_TBUF_X16%6_c20 VSS N_6_M20_g 3.18918e-17
R_x_PM_TBUF_X16%6_r21 x_PM_TBUF_X16%6_63 x_PM_TBUF_X16%6_59 0.123935
R_x_PM_TBUF_X16%6_r22 N_6_M17_d x_PM_TBUF_X16%6_59 1.45
R_x_PM_TBUF_X16%6_r23 x_PM_TBUF_X16%6_63 x_PM_TBUF_X16%6_58 0.123935
R_x_PM_TBUF_X16%6_r24 x_PM_TBUF_X16%6_56 x_PM_TBUF_X16%6_54 25.0012
R_x_PM_TBUF_X16%6_r25 x_PM_TBUF_X16%6_53 x_PM_TBUF_X16%6_51 25.0012
R_x_PM_TBUF_X16%6_r26 x_PM_TBUF_X16%6_54 x_PM_TBUF_X16%6_51 4.15286
R_x_PM_TBUF_X16%6_r27 x_PM_TBUF_X16%6_50 x_PM_TBUF_X16%6_48 25.0012
R_x_PM_TBUF_X16%6_r28 x_PM_TBUF_X16%6_51 x_PM_TBUF_X16%6_48 4.12571
R_x_PM_TBUF_X16%6_r29 x_PM_TBUF_X16%6_46 x_PM_TBUF_X16%6_44 25.0012
R_x_PM_TBUF_X16%6_r30 x_PM_TBUF_X16%6_48 x_PM_TBUF_X16%6_44 3.25714
R_x_PM_TBUF_X16%6_r31 x_PM_TBUF_X16%6_63 x_PM_TBUF_X16%6_43 0.0766861
R_x_PM_TBUF_X16%6_r32 x_PM_TBUF_X16%6_54 x_PM_TBUF_X16%6_43 3.325
R_x_PM_TBUF_X16%6_r33 x_PM_TBUF_X16%6_58 N_6_M35_d 0.607567
R_x_PM_TBUF_X16%6_r34 N_6_M33_g x_PM_TBUF_X16%6_37 28.08
R_x_PM_TBUF_X16%6_r35 x_PM_TBUF_X16%6_56 x_PM_TBUF_X16%6_36 0.550646
R_x_PM_TBUF_X16%6_r36 x_PM_TBUF_X16%6_37 x_PM_TBUF_X16%6_35 4.58872
R_x_PM_TBUF_X16%6_r37 x_PM_TBUF_X16%6_36 x_PM_TBUF_X16%6_35 14.56
R_x_PM_TBUF_X16%6_r38 x_PM_TBUF_X16%6_56 x_PM_TBUF_X16%6_31 4.03807
R_x_PM_TBUF_X16%6_r39 N_6_M32_g x_PM_TBUF_X16%6_31 28.08
R_x_PM_TBUF_X16%6_r40 N_6_M29_g x_PM_TBUF_X16%6_27 28.08
R_x_PM_TBUF_X16%6_r41 x_PM_TBUF_X16%6_53 x_PM_TBUF_X16%6_26 0.917744
R_x_PM_TBUF_X16%6_r42 x_PM_TBUF_X16%6_27 x_PM_TBUF_X16%6_25 4.58872
R_x_PM_TBUF_X16%6_r43 x_PM_TBUF_X16%6_26 x_PM_TBUF_X16%6_25 14.56
R_x_PM_TBUF_X16%6_r44 x_PM_TBUF_X16%6_53 x_PM_TBUF_X16%6_21 3.67098
R_x_PM_TBUF_X16%6_r45 N_6_M28_g x_PM_TBUF_X16%6_21 28.08
R_x_PM_TBUF_X16%6_r46 N_6_M25_g x_PM_TBUF_X16%6_17 28.08
R_x_PM_TBUF_X16%6_r47 x_PM_TBUF_X16%6_50 x_PM_TBUF_X16%6_16 0.917744
R_x_PM_TBUF_X16%6_r48 x_PM_TBUF_X16%6_17 x_PM_TBUF_X16%6_15 4.58872
R_x_PM_TBUF_X16%6_r49 x_PM_TBUF_X16%6_16 x_PM_TBUF_X16%6_15 14.56
R_x_PM_TBUF_X16%6_r50 x_PM_TBUF_X16%6_50 x_PM_TBUF_X16%6_11 3.67098
R_x_PM_TBUF_X16%6_r51 N_6_M24_g x_PM_TBUF_X16%6_11 28.08
R_x_PM_TBUF_X16%6_r52 x_PM_TBUF_X16%6_46 x_PM_TBUF_X16%6_7 4.03807
R_x_PM_TBUF_X16%6_r53 N_6_M21_g x_PM_TBUF_X16%6_7 28.08
R_x_PM_TBUF_X16%6_r54 x_PM_TBUF_X16%6_46 x_PM_TBUF_X16%6_5 0.550646
R_x_PM_TBUF_X16%6_r55 x_PM_TBUF_X16%6_6 x_PM_TBUF_X16%6_5 14.56
R_x_PM_TBUF_X16%6_r56 x_PM_TBUF_X16%6_6 x_PM_TBUF_X16%6_VSS 4.58872
R_x_PM_TBUF_X16%6_r57 N_6_M20_g x_PM_TBUF_X16%6_VSS 28.08
C_x_PM_TBUF_X16%EN_c0 VSS x_PM_TBUF_X16%EN_73 1.32456e-17
C_x_PM_TBUF_X16%EN_c1 VSS x_PM_TBUF_X16%EN_67 5.6827e-17
C_x_PM_TBUF_X16%EN_c2 VSS x_PM_TBUF_X16%EN_63 4.47745e-18
C_x_PM_TBUF_X16%EN_c3 VSS x_PM_TBUF_X16%EN_62 4.68934e-18
C_x_PM_TBUF_X16%EN_c4 VSS x_PM_TBUF_X16%EN_61 4.68934e-18
C_x_PM_TBUF_X16%EN_c5 VSS x_PM_TBUF_X16%EN_60 4.68934e-18
C_x_PM_TBUF_X16%EN_c6 VSS x_PM_TBUF_X16%EN_59 4.68934e-18
C_x_PM_TBUF_X16%EN_c7 VSS x_PM_TBUF_X16%EN_58 4.68934e-18
C_x_PM_TBUF_X16%EN_c8 VSS x_PM_TBUF_X16%EN_57 4.68934e-18
C_x_PM_TBUF_X16%EN_c9 VSS N_EN_M17_g 6.27376e-17
C_x_PM_TBUF_X16%EN_c10 VSS N_EN_M35_g 5.93284e-17
C_x_PM_TBUF_X16%EN_c11 VSS x_PM_TBUF_X16%EN_47 4.39345e-17
C_x_PM_TBUF_X16%EN_c12 VSS N_EN_M15_g 4.13033e-17
C_x_PM_TBUF_X16%EN_c13 VSS x_PM_TBUF_X16%EN_41 1.52572e-17
C_x_PM_TBUF_X16%EN_c14 VSS N_EN_M14_g 4.19648e-17
C_x_PM_TBUF_X16%EN_c15 VSS x_PM_TBUF_X16%EN_35 6.12588e-17
C_x_PM_TBUF_X16%EN_c16 VSS N_EN_M11_g 4.20557e-17
C_x_PM_TBUF_X16%EN_c17 VSS x_PM_TBUF_X16%EN_29 1.52572e-17
C_x_PM_TBUF_X16%EN_c18 VSS N_EN_M10_g 4.20025e-17
C_x_PM_TBUF_X16%EN_c19 VSS x_PM_TBUF_X16%EN_23 6.12588e-17
C_x_PM_TBUF_X16%EN_c20 VSS N_EN_M7_g 4.20557e-17
C_x_PM_TBUF_X16%EN_c21 VSS x_PM_TBUF_X16%EN_17 1.52572e-17
C_x_PM_TBUF_X16%EN_c22 VSS N_EN_M6_g 4.20025e-17
C_x_PM_TBUF_X16%EN_c23 VSS x_PM_TBUF_X16%EN_11 6.12429e-17
C_x_PM_TBUF_X16%EN_c24 VSS N_EN_M3_g 4.2047e-17
C_x_PM_TBUF_X16%EN_c25 VSS x_PM_TBUF_X16%EN_6 6.50566e-18
C_x_PM_TBUF_X16%EN_c26 VSS x_PM_TBUF_X16%EN_5 1.50604e-17
C_x_PM_TBUF_X16%EN_c27 VSS N_EN_M2_g 4.68513e-17
R_x_PM_TBUF_X16%EN_r28 x_PM_TBUF_X16%EN_73 x_PM_TBUF_X16%EN_69 4.42
R_x_PM_TBUF_X16%EN_r29 x_PM_TBUF_X16%EN_69 x_PM_TBUF_X16%EN_67 25.0012
R_x_PM_TBUF_X16%EN_r30 x_PM_TBUF_X16%EN_67 EN 0.1425
R_x_PM_TBUF_X16%EN_r31 N_EN_M17_g x_PM_TBUF_X16%EN_54 69.81
R_x_PM_TBUF_X16%EN_r32 x_PM_TBUF_X16%EN_73 x_PM_TBUF_X16%EN_53 1.95
R_x_PM_TBUF_X16%EN_r33 N_EN_M17_g x_PM_TBUF_X16%EN_53 30.81
R_x_PM_TBUF_X16%EN_r34 x_PM_TBUF_X16%EN_73 x_PM_TBUF_X16%EN_49 1.95
R_x_PM_TBUF_X16%EN_r35 N_EN_M35_g x_PM_TBUF_X16%EN_49 59.67
R_x_PM_TBUF_X16%EN_r36 x_PM_TBUF_X16%EN_63 x_PM_TBUF_X16%EN_48 3.30287
R_x_PM_TBUF_X16%EN_r37 x_PM_TBUF_X16%EN_54 x_PM_TBUF_X16%EN_47 4.35808
R_x_PM_TBUF_X16%EN_r38 x_PM_TBUF_X16%EN_48 x_PM_TBUF_X16%EN_47 51.48
R_x_PM_TBUF_X16%EN_r39 x_PM_TBUF_X16%EN_63 x_PM_TBUF_X16%EN_43 0.858359
R_x_PM_TBUF_X16%EN_r40 N_EN_M15_g x_PM_TBUF_X16%EN_43 49.92
R_x_PM_TBUF_X16%EN_r41 x_PM_TBUF_X16%EN_62 x_PM_TBUF_X16%EN_42 3.30287
R_x_PM_TBUF_X16%EN_r42 x_PM_TBUF_X16%EN_63 x_PM_TBUF_X16%EN_41 3.30287
R_x_PM_TBUF_X16%EN_r43 x_PM_TBUF_X16%EN_42 x_PM_TBUF_X16%EN_41 21.84
R_x_PM_TBUF_X16%EN_r44 x_PM_TBUF_X16%EN_62 x_PM_TBUF_X16%EN_37 0.858359
R_x_PM_TBUF_X16%EN_r45 N_EN_M14_g x_PM_TBUF_X16%EN_37 49.92
R_x_PM_TBUF_X16%EN_r46 x_PM_TBUF_X16%EN_61 x_PM_TBUF_X16%EN_36 3.30287
R_x_PM_TBUF_X16%EN_r47 x_PM_TBUF_X16%EN_62 x_PM_TBUF_X16%EN_35 3.30287
R_x_PM_TBUF_X16%EN_r48 x_PM_TBUF_X16%EN_36 x_PM_TBUF_X16%EN_35 81.12
R_x_PM_TBUF_X16%EN_r49 x_PM_TBUF_X16%EN_61 x_PM_TBUF_X16%EN_31 0.858359
R_x_PM_TBUF_X16%EN_r50 N_EN_M11_g x_PM_TBUF_X16%EN_31 49.92
R_x_PM_TBUF_X16%EN_r51 x_PM_TBUF_X16%EN_60 x_PM_TBUF_X16%EN_30 3.30287
R_x_PM_TBUF_X16%EN_r52 x_PM_TBUF_X16%EN_61 x_PM_TBUF_X16%EN_29 3.30287
R_x_PM_TBUF_X16%EN_r53 x_PM_TBUF_X16%EN_30 x_PM_TBUF_X16%EN_29 21.84
R_x_PM_TBUF_X16%EN_r54 x_PM_TBUF_X16%EN_60 x_PM_TBUF_X16%EN_25 0.858359
R_x_PM_TBUF_X16%EN_r55 N_EN_M10_g x_PM_TBUF_X16%EN_25 49.92
R_x_PM_TBUF_X16%EN_r56 x_PM_TBUF_X16%EN_59 x_PM_TBUF_X16%EN_24 3.30287
R_x_PM_TBUF_X16%EN_r57 x_PM_TBUF_X16%EN_60 x_PM_TBUF_X16%EN_23 3.30287
R_x_PM_TBUF_X16%EN_r58 x_PM_TBUF_X16%EN_24 x_PM_TBUF_X16%EN_23 81.12
R_x_PM_TBUF_X16%EN_r59 x_PM_TBUF_X16%EN_59 x_PM_TBUF_X16%EN_19 0.858359
R_x_PM_TBUF_X16%EN_r60 N_EN_M7_g x_PM_TBUF_X16%EN_19 49.92
R_x_PM_TBUF_X16%EN_r61 x_PM_TBUF_X16%EN_58 x_PM_TBUF_X16%EN_18 3.30287
R_x_PM_TBUF_X16%EN_r62 x_PM_TBUF_X16%EN_59 x_PM_TBUF_X16%EN_17 3.30287
R_x_PM_TBUF_X16%EN_r63 x_PM_TBUF_X16%EN_18 x_PM_TBUF_X16%EN_17 21.84
R_x_PM_TBUF_X16%EN_r64 x_PM_TBUF_X16%EN_58 x_PM_TBUF_X16%EN_13 0.858359
R_x_PM_TBUF_X16%EN_r65 N_EN_M6_g x_PM_TBUF_X16%EN_13 49.92
R_x_PM_TBUF_X16%EN_r66 x_PM_TBUF_X16%EN_57 x_PM_TBUF_X16%EN_12 3.30287
R_x_PM_TBUF_X16%EN_r67 x_PM_TBUF_X16%EN_58 x_PM_TBUF_X16%EN_11 3.30287
R_x_PM_TBUF_X16%EN_r68 x_PM_TBUF_X16%EN_12 x_PM_TBUF_X16%EN_11 81.12
R_x_PM_TBUF_X16%EN_r69 x_PM_TBUF_X16%EN_57 x_PM_TBUF_X16%EN_7 0.858359
R_x_PM_TBUF_X16%EN_r70 N_EN_M3_g x_PM_TBUF_X16%EN_7 49.92
R_x_PM_TBUF_X16%EN_r71 x_PM_TBUF_X16%EN_57 x_PM_TBUF_X16%EN_5 3.30287
R_x_PM_TBUF_X16%EN_r72 x_PM_TBUF_X16%EN_6 x_PM_TBUF_X16%EN_5 21.84
R_x_PM_TBUF_X16%EN_r73 x_PM_TBUF_X16%EN_6 x_PM_TBUF_X16%EN_VSS 4.35808
R_x_PM_TBUF_X16%EN_r74 N_EN_M2_g x_PM_TBUF_X16%EN_VSS 49.92
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X2 VSS VDD A Z EN
*.PININFO VSS:B VDD:B A:I Z:O EN:I
M_M4 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M5 8 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M6 N_Z_M2_d N_EN_M2_g 8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M7 N_VDD_M3_d N_EN_M3_g N_6_M3_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M4_d N_A_M4_g N_3_M4_s VSS NMOS_VTL W=0.095000U L=0.050000U
M_M1 9 N_3_M5_g N_VSS_M4_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_Z_M6_d N_6_M6_g 9 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_VSS_M7_d N_EN_M7_g N_6_M7_s VSS NMOS_VTL W=0.095000U L=0.050000U
C_x_PM_TBUF_X2%VSS_c0 VSS x_PM_TBUF_X2%VSS_17 3.81544e-17
C_x_PM_TBUF_X2%VSS_c1 VSS N_VSS_M7_d 1.98467e-17
C_x_PM_TBUF_X2%VSS_c2 VSS x_PM_TBUF_X2%VSS_9 9.13295e-17
C_x_PM_TBUF_X2%VSS_c3 VSS N_VSS_M4_d 3.76471e-17
R_x_PM_TBUF_X2%VSS_r4 N_VSS_M7_d x_PM_TBUF_X2%VSS_13 0.610714
R_x_PM_TBUF_X2%VSS_r5 x_PM_TBUF_X2%VSS_17 x_PM_TBUF_X2%VSS_10 0.0731438
R_x_PM_TBUF_X2%VSS_r6 VSS x_PM_TBUF_X2%VSS_10 0.614706
R_x_PM_TBUF_X2%VSS_r7 x_PM_TBUF_X2%VSS_13 x_PM_TBUF_X2%VSS_9 0.264221
R_x_PM_TBUF_X2%VSS_r8 VSS x_PM_TBUF_X2%VSS_9 0.849412
R_x_PM_TBUF_X2%VSS_r9 x_PM_TBUF_X2%VSS_17 x_PM_TBUF_X2%VSS_5 0.145286
R_x_PM_TBUF_X2%VSS_r10 N_VSS_M4_d x_PM_TBUF_X2%VSS_5 0.610714
C_x_PM_TBUF_X2%VDD_c0 VSS x_PM_TBUF_X2%VDD_17 3.75891e-17
C_x_PM_TBUF_X2%VDD_c1 VSS N_VDD_M3_d 1.61246e-17
C_x_PM_TBUF_X2%VDD_c2 VSS x_PM_TBUF_X2%VDD_9 8.42954e-17
C_x_PM_TBUF_X2%VDD_c3 VSS N_VDD_M0_d 1.95189e-17
R_x_PM_TBUF_X2%VDD_r4 N_VDD_M3_d x_PM_TBUF_X2%VDD_13 0.393571
R_x_PM_TBUF_X2%VDD_r5 x_PM_TBUF_X2%VDD_17 x_PM_TBUF_X2%VDD_10 0.0731438
R_x_PM_TBUF_X2%VDD_r6 VDD x_PM_TBUF_X2%VDD_10 0.614706
R_x_PM_TBUF_X2%VDD_r7 x_PM_TBUF_X2%VDD_13 x_PM_TBUF_X2%VDD_9 0.264221
R_x_PM_TBUF_X2%VDD_r8 VDD x_PM_TBUF_X2%VDD_9 0.838235
R_x_PM_TBUF_X2%VDD_r9 x_PM_TBUF_X2%VDD_17 x_PM_TBUF_X2%VDD_5 0.145286
R_x_PM_TBUF_X2%VDD_r10 N_VDD_M0_d x_PM_TBUF_X2%VDD_5 0.393571
C_x_PM_TBUF_X2%3_c0 VSS x_PM_TBUF_X2%3_28 8.98673e-18
C_x_PM_TBUF_X2%3_c1 VSS x_PM_TBUF_X2%3_26 1.00341e-16
C_x_PM_TBUF_X2%3_c2 VSS x_PM_TBUF_X2%3_22 1.61416e-17
C_x_PM_TBUF_X2%3_c3 VSS x_PM_TBUF_X2%3_21 3.14818e-17
C_x_PM_TBUF_X2%3_c4 VSS x_PM_TBUF_X2%3_20 6.28322e-18
C_x_PM_TBUF_X2%3_c5 VSS x_PM_TBUF_X2%3_19 4.03045e-17
C_x_PM_TBUF_X2%3_c6 VSS N_3_M0_s 5.15264e-17
C_x_PM_TBUF_X2%3_c7 VSS N_3_M4_s 3.40169e-17
C_x_PM_TBUF_X2%3_c8 VSS N_3_M1_g 5.52479e-17
C_x_PM_TBUF_X2%3_c9 VSS N_3_M5_g 5.91636e-17
R_x_PM_TBUF_X2%3_r10 x_PM_TBUF_X2%3_30 x_PM_TBUF_X2%3_28 4.74714
R_x_PM_TBUF_X2%3_r11 x_PM_TBUF_X2%3_28 x_PM_TBUF_X2%3_26 25.0012
R_x_PM_TBUF_X2%3_r12 x_PM_TBUF_X2%3_26 x_PM_TBUF_X2%3_24 0.0407143
R_x_PM_TBUF_X2%3_r13 x_PM_TBUF_X2%3_26 x_PM_TBUF_X2%3_23 1.94071
R_x_PM_TBUF_X2%3_r14 x_PM_TBUF_X2%3_24 x_PM_TBUF_X2%3_21 0.212317
R_x_PM_TBUF_X2%3_r15 x_PM_TBUF_X2%3_22 x_PM_TBUF_X2%3_21 1.03143
R_x_PM_TBUF_X2%3_r16 x_PM_TBUF_X2%3_23 x_PM_TBUF_X2%3_19 0.212317
R_x_PM_TBUF_X2%3_r17 x_PM_TBUF_X2%3_20 x_PM_TBUF_X2%3_19 1.03143
R_x_PM_TBUF_X2%3_r18 x_PM_TBUF_X2%3_22 x_PM_TBUF_X2%3_15 0.212317
R_x_PM_TBUF_X2%3_r19 N_3_M0_s x_PM_TBUF_X2%3_15 1.88643
R_x_PM_TBUF_X2%3_r20 x_PM_TBUF_X2%3_20 x_PM_TBUF_X2%3_11 0.212317
R_x_PM_TBUF_X2%3_r21 N_3_M4_s x_PM_TBUF_X2%3_11 0.610714
R_x_PM_TBUF_X2%3_r22 N_3_M1_g x_PM_TBUF_X2%3_30 49.92
R_x_PM_TBUF_X2%3_r23 x_PM_TBUF_X2%3_VSS x_PM_TBUF_X2%3_28 4.74714
R_x_PM_TBUF_X2%3_r24 N_3_M5_g x_PM_TBUF_X2%3_VSS 67.08
C_x_PM_TBUF_X2%A_c0 VSS x_PM_TBUF_X2%A_14 7.48679e-18
C_x_PM_TBUF_X2%A_c1 VSS x_PM_TBUF_X2%A_12 5.96709e-17
C_x_PM_TBUF_X2%A_c2 VSS N_A_M0_g 7.57446e-17
C_x_PM_TBUF_X2%A_c3 VSS N_A_M4_g 5.30187e-17
R_x_PM_TBUF_X2%A_r4 x_PM_TBUF_X2%A_18 x_PM_TBUF_X2%A_14 4.7687
R_x_PM_TBUF_X2%A_r5 x_PM_TBUF_X2%A_17 x_PM_TBUF_X2%A_14 4.7687
R_x_PM_TBUF_X2%A_r6 x_PM_TBUF_X2%A_14 x_PM_TBUF_X2%A_12 25.0012
R_x_PM_TBUF_X2%A_r7 x_PM_TBUF_X2%A_12 A 0.2375
R_x_PM_TBUF_X2%A_r8 N_A_M0_g x_PM_TBUF_X2%A_18 85.41
R_x_PM_TBUF_X2%A_r9 N_A_M4_g x_PM_TBUF_X2%A_17 59.67
C_x_PM_TBUF_X2%Z_c0 VSS N_Z_M6_d 9.12356e-17
C_x_PM_TBUF_X2%Z_c1 VSS N_Z_M2_d 9.76627e-17
C_x_PM_TBUF_X2%Z_c2 VSS x_PM_TBUF_X2%Z_10 1.83805e-17
C_x_PM_TBUF_X2%Z_c3 VSS x_PM_TBUF_X2%Z_9 4.3452e-17
C_x_PM_TBUF_X2%Z_c4 VSS x_PM_TBUF_X2%Z_8 1.92173e-17
C_x_PM_TBUF_X2%Z_c5 VSS x_PM_TBUF_X2%Z_7 1.3725e-17
C_x_PM_TBUF_X2%Z_c6 VSS Z 9.27999e-17
R_x_PM_TBUF_X2%Z_r7 N_Z_M2_d x_PM_TBUF_X2%Z_13 1.83214
R_x_PM_TBUF_X2%Z_r8 x_PM_TBUF_X2%Z_13 x_PM_TBUF_X2%Z_9 0.212317
R_x_PM_TBUF_X2%Z_r9 x_PM_TBUF_X2%Z_10 x_PM_TBUF_X2%Z_9 0.515714
R_x_PM_TBUF_X2%Z_r10 N_Z_M6_d x_PM_TBUF_X2%Z_7 0.198162
R_x_PM_TBUF_X2%Z_r11 x_PM_TBUF_X2%Z_8 x_PM_TBUF_X2%Z_7 0.515714
R_x_PM_TBUF_X2%Z_r12 x_PM_TBUF_X2%Z_10 x_PM_TBUF_X2%Z_4 0.212317
R_x_PM_TBUF_X2%Z_r13 Z x_PM_TBUF_X2%Z_4 0.325714
R_x_PM_TBUF_X2%Z_r14 x_PM_TBUF_X2%Z_8 x_PM_TBUF_X2%Z_3 0.212317
R_x_PM_TBUF_X2%Z_r15 Z x_PM_TBUF_X2%Z_3 1.11286
C_x_PM_TBUF_X2%6_c0 VSS N_6_M3_s 4.87943e-17
C_x_PM_TBUF_X2%6_c1 VSS x_PM_TBUF_X2%6_18 9.83569e-18
C_x_PM_TBUF_X2%6_c2 VSS x_PM_TBUF_X2%6_13 1.2769e-16
C_x_PM_TBUF_X2%6_c3 VSS x_PM_TBUF_X2%6_11 3.77925e-17
C_x_PM_TBUF_X2%6_c4 VSS x_PM_TBUF_X2%6_9 7.30867e-17
C_x_PM_TBUF_X2%6_c5 VSS x_PM_TBUF_X2%6_8 1.46078e-17
C_x_PM_TBUF_X2%6_c6 VSS N_6_M7_s 6.33057e-17
C_x_PM_TBUF_X2%6_c7 VSS N_6_M6_g 4.86651e-17
R_x_PM_TBUF_X2%6_r8 x_PM_TBUF_X2%6_13 N_6_M3_s 0.30478
R_x_PM_TBUF_X2%6_r9 x_PM_TBUF_X2%6_18 x_PM_TBUF_X2%6_12 0.266978
R_x_PM_TBUF_X2%6_r10 x_PM_TBUF_X2%6_13 x_PM_TBUF_X2%6_12 2.66
R_x_PM_TBUF_X2%6_r11 x_PM_TBUF_X2%6_18 x_PM_TBUF_X2%6_11 0.266978
R_x_PM_TBUF_X2%6_r12 x_PM_TBUF_X2%6_11 x_PM_TBUF_X2%6_17 1.11286
R_x_PM_TBUF_X2%6_r13 x_PM_TBUF_X2%6_18 x_PM_TBUF_X2%6_9 0.0272847
R_x_PM_TBUF_X2%6_r14 x_PM_TBUF_X2%6_8 x_PM_TBUF_X2%6_23 5.98
R_x_PM_TBUF_X2%6_r15 x_PM_TBUF_X2%6_9 x_PM_TBUF_X2%6_7 0.305065
R_x_PM_TBUF_X2%6_r16 x_PM_TBUF_X2%6_8 x_PM_TBUF_X2%6_7 25.0012
R_x_PM_TBUF_X2%6_r17 x_PM_TBUF_X2%6_17 N_6_M7_s 0.297071
R_x_PM_TBUF_X2%6_r18 x_PM_TBUF_X2%6_23 x_PM_TBUF_X2%6_VSS 1.95
R_x_PM_TBUF_X2%6_r19 N_6_M6_g x_PM_TBUF_X2%6_VSS 35.88
C_x_PM_TBUF_X2%EN_c0 VSS EN 5.28276e-17
C_x_PM_TBUF_X2%EN_c1 VSS x_PM_TBUF_X2%EN_17 4.20578e-18
C_x_PM_TBUF_X2%EN_c2 VSS N_EN_M7_g 7.0545e-17
C_x_PM_TBUF_X2%EN_c3 VSS N_EN_M3_g 5.19e-17
C_x_PM_TBUF_X2%EN_c4 VSS x_PM_TBUF_X2%EN_6 8.46063e-18
C_x_PM_TBUF_X2%EN_c5 VSS x_PM_TBUF_X2%EN_5 4.15697e-17
C_x_PM_TBUF_X2%EN_c6 VSS N_EN_M2_g 5.62241e-17
R_x_PM_TBUF_X2%EN_r7 x_PM_TBUF_X2%EN_17 x_PM_TBUF_X2%EN_15 25.0012
R_x_PM_TBUF_X2%EN_r8 EN x_PM_TBUF_X2%EN_15 0.298571
R_x_PM_TBUF_X2%EN_r9 x_PM_TBUF_X2%EN_17 x_PM_TBUF_X2%EN_11 5.62096
R_x_PM_TBUF_X2%EN_r10 N_EN_M7_g x_PM_TBUF_X2%EN_11 87.75
R_x_PM_TBUF_X2%EN_r11 x_PM_TBUF_X2%EN_17 x_PM_TBUF_X2%EN_7 5.62096
R_x_PM_TBUF_X2%EN_r12 N_EN_M3_g x_PM_TBUF_X2%EN_7 53.43
R_x_PM_TBUF_X2%EN_r13 x_PM_TBUF_X2%EN_17 x_PM_TBUF_X2%EN_5 0.631437
R_x_PM_TBUF_X2%EN_r14 x_PM_TBUF_X2%EN_6 x_PM_TBUF_X2%EN_5 22.62
R_x_PM_TBUF_X2%EN_r15 x_PM_TBUF_X2%EN_6 x_PM_TBUF_X2%EN_VSS 5.01959
R_x_PM_TBUF_X2%EN_r16 N_EN_M2_g x_PM_TBUF_X2%EN_VSS 38.22
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X4.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X4 VSS VDD A Z EN
*.PININFO VSS:B VDD:B A:I Z:O EN:I
M_M6 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 8 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M8 N_Z_M2_d N_EN_M2_g 8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 9 N_EN_M3_g N_Z_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M10 N_VDD_M4_d N_3_M4_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M11 N_6_M5_d N_EN_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M6_d N_A_M6_g N_3_M6_s VSS NMOS_VTL W=0.095000U L=0.050000U
M_M1 10 N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_Z_M8_d N_6_M8_g 10 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 11 N_6_M9_g N_Z_M8_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M10_d N_3_M10_g 11 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 N_6_M11_d N_EN_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.095000U L=0.050000U
C_x_PM_TBUF_X4%VSS_c0 VSS x_PM_TBUF_X4%VSS_20 4.348e-17
C_x_PM_TBUF_X4%VSS_c1 VSS x_PM_TBUF_X4%VSS_19 2.92076e-17
C_x_PM_TBUF_X4%VSS_c2 VSS N_VSS_M10_d 2.67047e-17
C_x_PM_TBUF_X4%VSS_c3 VSS x_PM_TBUF_X4%VSS_9 6.7759e-17
C_x_PM_TBUF_X4%VSS_c4 VSS N_VSS_M6_d 4.52684e-17
R_x_PM_TBUF_X4%VSS_r5 x_PM_TBUF_X4%VSS_20 x_PM_TBUF_X4%VSS_13 0.145286
R_x_PM_TBUF_X4%VSS_r6 N_VSS_M10_d x_PM_TBUF_X4%VSS_13 0.610714
R_x_PM_TBUF_X4%VSS_r7 x_PM_TBUF_X4%VSS_19 x_PM_TBUF_X4%VSS_10 0.0731438
R_x_PM_TBUF_X4%VSS_r8 VSS x_PM_TBUF_X4%VSS_10 0.782353
R_x_PM_TBUF_X4%VSS_r9 x_PM_TBUF_X4%VSS_20 x_PM_TBUF_X4%VSS_9 0.0731438
R_x_PM_TBUF_X4%VSS_r10 VSS x_PM_TBUF_X4%VSS_9 0.771176
R_x_PM_TBUF_X4%VSS_r11 x_PM_TBUF_X4%VSS_19 x_PM_TBUF_X4%VSS_5 0.145286
R_x_PM_TBUF_X4%VSS_r12 N_VSS_M6_d x_PM_TBUF_X4%VSS_5 1.12643
C_x_PM_TBUF_X4%VDD_c0 VSS x_PM_TBUF_X4%VDD_20 3.15792e-17
C_x_PM_TBUF_X4%VDD_c1 VSS x_PM_TBUF_X4%VDD_19 2.93904e-18
C_x_PM_TBUF_X4%VDD_c2 VSS N_VDD_M4_d 6.15813e-17
C_x_PM_TBUF_X4%VDD_c3 VSS x_PM_TBUF_X4%VDD_11 6.28267e-17
C_x_PM_TBUF_X4%VDD_c4 VSS N_VDD_M0_d 2.49672e-17
C_x_PM_TBUF_X4%VDD_c5 VSS x_PM_TBUF_X4%VDD_3 2.60729e-17
R_x_PM_TBUF_X4%VDD_r6 x_PM_TBUF_X4%VDD_20 x_PM_TBUF_X4%VDD_13 0.145286
R_x_PM_TBUF_X4%VDD_r7 N_VDD_M4_d x_PM_TBUF_X4%VDD_13 2.32071
R_x_PM_TBUF_X4%VDD_r8 x_PM_TBUF_X4%VDD_19 x_PM_TBUF_X4%VDD_12 0.0731438
R_x_PM_TBUF_X4%VDD_r9 x_PM_TBUF_X4%VDD_20 x_PM_TBUF_X4%VDD_11 0.0731438
R_x_PM_TBUF_X4%VDD_r10 x_PM_TBUF_X4%VDD_12 x_PM_TBUF_X4%VDD_11 1.54235
R_x_PM_TBUF_X4%VDD_r11 x_PM_TBUF_X4%VDD_19 x_PM_TBUF_X4%VDD_7 0.145286
R_x_PM_TBUF_X4%VDD_r12 N_VDD_M0_d x_PM_TBUF_X4%VDD_7 0.909286
R_x_PM_TBUF_X4%VDD_r13 x_PM_TBUF_X4%VDD_19 x_PM_TBUF_X4%VDD_3 0.0731438
R_x_PM_TBUF_X4%VDD_r14 VDD x_PM_TBUF_X4%VDD_3 0.273824
C_x_PM_TBUF_X4%3_c0 VSS x_PM_TBUF_X4%3_40 2.1541e-18
C_x_PM_TBUF_X4%3_c1 VSS x_PM_TBUF_X4%3_37 3.23405e-17
C_x_PM_TBUF_X4%3_c2 VSS x_PM_TBUF_X4%3_33 5.71856e-17
C_x_PM_TBUF_X4%3_c3 VSS N_3_M0_s 1.74914e-17
C_x_PM_TBUF_X4%3_c4 VSS x_PM_TBUF_X4%3_29 2.91012e-18
C_x_PM_TBUF_X4%3_c5 VSS x_PM_TBUF_X4%3_28 5.28271e-17
C_x_PM_TBUF_X4%3_c6 VSS N_3_M6_s 2.51944e-17
C_x_PM_TBUF_X4%3_c7 VSS x_PM_TBUF_X4%3_20 5.04426e-18
C_x_PM_TBUF_X4%3_c8 VSS x_PM_TBUF_X4%3_19 5.46255e-17
C_x_PM_TBUF_X4%3_c9 VSS x_PM_TBUF_X4%3_18 4.72821e-18
C_x_PM_TBUF_X4%3_c10 VSS N_3_M4_g 6.21045e-17
C_x_PM_TBUF_X4%3_c11 VSS N_3_M10_g 5.6112e-17
C_x_PM_TBUF_X4%3_c12 VSS N_3_M1_g 5.8922e-17
C_x_PM_TBUF_X4%3_c13 VSS N_3_M7_g 5.00193e-17
R_x_PM_TBUF_X4%3_r14 x_PM_TBUF_X4%3_42 x_PM_TBUF_X4%3_37 25.0012
R_x_PM_TBUF_X4%3_r15 x_PM_TBUF_X4%3_37 x_PM_TBUF_X4%3_35 0.502143
R_x_PM_TBUF_X4%3_r16 x_PM_TBUF_X4%3_40 x_PM_TBUF_X4%3_34 0.0457628
R_x_PM_TBUF_X4%3_r17 x_PM_TBUF_X4%3_35 x_PM_TBUF_X4%3_33 0.212317
R_x_PM_TBUF_X4%3_r18 x_PM_TBUF_X4%3_34 x_PM_TBUF_X4%3_33 1.38429
R_x_PM_TBUF_X4%3_r19 N_3_M0_s x_PM_TBUF_X4%3_29 0.152
R_x_PM_TBUF_X4%3_r20 x_PM_TBUF_X4%3_28 x_PM_TBUF_X4%3_29 0.192227
R_x_PM_TBUF_X4%3_r21 x_PM_TBUF_X4%3_40 x_PM_TBUF_X4%3_27 0.156262
R_x_PM_TBUF_X4%3_r22 x_PM_TBUF_X4%3_28 x_PM_TBUF_X4%3_27 2.85
R_x_PM_TBUF_X4%3_r23 x_PM_TBUF_X4%3_40 x_PM_TBUF_X4%3_23 0.156262
R_x_PM_TBUF_X4%3_r24 N_3_M6_s x_PM_TBUF_X4%3_23 0.57
R_x_PM_TBUF_X4%3_r25 x_PM_TBUF_X4%3_42 x_PM_TBUF_X4%3_19 52.78
R_x_PM_TBUF_X4%3_r26 x_PM_TBUF_X4%3_20 x_PM_TBUF_X4%3_19 0.043368
R_x_PM_TBUF_X4%3_r27 x_PM_TBUF_X4%3_42 x_PM_TBUF_X4%3_17 1.3
R_x_PM_TBUF_X4%3_r28 x_PM_TBUF_X4%3_18 x_PM_TBUF_X4%3_17 0.043368
R_x_PM_TBUF_X4%3_r29 x_PM_TBUF_X4%3_20 x_PM_TBUF_X4%3_13 4.56151
R_x_PM_TBUF_X4%3_r30 N_3_M4_g x_PM_TBUF_X4%3_13 56.94
R_x_PM_TBUF_X4%3_r31 x_PM_TBUF_X4%3_20 x_PM_TBUF_X4%3_9 4.56151
R_x_PM_TBUF_X4%3_r32 N_3_M10_g x_PM_TBUF_X4%3_9 51.48
R_x_PM_TBUF_X4%3_r33 x_PM_TBUF_X4%3_18 x_PM_TBUF_X4%3_5 4.56151
R_x_PM_TBUF_X4%3_r34 N_3_M1_g x_PM_TBUF_X4%3_5 56.94
R_x_PM_TBUF_X4%3_r35 x_PM_TBUF_X4%3_18 x_PM_TBUF_X4%3_VSS 4.56151
R_x_PM_TBUF_X4%3_r36 N_3_M7_g x_PM_TBUF_X4%3_VSS 51.48
C_x_PM_TBUF_X4%A_c0 VSS A 7.48901e-17
C_x_PM_TBUF_X4%A_c1 VSS x_PM_TBUF_X4%A_11 1.21539e-17
C_x_PM_TBUF_X4%A_c2 VSS N_A_M0_g 6.4871e-17
C_x_PM_TBUF_X4%A_c3 VSS N_A_M6_g 4.77962e-17
R_x_PM_TBUF_X4%A_r4 x_PM_TBUF_X4%A_11 x_PM_TBUF_X4%A_16 3.38
R_x_PM_TBUF_X4%A_r5 x_PM_TBUF_X4%A_11 x_PM_TBUF_X4%A_9 25.0012
R_x_PM_TBUF_X4%A_r6 A x_PM_TBUF_X4%A_9 0.169643
R_x_PM_TBUF_X4%A_r7 x_PM_TBUF_X4%A_16 x_PM_TBUF_X4%A_5 1.95
R_x_PM_TBUF_X4%A_r8 N_A_M0_g x_PM_TBUF_X4%A_5 69.81
R_x_PM_TBUF_X4%A_r9 x_PM_TBUF_X4%A_16 x_PM_TBUF_X4%A_VSS 1.95
R_x_PM_TBUF_X4%A_r10 N_A_M6_g x_PM_TBUF_X4%A_VSS 45.63
C_x_PM_TBUF_X4%Z_c0 VSS x_PM_TBUF_X4%Z_16 6.83596e-17
C_x_PM_TBUF_X4%Z_c1 VSS N_Z_M8_d 4.10236e-17
C_x_PM_TBUF_X4%Z_c2 VSS Z 3.48757e-17
C_x_PM_TBUF_X4%Z_c3 VSS x_PM_TBUF_X4%Z_5 1.30293e-17
R_x_PM_TBUF_X4%Z_r4 N_Z_M8_d x_PM_TBUF_X4%Z_11 0.232222
R_x_PM_TBUF_X4%Z_r5 N_Z_M2_d Z 0.153226
R_x_PM_TBUF_X4%Z_r6 x_PM_TBUF_X4%Z_16 x_PM_TBUF_X4%Z_5 0.305659
R_x_PM_TBUF_X4%Z_r7 Z x_PM_TBUF_X4%Z_5 0.165484
R_x_PM_TBUF_X4%Z_r8 x_PM_TBUF_X4%Z_11 x_PM_TBUF_X4%Z_3 0.095
R_x_PM_TBUF_X4%Z_r9 x_PM_TBUF_X4%Z_16 x_PM_TBUF_X4%Z_3 2.30714
C_x_PM_TBUF_X4%6_c0 VSS x_PM_TBUF_X4%6_24 2.32385e-18
C_x_PM_TBUF_X4%6_c1 VSS N_6_M5_d 5.86188e-17
C_x_PM_TBUF_X4%6_c2 VSS x_PM_TBUF_X4%6_19 5.09702e-17
C_x_PM_TBUF_X4%6_c3 VSS x_PM_TBUF_X4%6_13 7.56255e-17
C_x_PM_TBUF_X4%6_c4 VSS N_6_M9_g 2.82086e-17
C_x_PM_TBUF_X4%6_c5 VSS x_PM_TBUF_X4%6_7 5.95871e-18
C_x_PM_TBUF_X4%6_c6 VSS x_PM_TBUF_X4%6_6 9.11101e-18
C_x_PM_TBUF_X4%6_c7 VSS x_PM_TBUF_X4%6_5 1.58673e-17
C_x_PM_TBUF_X4%6_c8 VSS N_6_M8_g 3.62876e-17
R_x_PM_TBUF_X4%6_r9 x_PM_TBUF_X4%6_24 x_PM_TBUF_X4%6_20 0.123935
R_x_PM_TBUF_X4%6_r10 N_6_M5_d x_PM_TBUF_X4%6_20 1.43
R_x_PM_TBUF_X4%6_r11 x_PM_TBUF_X4%6_24 x_PM_TBUF_X4%6_19 0.123935
R_x_PM_TBUF_X4%6_r12 x_PM_TBUF_X4%6_16 x_PM_TBUF_X4%6_14 25.0012
R_x_PM_TBUF_X4%6_r13 x_PM_TBUF_X4%6_24 x_PM_TBUF_X4%6_13 0.0766861
R_x_PM_TBUF_X4%6_r14 x_PM_TBUF_X4%6_14 x_PM_TBUF_X4%6_13 2.45643
R_x_PM_TBUF_X4%6_r15 x_PM_TBUF_X4%6_19 N_6_M11_d 0.627567
R_x_PM_TBUF_X4%6_r16 x_PM_TBUF_X4%6_16 x_PM_TBUF_X4%6_7 3.67098
R_x_PM_TBUF_X4%6_r17 N_6_M9_g x_PM_TBUF_X4%6_7 28.08
R_x_PM_TBUF_X4%6_r18 x_PM_TBUF_X4%6_16 x_PM_TBUF_X4%6_5 0.917744
R_x_PM_TBUF_X4%6_r19 x_PM_TBUF_X4%6_6 x_PM_TBUF_X4%6_5 14.56
R_x_PM_TBUF_X4%6_r20 x_PM_TBUF_X4%6_6 x_PM_TBUF_X4%6_VSS 4.58872
R_x_PM_TBUF_X4%6_r21 N_6_M8_g x_PM_TBUF_X4%6_VSS 28.08
C_x_PM_TBUF_X4%EN_c0 VSS x_PM_TBUF_X4%EN_31 1.44819e-17
C_x_PM_TBUF_X4%EN_c1 VSS x_PM_TBUF_X4%EN_25 5.5427e-17
C_x_PM_TBUF_X4%EN_c2 VSS x_PM_TBUF_X4%EN_21 4.4746e-18
C_x_PM_TBUF_X4%EN_c3 VSS N_EN_M5_g 6.27362e-17
C_x_PM_TBUF_X4%EN_c4 VSS N_EN_M11_g 5.94957e-17
C_x_PM_TBUF_X4%EN_c5 VSS x_PM_TBUF_X4%EN_11 4.39142e-17
C_x_PM_TBUF_X4%EN_c6 VSS N_EN_M3_g 4.09989e-17
C_x_PM_TBUF_X4%EN_c7 VSS x_PM_TBUF_X4%EN_6 6.50566e-18
C_x_PM_TBUF_X4%EN_c8 VSS x_PM_TBUF_X4%EN_5 1.50594e-17
C_x_PM_TBUF_X4%EN_c9 VSS N_EN_M2_g 5.28808e-17
R_x_PM_TBUF_X4%EN_r10 x_PM_TBUF_X4%EN_31 x_PM_TBUF_X4%EN_27 5.98
R_x_PM_TBUF_X4%EN_r11 x_PM_TBUF_X4%EN_27 x_PM_TBUF_X4%EN_25 25.0012
R_x_PM_TBUF_X4%EN_r12 x_PM_TBUF_X4%EN_25 EN 0.101786
R_x_PM_TBUF_X4%EN_r13 N_EN_M5_g x_PM_TBUF_X4%EN_18 69.81
R_x_PM_TBUF_X4%EN_r14 x_PM_TBUF_X4%EN_31 x_PM_TBUF_X4%EN_17 1.95
R_x_PM_TBUF_X4%EN_r15 N_EN_M5_g x_PM_TBUF_X4%EN_17 30.81
R_x_PM_TBUF_X4%EN_r16 x_PM_TBUF_X4%EN_31 x_PM_TBUF_X4%EN_13 1.95
R_x_PM_TBUF_X4%EN_r17 N_EN_M11_g x_PM_TBUF_X4%EN_13 59.67
R_x_PM_TBUF_X4%EN_r18 x_PM_TBUF_X4%EN_21 x_PM_TBUF_X4%EN_12 3.30287
R_x_PM_TBUF_X4%EN_r19 x_PM_TBUF_X4%EN_18 x_PM_TBUF_X4%EN_11 4.35808
R_x_PM_TBUF_X4%EN_r20 x_PM_TBUF_X4%EN_12 x_PM_TBUF_X4%EN_11 51.48
R_x_PM_TBUF_X4%EN_r21 x_PM_TBUF_X4%EN_21 x_PM_TBUF_X4%EN_7 0.858359
R_x_PM_TBUF_X4%EN_r22 N_EN_M3_g x_PM_TBUF_X4%EN_7 49.92
R_x_PM_TBUF_X4%EN_r23 x_PM_TBUF_X4%EN_21 x_PM_TBUF_X4%EN_5 3.30287
R_x_PM_TBUF_X4%EN_r24 x_PM_TBUF_X4%EN_6 x_PM_TBUF_X4%EN_5 21.84
R_x_PM_TBUF_X4%EN_r25 x_PM_TBUF_X4%EN_6 x_PM_TBUF_X4%EN_VSS 4.35808
R_x_PM_TBUF_X4%EN_r26 N_EN_M2_g x_PM_TBUF_X4%EN_VSS 49.92
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TBUF_X8.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TBUF_X8 VSS VDD A Z EN
*.PININFO VSS:B VDD:B A:I Z:O EN:I
M_M10 N_VDD_M0_d N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M11 8 N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M12 N_Z_M2_d N_EN_M2_g 8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M13 9 N_EN_M3_g N_Z_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M14 N_VDD_M4_d N_3_M4_g 9 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M15 10 N_3_M5_g N_VDD_M4_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M16 N_Z_M6_d N_EN_M6_g 10 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M17 11 N_EN_M7_g N_Z_M6_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M18 N_VDD_M8_d N_3_M8_g 11 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M19 N_6_M9_d N_EN_M9_g N_VDD_M8_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M0 N_VSS_M10_d N_A_M10_g N_3_M10_s VSS NMOS_VTL W=0.095000U L=0.050000U
M_M1 12 N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M2 N_Z_M12_d N_6_M12_g 12 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 13 N_6_M13_g N_Z_M12_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M14_d N_3_M14_g 13 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M5 14 N_3_M15_g N_VSS_M14_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M6 N_Z_M16_d N_6_M16_g 14 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M7 15 N_6_M17_g N_Z_M16_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M8 N_VSS_M18_d N_3_M18_g 15 VSS NMOS_VTL W=0.260000U L=0.050000U
M_M9 N_6_M19_d N_EN_M19_g N_VSS_M18_d VSS NMOS_VTL W=0.095000U L=0.050000U
C_x_PM_TBUF_X8%VSS_c0 VSS x_PM_TBUF_X8%VSS_27 2.98373e-17
C_x_PM_TBUF_X8%VSS_c1 VSS x_PM_TBUF_X8%VSS_26 3.61398e-17
C_x_PM_TBUF_X8%VSS_c2 VSS x_PM_TBUF_X8%VSS_23 7.5872e-17
C_x_PM_TBUF_X8%VSS_c3 VSS x_PM_TBUF_X8%VSS_20 3.03717e-17
C_x_PM_TBUF_X8%VSS_c4 VSS N_VSS_M18_d 4.31446e-17
C_x_PM_TBUF_X8%VSS_c5 VSS x_PM_TBUF_X8%VSS_12 7.15159e-17
C_x_PM_TBUF_X8%VSS_c6 VSS N_VSS_M10_d 4.73632e-17
R_x_PM_TBUF_X8%VSS_r7 x_PM_TBUF_X8%VSS_26 N_VSS_M14_d 0.140674
R_x_PM_TBUF_X8%VSS_r8 N_VSS_M14_d VSS 0.0116327
R_x_PM_TBUF_X8%VSS_r9 x_PM_TBUF_X8%VSS_23 VSS 0.129041
R_x_PM_TBUF_X8%VSS_r10 x_PM_TBUF_X8%VSS_27 x_PM_TBUF_X8%VSS_14 0.145286
R_x_PM_TBUF_X8%VSS_r11 N_VSS_M18_d x_PM_TBUF_X8%VSS_14 1.12643
R_x_PM_TBUF_X8%VSS_r12 x_PM_TBUF_X8%VSS_27 x_PM_TBUF_X8%VSS_12 0.0731438
R_x_PM_TBUF_X8%VSS_r13 x_PM_TBUF_X8%VSS_26 x_PM_TBUF_X8%VSS_12 1.46412
R_x_PM_TBUF_X8%VSS_r14 x_PM_TBUF_X8%VSS_20 x_PM_TBUF_X8%VSS_11 0.0731438
R_x_PM_TBUF_X8%VSS_r15 x_PM_TBUF_X8%VSS_11 x_PM_TBUF_X8%VSS_23 1.48647
R_x_PM_TBUF_X8%VSS_r16 x_PM_TBUF_X8%VSS_20 x_PM_TBUF_X8%VSS_6 0.145286
R_x_PM_TBUF_X8%VSS_r17 N_VSS_M10_d x_PM_TBUF_X8%VSS_6 1.12643
C_x_PM_TBUF_X8%VDD_c0 VSS x_PM_TBUF_X8%VDD_28 2.95982e-17
C_x_PM_TBUF_X8%VDD_c1 VSS x_PM_TBUF_X8%VDD_27 4.64934e-18
C_x_PM_TBUF_X8%VDD_c2 VSS x_PM_TBUF_X8%VDD_26 2.98769e-17
C_x_PM_TBUF_X8%VDD_c3 VSS N_VDD_M8_d 2.52146e-17
C_x_PM_TBUF_X8%VDD_c4 VSS x_PM_TBUF_X8%VDD_18 7.13226e-17
C_x_PM_TBUF_X8%VDD_c5 VSS N_VDD_M4_d 3.61417e-17
C_x_PM_TBUF_X8%VDD_c6 VSS x_PM_TBUF_X8%VDD_10 7.16386e-17
C_x_PM_TBUF_X8%VDD_c7 VSS N_VDD_M0_d 2.61064e-17
R_x_PM_TBUF_X8%VDD_r8 x_PM_TBUF_X8%VDD_28 x_PM_TBUF_X8%VDD_20 0.145286
R_x_PM_TBUF_X8%VDD_r9 N_VDD_M8_d x_PM_TBUF_X8%VDD_20 0.909286
R_x_PM_TBUF_X8%VDD_r10 x_PM_TBUF_X8%VDD_27 x_PM_TBUF_X8%VDD_19 0.0731438
R_x_PM_TBUF_X8%VDD_r11 x_PM_TBUF_X8%VDD_28 x_PM_TBUF_X8%VDD_18 0.0731438
R_x_PM_TBUF_X8%VDD_r12 x_PM_TBUF_X8%VDD_19 x_PM_TBUF_X8%VDD_18 1.54235
R_x_PM_TBUF_X8%VDD_r13 VDD N_VDD_M4_d 0.732857
R_x_PM_TBUF_X8%VDD_r14 x_PM_TBUF_X8%VDD_27 x_PM_TBUF_X8%VDD_12 0.145286
R_x_PM_TBUF_X8%VDD_r15 VDD x_PM_TBUF_X8%VDD_12 0.176429
R_x_PM_TBUF_X8%VDD_r16 x_PM_TBUF_X8%VDD_26 x_PM_TBUF_X8%VDD_11 0.0731438
R_x_PM_TBUF_X8%VDD_r17 x_PM_TBUF_X8%VDD_27 x_PM_TBUF_X8%VDD_10 0.0731438
R_x_PM_TBUF_X8%VDD_r18 x_PM_TBUF_X8%VDD_11 x_PM_TBUF_X8%VDD_10 1.54235
R_x_PM_TBUF_X8%VDD_r19 x_PM_TBUF_X8%VDD_26 x_PM_TBUF_X8%VDD_6 0.145286
R_x_PM_TBUF_X8%VDD_r20 N_VDD_M0_d x_PM_TBUF_X8%VDD_6 0.909286
C_x_PM_TBUF_X8%3_c0 VSS x_PM_TBUF_X8%3_63 8.71048e-18
C_x_PM_TBUF_X8%3_c1 VSS x_PM_TBUF_X8%3_55 2.30825e-17
C_x_PM_TBUF_X8%3_c2 VSS N_3_M0_s 2.25358e-17
C_x_PM_TBUF_X8%3_c3 VSS x_PM_TBUF_X8%3_50 2.68743e-18
C_x_PM_TBUF_X8%3_c4 VSS x_PM_TBUF_X8%3_48 4.7531e-17
C_x_PM_TBUF_X8%3_c5 VSS x_PM_TBUF_X8%3_47 5.32944e-17
C_x_PM_TBUF_X8%3_c6 VSS N_3_M10_s 2.76848e-17
C_x_PM_TBUF_X8%3_c7 VSS x_PM_TBUF_X8%3_39 5.0758e-18
C_x_PM_TBUF_X8%3_c8 VSS x_PM_TBUF_X8%3_38 3.49561e-18
C_x_PM_TBUF_X8%3_c9 VSS x_PM_TBUF_X8%3_37 4.61669e-18
C_x_PM_TBUF_X8%3_c10 VSS N_3_M18_g 1.37432e-16
C_x_PM_TBUF_X8%3_c11 VSS N_3_M5_g 6.31018e-17
C_x_PM_TBUF_X8%3_c12 VSS N_3_M15_g 3.18198e-17
C_x_PM_TBUF_X8%3_c13 VSS x_PM_TBUF_X8%3_21 9.2362e-17
C_x_PM_TBUF_X8%3_c14 VSS x_PM_TBUF_X8%3_19 1.15594e-17
C_x_PM_TBUF_X8%3_c15 VSS N_3_M4_g 6.51905e-17
C_x_PM_TBUF_X8%3_c16 VSS N_3_M14_g 3.20342e-17
C_x_PM_TBUF_X8%3_c17 VSS x_PM_TBUF_X8%3_10 6.01812e-18
C_x_PM_TBUF_X8%3_c18 VSS x_PM_TBUF_X8%3_9 6.70932e-17
C_x_PM_TBUF_X8%3_c19 VSS N_3_M1_g 7.37556e-17
C_x_PM_TBUF_X8%3_c20 VSS N_3_M11_g 4.39688e-17
R_x_PM_TBUF_X8%3_r21 x_PM_TBUF_X8%3_63 x_PM_TBUF_X8%3_61 3.38
R_x_PM_TBUF_X8%3_r22 x_PM_TBUF_X8%3_63 x_PM_TBUF_X8%3_58 25.0012
R_x_PM_TBUF_X8%3_r23 x_PM_TBUF_X8%3_58 x_PM_TBUF_X8%3_55 0.176429
R_x_PM_TBUF_X8%3_r24 x_PM_TBUF_X8%3_50 x_PM_TBUF_X8%3_49 0.0604376
R_x_PM_TBUF_X8%3_r25 x_PM_TBUF_X8%3_55 x_PM_TBUF_X8%3_48 0.095
R_x_PM_TBUF_X8%3_r26 x_PM_TBUF_X8%3_49 x_PM_TBUF_X8%3_48 1.35714
R_x_PM_TBUF_X8%3_r27 x_PM_TBUF_X8%3_47 N_3_M0_s 0.297071
R_x_PM_TBUF_X8%3_r28 x_PM_TBUF_X8%3_50 x_PM_TBUF_X8%3_46 0.140052
R_x_PM_TBUF_X8%3_r29 x_PM_TBUF_X8%3_47 x_PM_TBUF_X8%3_46 2.85
R_x_PM_TBUF_X8%3_r30 x_PM_TBUF_X8%3_50 x_PM_TBUF_X8%3_42 0.140052
R_x_PM_TBUF_X8%3_r31 N_3_M10_s x_PM_TBUF_X8%3_42 0.45
R_x_PM_TBUF_X8%3_r32 N_3_M8_g N_3_M18_g 120.12
R_x_PM_TBUF_X8%3_r33 N_3_M8_g x_PM_TBUF_X8%3_31 49.92
R_x_PM_TBUF_X8%3_r34 x_PM_TBUF_X8%3_39 x_PM_TBUF_X8%3_27 3.30287
R_x_PM_TBUF_X8%3_r35 N_3_M5_g x_PM_TBUF_X8%3_27 84.24
R_x_PM_TBUF_X8%3_r36 x_PM_TBUF_X8%3_39 x_PM_TBUF_X8%3_23 3.30287
R_x_PM_TBUF_X8%3_r37 N_3_M15_g x_PM_TBUF_X8%3_23 28.08
R_x_PM_TBUF_X8%3_r38 x_PM_TBUF_X8%3_38 x_PM_TBUF_X8%3_22 3.30287
R_x_PM_TBUF_X8%3_r39 x_PM_TBUF_X8%3_31 x_PM_TBUF_X8%3_21 4.35808
R_x_PM_TBUF_X8%3_r40 x_PM_TBUF_X8%3_22 x_PM_TBUF_X8%3_21 110.76
R_x_PM_TBUF_X8%3_r41 x_PM_TBUF_X8%3_37 x_PM_TBUF_X8%3_20 0.858359
R_x_PM_TBUF_X8%3_r42 x_PM_TBUF_X8%3_39 x_PM_TBUF_X8%3_19 0.858359
R_x_PM_TBUF_X8%3_r43 x_PM_TBUF_X8%3_20 x_PM_TBUF_X8%3_19 21.84
R_x_PM_TBUF_X8%3_r44 x_PM_TBUF_X8%3_38 x_PM_TBUF_X8%3_16 0.858359
R_x_PM_TBUF_X8%3_r45 N_3_M4_g x_PM_TBUF_X8%3_16 49.92
R_x_PM_TBUF_X8%3_r46 x_PM_TBUF_X8%3_37 x_PM_TBUF_X8%3_15 3.30287
R_x_PM_TBUF_X8%3_r47 N_3_M4_g x_PM_TBUF_X8%3_15 84.24
R_x_PM_TBUF_X8%3_r48 x_PM_TBUF_X8%3_37 x_PM_TBUF_X8%3_11 3.30287
R_x_PM_TBUF_X8%3_r49 N_3_M14_g x_PM_TBUF_X8%3_11 28.08
R_x_PM_TBUF_X8%3_r50 x_PM_TBUF_X8%3_38 x_PM_TBUF_X8%3_9 3.30287
R_x_PM_TBUF_X8%3_r51 x_PM_TBUF_X8%3_10 x_PM_TBUF_X8%3_9 81.12
R_x_PM_TBUF_X8%3_r52 x_PM_TBUF_X8%3_10 x_PM_TBUF_X8%3_6 4.35808
R_x_PM_TBUF_X8%3_r53 N_3_M1_g x_PM_TBUF_X8%3_6 49.92
R_x_PM_TBUF_X8%3_r54 x_PM_TBUF_X8%3_61 x_PM_TBUF_X8%3_5 1.95
R_x_PM_TBUF_X8%3_r55 N_3_M1_g x_PM_TBUF_X8%3_5 71.76
R_x_PM_TBUF_X8%3_r56 x_PM_TBUF_X8%3_61 x_PM_TBUF_X8%3_VSS 1.95
R_x_PM_TBUF_X8%3_r57 N_3_M11_g x_PM_TBUF_X8%3_VSS 36.66
C_x_PM_TBUF_X8%A_c0 VSS A 6.54853e-17
C_x_PM_TBUF_X8%A_c1 VSS x_PM_TBUF_X8%A_11 1.0031e-17
C_x_PM_TBUF_X8%A_c2 VSS N_A_M0_g 6.43884e-17
C_x_PM_TBUF_X8%A_c3 VSS N_A_M10_g 4.82961e-17
R_x_PM_TBUF_X8%A_r4 x_PM_TBUF_X8%A_18 x_PM_TBUF_X8%A_11 4.7687
R_x_PM_TBUF_X8%A_r5 x_PM_TBUF_X8%A_17 x_PM_TBUF_X8%A_11 4.7687
R_x_PM_TBUF_X8%A_r6 x_PM_TBUF_X8%A_11 x_PM_TBUF_X8%A_9 25.0012
R_x_PM_TBUF_X8%A_r7 A x_PM_TBUF_X8%A_9 0.210357
R_x_PM_TBUF_X8%A_r8 N_A_M0_g x_PM_TBUF_X8%A_18 69.81
R_x_PM_TBUF_X8%A_r9 N_A_M10_g x_PM_TBUF_X8%A_17 45.63
C_x_PM_TBUF_X8%Z_c0 VSS x_PM_TBUF_X8%Z_21 8.37361e-17
C_x_PM_TBUF_X8%Z_c1 VSS Z 1.56996e-17
C_x_PM_TBUF_X8%Z_c2 VSS N_Z_M6_d 1.4873e-16
C_x_PM_TBUF_X8%Z_c3 VSS x_PM_TBUF_X8%Z_15 1.15731e-17
C_x_PM_TBUF_X8%Z_c4 VSS x_PM_TBUF_X8%Z_12 1.51694e-17
C_x_PM_TBUF_X8%Z_c5 VSS x_PM_TBUF_X8%Z_11 1.44048e-16
C_x_PM_TBUF_X8%Z_c6 VSS N_Z_M2_d 3.46851e-17
R_x_PM_TBUF_X8%Z_r7 x_PM_TBUF_X8%Z_21 Z 0.300409
R_x_PM_TBUF_X8%Z_r8 N_Z_M16_d x_PM_TBUF_X8%Z_15 0.0141545
R_x_PM_TBUF_X8%Z_r9 N_Z_M6_d x_PM_TBUF_X8%Z_15 3.62357
R_x_PM_TBUF_X8%Z_r10 N_Z_M12_d x_PM_TBUF_X8%Z_12 0.312143
R_x_PM_TBUF_X8%Z_r11 N_Z_M16_d x_PM_TBUF_X8%Z_11 0.198162
R_x_PM_TBUF_X8%Z_r12 N_Z_M12_d x_PM_TBUF_X8%Z_11 3.92214
R_x_PM_TBUF_X8%Z_r13 Z x_PM_TBUF_X8%Z_7 0.011875
R_x_PM_TBUF_X8%Z_r14 N_Z_M2_d x_PM_TBUF_X8%Z_7 0.302812
R_x_PM_TBUF_X8%Z_r15 x_PM_TBUF_X8%Z_12 x_PM_TBUF_X8%Z_5 0.212317
R_x_PM_TBUF_X8%Z_r16 x_PM_TBUF_X8%Z_21 x_PM_TBUF_X8%Z_5 2.87714
C_x_PM_TBUF_X8%6_c0 VSS x_PM_TBUF_X8%6_57 1.48534e-17
C_x_PM_TBUF_X8%6_c1 VSS N_6_M9_d 2.15957e-17
C_x_PM_TBUF_X8%6_c2 VSS x_PM_TBUF_X8%6_47 2.60856e-18
C_x_PM_TBUF_X8%6_c3 VSS x_PM_TBUF_X8%6_43 8.79192e-18
C_x_PM_TBUF_X8%6_c4 VSS x_PM_TBUF_X8%6_41 3.83813e-17
C_x_PM_TBUF_X8%6_c5 VSS x_PM_TBUF_X8%6_39 1.32056e-16
C_x_PM_TBUF_X8%6_c6 VSS x_PM_TBUF_X8%6_37 5.53601e-17
C_x_PM_TBUF_X8%6_c7 VSS x_PM_TBUF_X8%6_35 4.55948e-17
C_x_PM_TBUF_X8%6_c8 VSS x_PM_TBUF_X8%6_28 5.07778e-17
C_x_PM_TBUF_X8%6_c9 VSS N_6_M19_d 2.63021e-17
C_x_PM_TBUF_X8%6_c10 VSS N_6_M17_g 2.81344e-17
C_x_PM_TBUF_X8%6_c11 VSS x_PM_TBUF_X8%6_16 1.0189e-17
C_x_PM_TBUF_X8%6_c12 VSS N_6_M16_g 3.08851e-17
C_x_PM_TBUF_X8%6_c13 VSS N_6_M13_g 3.18627e-17
C_x_PM_TBUF_X8%6_c14 VSS x_PM_TBUF_X8%6_7 4.73681e-18
C_x_PM_TBUF_X8%6_c15 VSS x_PM_TBUF_X8%6_6 6.9915e-18
C_x_PM_TBUF_X8%6_c16 VSS x_PM_TBUF_X8%6_5 1.1907e-17
C_x_PM_TBUF_X8%6_c17 VSS N_6_M12_g 3.17398e-17
R_x_PM_TBUF_X8%6_r18 x_PM_TBUF_X8%6_57 x_PM_TBUF_X8%6_56 2.64572
R_x_PM_TBUF_X8%6_r19 x_PM_TBUF_X8%6_54 x_PM_TBUF_X8%6_52 4.42
R_x_PM_TBUF_X8%6_r20 x_PM_TBUF_X8%6_43 x_PM_TBUF_X8%6_56 3.38
R_x_PM_TBUF_X8%6_r21 x_PM_TBUF_X8%6_43 x_PM_TBUF_X8%6_41 25.0012
R_x_PM_TBUF_X8%6_r22 x_PM_TBUF_X8%6_45 x_PM_TBUF_X8%6_41 0.176429
R_x_PM_TBUF_X8%6_r23 x_PM_TBUF_X8%6_39 x_PM_TBUF_X8%6_37 0.131883
R_x_PM_TBUF_X8%6_r24 x_PM_TBUF_X8%6_52 x_PM_TBUF_X8%6_37 25.0012
R_x_PM_TBUF_X8%6_r25 x_PM_TBUF_X8%6_35 N_6_M9_d 0.30478
R_x_PM_TBUF_X8%6_r26 x_PM_TBUF_X8%6_47 x_PM_TBUF_X8%6_34 0.143785
R_x_PM_TBUF_X8%6_r27 x_PM_TBUF_X8%6_35 x_PM_TBUF_X8%6_34 2.79571
R_x_PM_TBUF_X8%6_r28 x_PM_TBUF_X8%6_47 x_PM_TBUF_X8%6_30 0.143785
R_x_PM_TBUF_X8%6_r29 x_PM_TBUF_X8%6_45 x_PM_TBUF_X8%6_29 0.095
R_x_PM_TBUF_X8%6_r30 x_PM_TBUF_X8%6_47 x_PM_TBUF_X8%6_28 0.0569232
R_x_PM_TBUF_X8%6_r31 x_PM_TBUF_X8%6_29 x_PM_TBUF_X8%6_28 2.00857
R_x_PM_TBUF_X8%6_r32 x_PM_TBUF_X8%6_26 x_PM_TBUF_X8%6_24 25.0012
R_x_PM_TBUF_X8%6_r33 x_PM_TBUF_X8%6_24 x_PM_TBUF_X8%6_39 1.9475
R_x_PM_TBUF_X8%6_r34 N_6_M19_d x_PM_TBUF_X8%6_30 0.517222
R_x_PM_TBUF_X8%6_r35 x_PM_TBUF_X8%6_56 x_PM_TBUF_X8%6_17 1.95
R_x_PM_TBUF_X8%6_r36 N_6_M17_g x_PM_TBUF_X8%6_17 28.08
R_x_PM_TBUF_X8%6_r37 x_PM_TBUF_X8%6_16 x_PM_TBUF_X8%6_54 2.64572
R_x_PM_TBUF_X8%6_r38 x_PM_TBUF_X8%6_16 x_PM_TBUF_X8%6_57 15.6
R_x_PM_TBUF_X8%6_r39 x_PM_TBUF_X8%6_54 x_PM_TBUF_X8%6_11 1.95
R_x_PM_TBUF_X8%6_r40 N_6_M16_g x_PM_TBUF_X8%6_11 28.08
R_x_PM_TBUF_X8%6_r41 x_PM_TBUF_X8%6_26 x_PM_TBUF_X8%6_7 4.40517
R_x_PM_TBUF_X8%6_r42 N_6_M13_g x_PM_TBUF_X8%6_7 28.08
R_x_PM_TBUF_X8%6_r43 x_PM_TBUF_X8%6_26 x_PM_TBUF_X8%6_5 0.183549
R_x_PM_TBUF_X8%6_r44 x_PM_TBUF_X8%6_6 x_PM_TBUF_X8%6_5 14.56
R_x_PM_TBUF_X8%6_r45 x_PM_TBUF_X8%6_6 x_PM_TBUF_X8%6_VSS 4.58872
R_x_PM_TBUF_X8%6_r46 N_6_M12_g x_PM_TBUF_X8%6_VSS 28.08
C_x_PM_TBUF_X8%EN_c0 VSS x_PM_TBUF_X8%EN_58 1.54435e-17
C_x_PM_TBUF_X8%EN_c1 VSS x_PM_TBUF_X8%EN_49 8.60531e-18
C_x_PM_TBUF_X8%EN_c2 VSS x_PM_TBUF_X8%EN_46 8.4129e-17
C_x_PM_TBUF_X8%EN_c3 VSS x_PM_TBUF_X8%EN_44 4.43633e-17
C_x_PM_TBUF_X8%EN_c4 VSS x_PM_TBUF_X8%EN_39 4.39755e-17
C_x_PM_TBUF_X8%EN_c5 VSS EN 3.40993e-17
C_x_PM_TBUF_X8%EN_c6 VSS x_PM_TBUF_X8%EN_34 2.88338e-17
C_x_PM_TBUF_X8%EN_c7 VSS N_EN_M9_g 6.05886e-17
C_x_PM_TBUF_X8%EN_c8 VSS N_EN_M19_g 5.25218e-17
C_x_PM_TBUF_X8%EN_c9 VSS N_EN_M7_g 3.54791e-17
C_x_PM_TBUF_X8%EN_c10 VSS x_PM_TBUF_X8%EN_16 9.43863e-18
C_x_PM_TBUF_X8%EN_c11 VSS x_PM_TBUF_X8%EN_15 1.51796e-17
C_x_PM_TBUF_X8%EN_c12 VSS N_EN_M6_g 3.59901e-17
C_x_PM_TBUF_X8%EN_c13 VSS N_EN_M3_g 3.59649e-17
C_x_PM_TBUF_X8%EN_c14 VSS x_PM_TBUF_X8%EN_7 5.22766e-18
C_x_PM_TBUF_X8%EN_c15 VSS x_PM_TBUF_X8%EN_6 7.07716e-18
C_x_PM_TBUF_X8%EN_c16 VSS x_PM_TBUF_X8%EN_5 1.25741e-17
C_x_PM_TBUF_X8%EN_c17 VSS N_EN_M2_g 4.31878e-17
R_x_PM_TBUF_X8%EN_r18 x_PM_TBUF_X8%EN_52 x_PM_TBUF_X8%EN_50 4.42
R_x_PM_TBUF_X8%EN_r19 x_PM_TBUF_X8%EN_49 x_PM_TBUF_X8%EN_53 3.38
R_x_PM_TBUF_X8%EN_r20 x_PM_TBUF_X8%EN_49 x_PM_TBUF_X8%EN_48 25.0012
R_x_PM_TBUF_X8%EN_r21 x_PM_TBUF_X8%EN_46 x_PM_TBUF_X8%EN_44 0.131883
R_x_PM_TBUF_X8%EN_r22 x_PM_TBUF_X8%EN_50 x_PM_TBUF_X8%EN_44 25.0012
R_x_PM_TBUF_X8%EN_r23 x_PM_TBUF_X8%EN_58 x_PM_TBUF_X8%EN_41 5.46
R_x_PM_TBUF_X8%EN_r24 x_PM_TBUF_X8%EN_41 x_PM_TBUF_X8%EN_39 25.0012
R_x_PM_TBUF_X8%EN_r25 x_PM_TBUF_X8%EN_48 x_PM_TBUF_X8%EN_38 0.186554
R_x_PM_TBUF_X8%EN_r26 x_PM_TBUF_X8%EN_39 x_PM_TBUF_X8%EN_38 1.09929
R_x_PM_TBUF_X8%EN_r27 x_PM_TBUF_X8%EN_48 x_PM_TBUF_X8%EN_34 0.0485041
R_x_PM_TBUF_X8%EN_r28 EN x_PM_TBUF_X8%EN_34 0.1976
R_x_PM_TBUF_X8%EN_r29 x_PM_TBUF_X8%EN_32 x_PM_TBUF_X8%EN_30 25.0012
R_x_PM_TBUF_X8%EN_r30 x_PM_TBUF_X8%EN_30 x_PM_TBUF_X8%EN_46 1.9095
R_x_PM_TBUF_X8%EN_r31 x_PM_TBUF_X8%EN_58 x_PM_TBUF_X8%EN_25 1.95
R_x_PM_TBUF_X8%EN_r32 N_EN_M9_g x_PM_TBUF_X8%EN_25 64.35
R_x_PM_TBUF_X8%EN_r33 x_PM_TBUF_X8%EN_58 x_PM_TBUF_X8%EN_21 1.95
R_x_PM_TBUF_X8%EN_r34 N_EN_M19_g x_PM_TBUF_X8%EN_21 51.09
R_x_PM_TBUF_X8%EN_r35 x_PM_TBUF_X8%EN_53 x_PM_TBUF_X8%EN_17 1.95
R_x_PM_TBUF_X8%EN_r36 N_EN_M7_g x_PM_TBUF_X8%EN_17 39
R_x_PM_TBUF_X8%EN_r37 x_PM_TBUF_X8%EN_52 x_PM_TBUF_X8%EN_16 2.6
R_x_PM_TBUF_X8%EN_r38 x_PM_TBUF_X8%EN_53 x_PM_TBUF_X8%EN_15 2.6
R_x_PM_TBUF_X8%EN_r39 x_PM_TBUF_X8%EN_16 x_PM_TBUF_X8%EN_15 14.56
R_x_PM_TBUF_X8%EN_r40 x_PM_TBUF_X8%EN_52 x_PM_TBUF_X8%EN_11 1.95
R_x_PM_TBUF_X8%EN_r41 N_EN_M6_g x_PM_TBUF_X8%EN_11 39
R_x_PM_TBUF_X8%EN_r42 x_PM_TBUF_X8%EN_32 x_PM_TBUF_X8%EN_7 3.67098
R_x_PM_TBUF_X8%EN_r43 N_EN_M3_g x_PM_TBUF_X8%EN_7 39
R_x_PM_TBUF_X8%EN_r44 x_PM_TBUF_X8%EN_32 x_PM_TBUF_X8%EN_5 0.917744
R_x_PM_TBUF_X8%EN_r45 x_PM_TBUF_X8%EN_6 x_PM_TBUF_X8%EN_5 14.56
R_x_PM_TBUF_X8%EN_r46 x_PM_TBUF_X8%EN_6 x_PM_TBUF_X8%EN_VSS 4.58872
R_x_PM_TBUF_X8%EN_r47 N_EN_M2_g x_PM_TBUF_X8%EN_VSS 39
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TINV_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TINV_X1 VSS VDD EN I ZN
*.PININFO VSS:B VDD:B EN:I I:I ZN:O
M_M3 N_VDD_M0_d N_EN_M0_g N_3_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M4 7 N_I_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M5 N_ZN_M2_d N_EN_M2_g 7 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_VSS_M3_d N_EN_M3_g N_3_M3_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 8 N_I_M4_g N_VSS_M3_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_ZN_M5_d N_3_M5_g 8 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_TINV_X1%VSS_c0 VSS x_PM_TINV_X1%VSS_12 3.31128e-17
C_x_PM_TINV_X1%VSS_c1 VSS VSS 7.24435e-17
C_x_PM_TINV_X1%VSS_c2 VSS N_VSS_M3_d 4.15769e-17
R_x_PM_TINV_X1%VSS_r3 x_PM_TINV_X1%VSS_12 x_PM_TINV_X1%VSS_8 0.0731438
R_x_PM_TINV_X1%VSS_r4 VSS x_PM_TINV_X1%VSS_8 0.19
R_x_PM_TINV_X1%VSS_r5 x_PM_TINV_X1%VSS_12 x_PM_TINV_X1%VSS_4 0.145286
R_x_PM_TINV_X1%VSS_r6 N_VSS_M3_d x_PM_TINV_X1%VSS_4 0.773571
C_x_PM_TINV_X1%VDD_c0 VSS x_PM_TINV_X1%VDD_12 6.58365e-17
C_x_PM_TINV_X1%VDD_c1 VSS N_VDD_M0_d 3.78485e-17
C_x_PM_TINV_X1%VDD_c2 VSS x_PM_TINV_X1%VDD_2 3.29223e-17
R_x_PM_TINV_X1%VDD_r3 x_PM_TINV_X1%VDD_12 x_PM_TINV_X1%VDD_6 0.145286
R_x_PM_TINV_X1%VDD_r4 N_VDD_M0_d x_PM_TINV_X1%VDD_6 0.556429
R_x_PM_TINV_X1%VDD_r5 x_PM_TINV_X1%VDD_12 x_PM_TINV_X1%VDD_2 0.0731438
R_x_PM_TINV_X1%VDD_r6 VDD x_PM_TINV_X1%VDD_2 0.251471
C_x_PM_TINV_X1%3_c0 VSS x_PM_TINV_X1%3_24 1.15112e-17
C_x_PM_TINV_X1%3_c1 VSS x_PM_TINV_X1%3_20 2.29342e-18
C_x_PM_TINV_X1%3_c2 VSS x_PM_TINV_X1%3_17 7.79658e-17
C_x_PM_TINV_X1%3_c3 VSS N_3_M0_s 2.94275e-17
C_x_PM_TINV_X1%3_c4 VSS x_PM_TINV_X1%3_11 2.85243e-18
C_x_PM_TINV_X1%3_c5 VSS x_PM_TINV_X1%3_10 6.74873e-17
C_x_PM_TINV_X1%3_c6 VSS x_PM_TINV_X1%3_8 3.43946e-17
C_x_PM_TINV_X1%3_c7 VSS N_3_M5_g 3.33599e-17
R_x_PM_TINV_X1%3_r8 x_PM_TINV_X1%3_24 x_PM_TINV_X1%3_22 2.86
R_x_PM_TINV_X1%3_r9 x_PM_TINV_X1%3_22 x_PM_TINV_X1%3_17 25.0012
R_x_PM_TINV_X1%3_r10 x_PM_TINV_X1%3_20 x_PM_TINV_X1%3_15 0.0457628
R_x_PM_TINV_X1%3_r11 x_PM_TINV_X1%3_17 x_PM_TINV_X1%3_15 2.23929
R_x_PM_TINV_X1%3_r12 N_3_M0_s x_PM_TINV_X1%3_11 0.152
R_x_PM_TINV_X1%3_r13 x_PM_TINV_X1%3_10 x_PM_TINV_X1%3_11 0.192227
R_x_PM_TINV_X1%3_r14 x_PM_TINV_X1%3_20 x_PM_TINV_X1%3_9 0.156262
R_x_PM_TINV_X1%3_r15 x_PM_TINV_X1%3_10 x_PM_TINV_X1%3_9 3.58286
R_x_PM_TINV_X1%3_r16 x_PM_TINV_X1%3_20 x_PM_TINV_X1%3_8 0.156262
R_x_PM_TINV_X1%3_r17 x_PM_TINV_X1%3_8 N_3_M3_s 0.50787
R_x_PM_TINV_X1%3_r18 x_PM_TINV_X1%3_24 x_PM_TINV_X1%3_VSS 1.95
R_x_PM_TINV_X1%3_r19 N_3_M5_g x_PM_TINV_X1%3_VSS 24.18
C_x_PM_TINV_X1%EN_c0 VSS x_PM_TINV_X1%EN_27 1.28388e-17
C_x_PM_TINV_X1%EN_c1 VSS x_PM_TINV_X1%EN_16 6.41823e-17
C_x_PM_TINV_X1%EN_c2 VSS x_PM_TINV_X1%EN_15 6.97724e-17
C_x_PM_TINV_X1%EN_c3 VSS x_PM_TINV_X1%EN_14 1.17074e-17
C_x_PM_TINV_X1%EN_c4 VSS N_EN_M2_g 3.52989e-17
C_x_PM_TINV_X1%EN_c5 VSS N_EN_M0_g 3.06417e-17
C_x_PM_TINV_X1%EN_c6 VSS N_EN_M3_g 9.95637e-17
R_x_PM_TINV_X1%EN_r7 x_PM_TINV_X1%EN_27 x_PM_TINV_X1%EN_20 3.38
R_x_PM_TINV_X1%EN_r8 x_PM_TINV_X1%EN_20 x_PM_TINV_X1%EN_19 25.0012
R_x_PM_TINV_X1%EN_r9 x_PM_TINV_X1%EN_19 x_PM_TINV_X1%EN_16 0.115633
R_x_PM_TINV_X1%EN_r10 EN x_PM_TINV_X1%EN_16 0.120909
R_x_PM_TINV_X1%EN_r11 x_PM_TINV_X1%EN_19 x_PM_TINV_X1%EN_15 0.0995725
R_x_PM_TINV_X1%EN_r12 x_PM_TINV_X1%EN_14 x_PM_TINV_X1%EN_21 3.38
R_x_PM_TINV_X1%EN_r13 x_PM_TINV_X1%EN_15 x_PM_TINV_X1%EN_13 0.60062
R_x_PM_TINV_X1%EN_r14 x_PM_TINV_X1%EN_14 x_PM_TINV_X1%EN_13 25.0012
R_x_PM_TINV_X1%EN_r15 x_PM_TINV_X1%EN_27 x_PM_TINV_X1%EN_9 1.95
R_x_PM_TINV_X1%EN_r16 N_EN_M2_g x_PM_TINV_X1%EN_9 25.35
R_x_PM_TINV_X1%EN_r17 x_PM_TINV_X1%EN_21 x_PM_TINV_X1%EN_5 1.95
R_x_PM_TINV_X1%EN_r18 N_EN_M0_g x_PM_TINV_X1%EN_5 20.67
R_x_PM_TINV_X1%EN_r19 x_PM_TINV_X1%EN_21 x_PM_TINV_X1%EN_VSS 1.95
R_x_PM_TINV_X1%EN_r20 N_EN_M3_g x_PM_TINV_X1%EN_VSS 115.44
C_x_PM_TINV_X1%I_c0 VSS x_PM_TINV_X1%I_18 1.14781e-17
C_x_PM_TINV_X1%I_c1 VSS x_PM_TINV_X1%I_12 2.31577e-17
C_x_PM_TINV_X1%I_c2 VSS N_I_M1_g 7.95088e-17
C_x_PM_TINV_X1%I_c3 VSS N_I_M4_g 5.62785e-17
R_x_PM_TINV_X1%I_r4 x_PM_TINV_X1%I_18 x_PM_TINV_X1%I_14 4.42
R_x_PM_TINV_X1%I_r5 x_PM_TINV_X1%I_14 x_PM_TINV_X1%I_12 25.0012
R_x_PM_TINV_X1%I_r6 x_PM_TINV_X1%I_12 I 0.176429
R_x_PM_TINV_X1%I_r7 x_PM_TINV_X1%I_18 x_PM_TINV_X1%I_5 1.95
R_x_PM_TINV_X1%I_r8 N_I_M1_g x_PM_TINV_X1%I_5 84.63
R_x_PM_TINV_X1%I_r9 x_PM_TINV_X1%I_18 x_PM_TINV_X1%I_VSS 1.95
R_x_PM_TINV_X1%I_r10 N_I_M4_g x_PM_TINV_X1%I_VSS 59.28
C_x_PM_TINV_X1%ZN_c0 VSS x_PM_TINV_X1%ZN_14 3.6269e-17
C_x_PM_TINV_X1%ZN_c1 VSS x_PM_TINV_X1%ZN_10 8.55082e-17
C_x_PM_TINV_X1%ZN_c2 VSS x_PM_TINV_X1%ZN_3 8.44942e-17
R_x_PM_TINV_X1%ZN_r3 x_PM_TINV_X1%ZN_14 N_ZN_M2_d 0.133704
R_x_PM_TINV_X1%ZN_r4 x_PM_TINV_X1%ZN_14 x_PM_TINV_X1%ZN_10 0.095
R_x_PM_TINV_X1%ZN_r5 x_PM_TINV_X1%ZN_10 x_PM_TINV_X1%ZN_9 4.50571
R_x_PM_TINV_X1%ZN_r6 N_ZN_M5_d ZN 0.6365
R_x_PM_TINV_X1%ZN_r7 x_PM_TINV_X1%ZN_9 x_PM_TINV_X1%ZN_3 0.221031
R_x_PM_TINV_X1%ZN_r8 N_ZN_M5_d x_PM_TINV_X1%ZN_3 0.0475
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   TLAT_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT TLAT_X1 VSS VDD G D OE Q
*.PININFO VSS:B VDD:B G:I D:I OE:I Q:O
M_M10 N_VDD_M0_d N_G_M0_g N_3_M0_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M11 N_5_M1_d N_3_M1_g N_VDD_M0_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M12 12 N_D_M2_g N_VDD_M2_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M13 N_7_M3_d N_3_M3_g 12 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M14 13 N_5_M4_g N_7_M3_d VDD PMOS_VTL W=0.360000U L=0.050000U
M_M15 N_VDD_M5_d N_8_M5_g 13 VDD PMOS_VTL W=0.360000U L=0.050000U
M_M16 N_10_M6_d N_OE_M6_g N_VDD_M5_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M17 N_VDD_M7_d N_7_M7_g N_8_M7_s VDD PMOS_VTL W=0.360000U L=0.050000U
M_M18 14 N_7_M8_g N_VDD_M7_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M19 N_Q_M9_d N_10_M9_g 14 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_VSS_M10_d N_G_M10_g N_3_M10_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M1 N_5_M11_d N_3_M11_g N_VSS_M10_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M2 15 N_D_M12_g N_VSS_M12_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 N_7_M13_d N_5_M13_g 15 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M4 16 N_3_M14_g N_7_M13_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M5 N_VSS_M15_d N_8_M15_g 16 VSS NMOS_VTL W=0.180000U L=0.050000U
M_M6 N_10_M16_d N_OE_M16_g N_VSS_M15_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M7 N_VSS_M17_d N_7_M17_g N_8_M17_s VSS NMOS_VTL W=0.180000U L=0.050000U
M_M8 17 N_7_M18_g N_VSS_M17_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M9 N_Q_M19_d N_OE_M19_g 17 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_TLAT_X1%VSS_c0 VSS x_PM_TLAT_X1%VSS_36 4.72988e-17
C_x_PM_TLAT_X1%VSS_c1 VSS x_PM_TLAT_X1%VSS_35 2.93904e-18
C_x_PM_TLAT_X1%VSS_c2 VSS x_PM_TLAT_X1%VSS_34 4.6069e-18
C_x_PM_TLAT_X1%VSS_c3 VSS x_PM_TLAT_X1%VSS_33 3.74784e-17
C_x_PM_TLAT_X1%VSS_c4 VSS N_VSS_M17_d 4.95562e-17
C_x_PM_TLAT_X1%VSS_c5 VSS x_PM_TLAT_X1%VSS_25 4.47302e-17
C_x_PM_TLAT_X1%VSS_c6 VSS N_VSS_M15_d 2.66007e-17
C_x_PM_TLAT_X1%VSS_c7 VSS x_PM_TLAT_X1%VSS_17 6.41421e-17
C_x_PM_TLAT_X1%VSS_c8 VSS N_VSS_M12_s 3.22329e-17
C_x_PM_TLAT_X1%VSS_c9 VSS x_PM_TLAT_X1%VSS_11 2.84315e-17
C_x_PM_TLAT_X1%VSS_c10 VSS N_VSS_M10_d 2.32035e-17
R_x_PM_TLAT_X1%VSS_r11 x_PM_TLAT_X1%VSS_36 x_PM_TLAT_X1%VSS_27 0.145286
R_x_PM_TLAT_X1%VSS_r12 N_VSS_M17_d x_PM_TLAT_X1%VSS_27 1.615
R_x_PM_TLAT_X1%VSS_r13 x_PM_TLAT_X1%VSS_35 x_PM_TLAT_X1%VSS_26 0.0731438
R_x_PM_TLAT_X1%VSS_r14 x_PM_TLAT_X1%VSS_36 x_PM_TLAT_X1%VSS_25 0.0731438
R_x_PM_TLAT_X1%VSS_r15 x_PM_TLAT_X1%VSS_26 x_PM_TLAT_X1%VSS_25 1.08412
R_x_PM_TLAT_X1%VSS_r16 x_PM_TLAT_X1%VSS_35 x_PM_TLAT_X1%VSS_21 0.145286
R_x_PM_TLAT_X1%VSS_r17 N_VSS_M15_d x_PM_TLAT_X1%VSS_21 0.909286
R_x_PM_TLAT_X1%VSS_r18 x_PM_TLAT_X1%VSS_34 x_PM_TLAT_X1%VSS_18 0.0731438
R_x_PM_TLAT_X1%VSS_r19 VSS x_PM_TLAT_X1%VSS_18 1.15118
R_x_PM_TLAT_X1%VSS_r20 x_PM_TLAT_X1%VSS_35 x_PM_TLAT_X1%VSS_17 0.0731438
R_x_PM_TLAT_X1%VSS_r21 VSS x_PM_TLAT_X1%VSS_17 0.368824
R_x_PM_TLAT_X1%VSS_r22 x_PM_TLAT_X1%VSS_34 x_PM_TLAT_X1%VSS_13 0.145286
R_x_PM_TLAT_X1%VSS_r23 N_VSS_M12_s x_PM_TLAT_X1%VSS_13 0.909286
R_x_PM_TLAT_X1%VSS_r24 x_PM_TLAT_X1%VSS_33 x_PM_TLAT_X1%VSS_12 0.0731438
R_x_PM_TLAT_X1%VSS_r25 x_PM_TLAT_X1%VSS_34 x_PM_TLAT_X1%VSS_11 0.0731438
R_x_PM_TLAT_X1%VSS_r26 x_PM_TLAT_X1%VSS_12 x_PM_TLAT_X1%VSS_11 0.625882
R_x_PM_TLAT_X1%VSS_r27 x_PM_TLAT_X1%VSS_33 x_PM_TLAT_X1%VSS_7 0.145286
R_x_PM_TLAT_X1%VSS_r28 N_VSS_M10_d x_PM_TLAT_X1%VSS_7 0.502143
C_x_PM_TLAT_X1%VDD_c0 VSS N_VDD_M7_d 6.41494e-17
C_x_PM_TLAT_X1%VDD_c1 VSS x_PM_TLAT_X1%VDD_31 5.64357e-18
C_x_PM_TLAT_X1%VDD_c2 VSS x_PM_TLAT_X1%VDD_30 4.64934e-18
C_x_PM_TLAT_X1%VDD_c3 VSS x_PM_TLAT_X1%VDD_29 2.83917e-18
C_x_PM_TLAT_X1%VDD_c4 VSS x_PM_TLAT_X1%VDD_28 1.83248e-17
C_x_PM_TLAT_X1%VDD_c5 VSS x_PM_TLAT_X1%VDD_25 7.38466e-17
C_x_PM_TLAT_X1%VDD_c6 VSS x_PM_TLAT_X1%VDD_23 1.87975e-16
C_x_PM_TLAT_X1%VDD_c7 VSS x_PM_TLAT_X1%VDD_22 5.2495e-17
C_x_PM_TLAT_X1%VDD_c8 VSS x_PM_TLAT_X1%VDD_19 6.46514e-17
C_x_PM_TLAT_X1%VDD_c9 VSS N_VDD_M2_s 4.21565e-17
C_x_PM_TLAT_X1%VDD_c10 VSS x_PM_TLAT_X1%VDD_13 2.40781e-17
C_x_PM_TLAT_X1%VDD_c11 VSS N_VDD_M0_d 4.11132e-17
C_x_PM_TLAT_X1%VDD_c12 VSS x_PM_TLAT_X1%VDD_5 2.82248e-17
R_x_PM_TLAT_X1%VDD_r13 x_PM_TLAT_X1%VDD_35 N_VDD_M7_d 0.133704
R_x_PM_TLAT_X1%VDD_r14 x_PM_TLAT_X1%VDD_28 x_PM_TLAT_X1%VDD_27 1.08571
R_x_PM_TLAT_X1%VDD_r15 x_PM_TLAT_X1%VDD_35 x_PM_TLAT_X1%VDD_26 0.095
R_x_PM_TLAT_X1%VDD_r16 x_PM_TLAT_X1%VDD_27 x_PM_TLAT_X1%VDD_25 0.212317
R_x_PM_TLAT_X1%VDD_r17 x_PM_TLAT_X1%VDD_26 x_PM_TLAT_X1%VDD_25 1.62857
R_x_PM_TLAT_X1%VDD_r18 x_PM_TLAT_X1%VDD_31 x_PM_TLAT_X1%VDD_24 0.132285
R_x_PM_TLAT_X1%VDD_r19 x_PM_TLAT_X1%VDD_28 x_PM_TLAT_X1%VDD_23 0.264221
R_x_PM_TLAT_X1%VDD_r20 x_PM_TLAT_X1%VDD_24 x_PM_TLAT_X1%VDD_23 1.9
R_x_PM_TLAT_X1%VDD_r21 x_PM_TLAT_X1%VDD_31 x_PM_TLAT_X1%VDD_22 0.0680382
R_x_PM_TLAT_X1%VDD_r22 x_PM_TLAT_X1%VDD_22 N_VDD_M5_d 0.403583
R_x_PM_TLAT_X1%VDD_r23 x_PM_TLAT_X1%VDD_30 x_PM_TLAT_X1%VDD_20 0.0731438
R_x_PM_TLAT_X1%VDD_r24 x_PM_TLAT_X1%VDD_31 x_PM_TLAT_X1%VDD_19 0.132285
R_x_PM_TLAT_X1%VDD_r25 x_PM_TLAT_X1%VDD_20 x_PM_TLAT_X1%VDD_19 1.48647
R_x_PM_TLAT_X1%VDD_r26 x_PM_TLAT_X1%VDD_30 x_PM_TLAT_X1%VDD_15 0.145286
R_x_PM_TLAT_X1%VDD_r27 N_VDD_M2_s x_PM_TLAT_X1%VDD_15 0.909286
R_x_PM_TLAT_X1%VDD_r28 x_PM_TLAT_X1%VDD_29 x_PM_TLAT_X1%VDD_14 0.0731438
R_x_PM_TLAT_X1%VDD_r29 x_PM_TLAT_X1%VDD_30 x_PM_TLAT_X1%VDD_13 0.0731438
R_x_PM_TLAT_X1%VDD_r30 x_PM_TLAT_X1%VDD_14 x_PM_TLAT_X1%VDD_13 0.614706
R_x_PM_TLAT_X1%VDD_r31 x_PM_TLAT_X1%VDD_29 x_PM_TLAT_X1%VDD_9 0.145286
R_x_PM_TLAT_X1%VDD_r32 N_VDD_M0_d x_PM_TLAT_X1%VDD_9 1.20786
R_x_PM_TLAT_X1%VDD_r33 x_PM_TLAT_X1%VDD_29 x_PM_TLAT_X1%VDD_5 0.0731438
R_x_PM_TLAT_X1%VDD_r34 VDD x_PM_TLAT_X1%VDD_5 0.335294
C_x_PM_TLAT_X1%3_c0 VSS x_PM_TLAT_X1%3_45 1.17098e-17
C_x_PM_TLAT_X1%3_c1 VSS x_PM_TLAT_X1%3_37 3.12053e-17
C_x_PM_TLAT_X1%3_c2 VSS x_PM_TLAT_X1%3_35 3.06158e-18
C_x_PM_TLAT_X1%3_c3 VSS x_PM_TLAT_X1%3_33 2.32877e-17
C_x_PM_TLAT_X1%3_c4 VSS N_3_M0_s 3.14312e-17
C_x_PM_TLAT_X1%3_c5 VSS x_PM_TLAT_X1%3_29 5.66181e-18
C_x_PM_TLAT_X1%3_c6 VSS x_PM_TLAT_X1%3_28 3.91904e-17
C_x_PM_TLAT_X1%3_c7 VSS N_3_M10_s 2.69153e-17
C_x_PM_TLAT_X1%3_c8 VSS N_3_M14_g 4.11729e-17
C_x_PM_TLAT_X1%3_c9 VSS N_3_M3_g 5.71877e-17
C_x_PM_TLAT_X1%3_c10 VSS x_PM_TLAT_X1%3_12 6.06779e-18
C_x_PM_TLAT_X1%3_c11 VSS x_PM_TLAT_X1%3_11 6.18656e-17
C_x_PM_TLAT_X1%3_c12 VSS x_PM_TLAT_X1%3_10 6.06779e-18
C_x_PM_TLAT_X1%3_c13 VSS x_PM_TLAT_X1%3_9 8.71111e-17
C_x_PM_TLAT_X1%3_c14 VSS N_3_M1_g 8.94084e-17
C_x_PM_TLAT_X1%3_c15 VSS N_3_M11_g 3.16566e-17
R_x_PM_TLAT_X1%3_r16 x_PM_TLAT_X1%3_45 x_PM_TLAT_X1%3_43 3.9
R_x_PM_TLAT_X1%3_r17 x_PM_TLAT_X1%3_43 x_PM_TLAT_X1%3_40 25.0012
R_x_PM_TLAT_X1%3_r18 x_PM_TLAT_X1%3_40 x_PM_TLAT_X1%3_37 0.176429
R_x_PM_TLAT_X1%3_r19 x_PM_TLAT_X1%3_35 x_PM_TLAT_X1%3_34 0.0766861
R_x_PM_TLAT_X1%3_r20 x_PM_TLAT_X1%3_37 x_PM_TLAT_X1%3_33 0.095
R_x_PM_TLAT_X1%3_r21 x_PM_TLAT_X1%3_34 x_PM_TLAT_X1%3_33 0.95
R_x_PM_TLAT_X1%3_r22 N_3_M0_s x_PM_TLAT_X1%3_29 0.467083
R_x_PM_TLAT_X1%3_r23 x_PM_TLAT_X1%3_28 x_PM_TLAT_X1%3_29 0.255421
R_x_PM_TLAT_X1%3_r24 x_PM_TLAT_X1%3_35 x_PM_TLAT_X1%3_27 0.123935
R_x_PM_TLAT_X1%3_r25 x_PM_TLAT_X1%3_28 x_PM_TLAT_X1%3_27 1.76429
R_x_PM_TLAT_X1%3_r26 x_PM_TLAT_X1%3_35 x_PM_TLAT_X1%3_23 0.123935
R_x_PM_TLAT_X1%3_r27 N_3_M10_s x_PM_TLAT_X1%3_23 0.277083
R_x_PM_TLAT_X1%3_r28 N_3_M14_g x_PM_TLAT_X1%3_17 33.54
R_x_PM_TLAT_X1%3_r29 N_3_M3_g x_PM_TLAT_X1%3_13 47.58
R_x_PM_TLAT_X1%3_r30 x_PM_TLAT_X1%3_13 x_PM_TLAT_X1%3_11 4.35808
R_x_PM_TLAT_X1%3_r31 x_PM_TLAT_X1%3_12 x_PM_TLAT_X1%3_11 74.88
R_x_PM_TLAT_X1%3_r32 x_PM_TLAT_X1%3_17 x_PM_TLAT_X1%3_9 4.35808
R_x_PM_TLAT_X1%3_r33 x_PM_TLAT_X1%3_10 x_PM_TLAT_X1%3_9 104.52
R_x_PM_TLAT_X1%3_r34 x_PM_TLAT_X1%3_12 x_PM_TLAT_X1%3_6 4.35808
R_x_PM_TLAT_X1%3_r35 N_3_M1_g x_PM_TLAT_X1%3_6 56.16
R_x_PM_TLAT_X1%3_r36 x_PM_TLAT_X1%3_45 x_PM_TLAT_X1%3_5 1.95
R_x_PM_TLAT_X1%3_r37 N_3_M1_g x_PM_TLAT_X1%3_5 74.1
R_x_PM_TLAT_X1%3_r38 x_PM_TLAT_X1%3_45 x_PM_TLAT_X1%3_2 1.95
R_x_PM_TLAT_X1%3_r39 N_3_M11_g x_PM_TLAT_X1%3_2 26.52
R_x_PM_TLAT_X1%3_r40 x_PM_TLAT_X1%3_10 x_PM_TLAT_X1%3_VSS 4.35808
R_x_PM_TLAT_X1%3_r41 N_3_M11_g x_PM_TLAT_X1%3_VSS 21.84
C_x_PM_TLAT_X1%G_c0 VSS G 4.69275e-17
C_x_PM_TLAT_X1%G_c1 VSS x_PM_TLAT_X1%G_11 9.88516e-18
C_x_PM_TLAT_X1%G_c2 VSS N_G_M0_g 5.66788e-17
C_x_PM_TLAT_X1%G_c3 VSS N_G_M10_g 5.83417e-17
R_x_PM_TLAT_X1%G_r4 x_PM_TLAT_X1%G_18 x_PM_TLAT_X1%G_11 4.7687
R_x_PM_TLAT_X1%G_r5 x_PM_TLAT_X1%G_17 x_PM_TLAT_X1%G_11 4.7687
R_x_PM_TLAT_X1%G_r6 x_PM_TLAT_X1%G_11 x_PM_TLAT_X1%G_9 25.0012
R_x_PM_TLAT_X1%G_r7 G x_PM_TLAT_X1%G_9 0.1425
R_x_PM_TLAT_X1%G_r8 N_G_M0_g x_PM_TLAT_X1%G_18 44.46
R_x_PM_TLAT_X1%G_r9 N_G_M10_g x_PM_TLAT_X1%G_17 56.16
C_x_PM_TLAT_X1%5_c0 VSS x_PM_TLAT_X1%5_21 4.08171e-17
C_x_PM_TLAT_X1%5_c1 VSS x_PM_TLAT_X1%5_17 5.93239e-17
C_x_PM_TLAT_X1%5_c2 VSS N_5_M11_d 9.87591e-17
C_x_PM_TLAT_X1%5_c3 VSS x_PM_TLAT_X1%5_13 8.31407e-18
C_x_PM_TLAT_X1%5_c4 VSS N_5_M4_g 7.27327e-17
C_x_PM_TLAT_X1%5_c5 VSS x_PM_TLAT_X1%5_5 2.57505e-17
C_x_PM_TLAT_X1%5_c6 VSS N_5_M13_g 4.77986e-17
C_x_PM_TLAT_X1%5_c7 VSS x_PM_TLAT_X1%5_VSS 6.78716e-18
R_x_PM_TLAT_X1%5_r8 x_PM_TLAT_X1%5_22 x_PM_TLAT_X1%5_21 25.0012
R_x_PM_TLAT_X1%5_r9 x_PM_TLAT_X1%5_21 x_PM_TLAT_X1%5_19 0.800714
R_x_PM_TLAT_X1%5_r10 N_5_M1_d x_PM_TLAT_X1%5_18 0.185709
R_x_PM_TLAT_X1%5_r11 x_PM_TLAT_X1%5_19 x_PM_TLAT_X1%5_17 0.212317
R_x_PM_TLAT_X1%5_r12 x_PM_TLAT_X1%5_18 x_PM_TLAT_X1%5_17 1.98143
R_x_PM_TLAT_X1%5_r13 N_5_M1_d x_PM_TLAT_X1%5_13 0.0309515
R_x_PM_TLAT_X1%5_r14 N_5_M11_d x_PM_TLAT_X1%5_13 2.20611
R_x_PM_TLAT_X1%5_r15 N_5_M4_g x_PM_TLAT_X1%5_7 48.36
R_x_PM_TLAT_X1%5_r16 x_PM_TLAT_X1%5_22 x_PM_TLAT_X1%5_6 0.550646
R_x_PM_TLAT_X1%5_r17 x_PM_TLAT_X1%5_7 x_PM_TLAT_X1%5_5 4.58872
R_x_PM_TLAT_X1%5_r18 x_PM_TLAT_X1%5_6 x_PM_TLAT_X1%5_5 14.56
R_x_PM_TLAT_X1%5_r19 x_PM_TLAT_X1%5_22 x_PM_TLAT_X1%5_VSS 4.03807
R_x_PM_TLAT_X1%5_r20 N_5_M13_g x_PM_TLAT_X1%5_VSS 49.14
C_x_PM_TLAT_X1%D_c0 VSS D 2.8513e-17
C_x_PM_TLAT_X1%D_c1 VSS x_PM_TLAT_X1%D_11 9.08032e-18
C_x_PM_TLAT_X1%D_c2 VSS N_D_M2_g 8.14582e-17
C_x_PM_TLAT_X1%D_c3 VSS N_D_M12_g 3.35749e-17
R_x_PM_TLAT_X1%D_r4 x_PM_TLAT_X1%D_18 x_PM_TLAT_X1%D_11 4.7687
R_x_PM_TLAT_X1%D_r5 x_PM_TLAT_X1%D_17 x_PM_TLAT_X1%D_11 4.7687
R_x_PM_TLAT_X1%D_r6 x_PM_TLAT_X1%D_11 x_PM_TLAT_X1%D_9 25.0012
R_x_PM_TLAT_X1%D_r7 D x_PM_TLAT_X1%D_9 0.251071
R_x_PM_TLAT_X1%D_r8 N_D_M2_g x_PM_TLAT_X1%D_18 74.1
R_x_PM_TLAT_X1%D_r9 N_D_M12_g x_PM_TLAT_X1%D_17 23.4
C_x_PM_TLAT_X1%7_c0 VSS x_PM_TLAT_X1%7_41 2.5323e-17
C_x_PM_TLAT_X1%7_c1 VSS x_PM_TLAT_X1%7_38 1.94007e-17
C_x_PM_TLAT_X1%7_c2 VSS x_PM_TLAT_X1%7_32 1.94044e-16
C_x_PM_TLAT_X1%7_c3 VSS x_PM_TLAT_X1%7_29 4.05072e-17
C_x_PM_TLAT_X1%7_c4 VSS x_PM_TLAT_X1%7_27 3.80736e-17
C_x_PM_TLAT_X1%7_c5 VSS N_7_M3_d 4.33625e-17
C_x_PM_TLAT_X1%7_c6 VSS x_PM_TLAT_X1%7_22 8.70047e-18
C_x_PM_TLAT_X1%7_c7 VSS x_PM_TLAT_X1%7_19 4.97792e-18
C_x_PM_TLAT_X1%7_c8 VSS N_7_M8_g 5.3585e-17
C_x_PM_TLAT_X1%7_c9 VSS N_7_M18_g 2.44891e-17
C_x_PM_TLAT_X1%7_c10 VSS x_PM_TLAT_X1%7_9 1.02762e-17
C_x_PM_TLAT_X1%7_c11 VSS N_7_M7_g 5.46235e-17
C_x_PM_TLAT_X1%7_c12 VSS x_PM_TLAT_X1%7_5 1.25554e-17
C_x_PM_TLAT_X1%7_c13 VSS N_7_M17_g 2.44513e-17
R_x_PM_TLAT_X1%7_r14 x_PM_TLAT_X1%7_43 x_PM_TLAT_X1%7_42 11.6371
R_x_PM_TLAT_X1%7_r15 x_PM_TLAT_X1%7_38 N_7_M13_d 0.312143
R_x_PM_TLAT_X1%7_r16 x_PM_TLAT_X1%7_43 x_PM_TLAT_X1%7_32 25.0012
R_x_PM_TLAT_X1%7_r17 x_PM_TLAT_X1%7_41 x_PM_TLAT_X1%7_30 0.0418175
R_x_PM_TLAT_X1%7_r18 x_PM_TLAT_X1%7_32 x_PM_TLAT_X1%7_30 3.97643
R_x_PM_TLAT_X1%7_r19 x_PM_TLAT_X1%7_41 x_PM_TLAT_X1%7_28 0.160909
R_x_PM_TLAT_X1%7_r20 x_PM_TLAT_X1%7_29 x_PM_TLAT_X1%7_28 1.14
R_x_PM_TLAT_X1%7_r21 x_PM_TLAT_X1%7_41 x_PM_TLAT_X1%7_27 0.160909
R_x_PM_TLAT_X1%7_r22 x_PM_TLAT_X1%7_38 x_PM_TLAT_X1%7_26 0.095
R_x_PM_TLAT_X1%7_r23 x_PM_TLAT_X1%7_27 x_PM_TLAT_X1%7_26 1.43857
R_x_PM_TLAT_X1%7_r24 x_PM_TLAT_X1%7_29 x_PM_TLAT_X1%7_22 0.26298
R_x_PM_TLAT_X1%7_r25 N_7_M3_d x_PM_TLAT_X1%7_22 0.4408
R_x_PM_TLAT_X1%7_r26 x_PM_TLAT_X1%7_19 x_PM_TLAT_X1%7_15 3.30287
R_x_PM_TLAT_X1%7_r27 N_7_M8_g x_PM_TLAT_X1%7_15 54.21
R_x_PM_TLAT_X1%7_r28 x_PM_TLAT_X1%7_19 x_PM_TLAT_X1%7_11 3.30287
R_x_PM_TLAT_X1%7_r29 N_7_M18_g x_PM_TLAT_X1%7_11 25.74
R_x_PM_TLAT_X1%7_r30 x_PM_TLAT_X1%7_42 x_PM_TLAT_X1%7_10 2.35887
R_x_PM_TLAT_X1%7_r31 x_PM_TLAT_X1%7_19 x_PM_TLAT_X1%7_9 0.858359
R_x_PM_TLAT_X1%7_r32 x_PM_TLAT_X1%7_10 x_PM_TLAT_X1%7_9 21.84
R_x_PM_TLAT_X1%7_r33 x_PM_TLAT_X1%7_43 x_PM_TLAT_X1%7_5 5.03268
R_x_PM_TLAT_X1%7_r34 N_7_M7_g x_PM_TLAT_X1%7_5 50.7
R_x_PM_TLAT_X1%7_r35 x_PM_TLAT_X1%7_42 x_PM_TLAT_X1%7_VSS 3.4601
R_x_PM_TLAT_X1%7_r36 N_7_M17_g x_PM_TLAT_X1%7_VSS 21.84
C_x_PM_TLAT_X1%8_c0 VSS x_PM_TLAT_X1%8_27 4.57575e-17
C_x_PM_TLAT_X1%8_c1 VSS x_PM_TLAT_X1%8_26 1.42282e-17
C_x_PM_TLAT_X1%8_c2 VSS x_PM_TLAT_X1%8_25 3.55544e-17
C_x_PM_TLAT_X1%8_c3 VSS x_PM_TLAT_X1%8_22 5.03207e-17
C_x_PM_TLAT_X1%8_c4 VSS x_PM_TLAT_X1%8_20 4.89053e-17
C_x_PM_TLAT_X1%8_c5 VSS x_PM_TLAT_X1%8_14 7.71003e-18
C_x_PM_TLAT_X1%8_c6 VSS x_PM_TLAT_X1%8_11 1.22604e-16
C_x_PM_TLAT_X1%8_c7 VSS N_8_M17_s 1.8405e-17
C_x_PM_TLAT_X1%8_c8 VSS N_8_M5_g 6.65016e-17
C_x_PM_TLAT_X1%8_c9 VSS N_8_M15_g 3.62389e-17
R_x_PM_TLAT_X1%8_r10 N_8_M7_s x_PM_TLAT_X1%8_27 0.312143
R_x_PM_TLAT_X1%8_r11 x_PM_TLAT_X1%8_25 x_PM_TLAT_X1%8_24 1.46571
R_x_PM_TLAT_X1%8_r12 x_PM_TLAT_X1%8_27 x_PM_TLAT_X1%8_23 0.095
R_x_PM_TLAT_X1%8_r13 x_PM_TLAT_X1%8_25 x_PM_TLAT_X1%8_22 0.212317
R_x_PM_TLAT_X1%8_r14 x_PM_TLAT_X1%8_23 x_PM_TLAT_X1%8_22 0.95
R_x_PM_TLAT_X1%8_r15 x_PM_TLAT_X1%8_26 x_PM_TLAT_X1%8_21 0.160909
R_x_PM_TLAT_X1%8_r16 x_PM_TLAT_X1%8_24 x_PM_TLAT_X1%8_20 0.212317
R_x_PM_TLAT_X1%8_r17 x_PM_TLAT_X1%8_21 x_PM_TLAT_X1%8_20 0.977143
R_x_PM_TLAT_X1%8_r18 x_PM_TLAT_X1%8_26 x_PM_TLAT_X1%8_16 0.0418175
R_x_PM_TLAT_X1%8_r19 x_PM_TLAT_X1%8_34 x_PM_TLAT_X1%8_14 4.7687
R_x_PM_TLAT_X1%8_r20 x_PM_TLAT_X1%8_33 x_PM_TLAT_X1%8_14 4.7687
R_x_PM_TLAT_X1%8_r21 x_PM_TLAT_X1%8_14 x_PM_TLAT_X1%8_12 25.0012
R_x_PM_TLAT_X1%8_r22 x_PM_TLAT_X1%8_26 x_PM_TLAT_X1%8_11 0.160909
R_x_PM_TLAT_X1%8_r23 x_PM_TLAT_X1%8_12 x_PM_TLAT_X1%8_11 2.23929
R_x_PM_TLAT_X1%8_r24 N_8_M17_s x_PM_TLAT_X1%8_16 0.203571
R_x_PM_TLAT_X1%8_r25 N_8_M5_g x_PM_TLAT_X1%8_34 63.96
R_x_PM_TLAT_X1%8_r26 N_8_M15_g x_PM_TLAT_X1%8_33 33.54
C_x_PM_TLAT_X1%OE_c0 VSS x_PM_TLAT_X1%OE_20 1.01779e-17
C_x_PM_TLAT_X1%OE_c1 VSS x_PM_TLAT_X1%OE_18 7.89833e-17
C_x_PM_TLAT_X1%OE_c2 VSS N_OE_M19_g 4.01869e-17
C_x_PM_TLAT_X1%OE_c3 VSS x_PM_TLAT_X1%OE_10 7.24942e-18
C_x_PM_TLAT_X1%OE_c4 VSS x_PM_TLAT_X1%OE_9 8.38634e-17
C_x_PM_TLAT_X1%OE_c5 VSS N_OE_M6_g 3.13132e-17
C_x_PM_TLAT_X1%OE_c6 VSS N_OE_M16_g 8.81119e-17
R_x_PM_TLAT_X1%OE_r7 x_PM_TLAT_X1%OE_24 x_PM_TLAT_X1%OE_20 4.7687
R_x_PM_TLAT_X1%OE_r8 x_PM_TLAT_X1%OE_23 x_PM_TLAT_X1%OE_20 4.7687
R_x_PM_TLAT_X1%OE_r9 x_PM_TLAT_X1%OE_20 x_PM_TLAT_X1%OE_18 25.0012
R_x_PM_TLAT_X1%OE_r10 x_PM_TLAT_X1%OE_18 OE 0.199744
R_x_PM_TLAT_X1%OE_r11 N_OE_M19_g x_PM_TLAT_X1%OE_11 38.22
R_x_PM_TLAT_X1%OE_r12 x_PM_TLAT_X1%OE_11 x_PM_TLAT_X1%OE_9 4.35808
R_x_PM_TLAT_X1%OE_r13 x_PM_TLAT_X1%OE_10 x_PM_TLAT_X1%OE_9 108.42
R_x_PM_TLAT_X1%OE_r14 N_OE_M6_g x_PM_TLAT_X1%OE_24 24.57
R_x_PM_TLAT_X1%OE_r15 N_OE_M16_g x_PM_TLAT_X1%OE_23 104.52
R_x_PM_TLAT_X1%OE_r16 x_PM_TLAT_X1%OE_10 x_PM_TLAT_X1%OE_VSS 4.35808
R_x_PM_TLAT_X1%OE_r17 N_OE_M16_g x_PM_TLAT_X1%OE_VSS 14.82
C_x_PM_TLAT_X1%10_c0 VSS x_PM_TLAT_X1%10_35 1.5893e-17
C_x_PM_TLAT_X1%10_c1 VSS N_10_M6_d 5.2225e-17
C_x_PM_TLAT_X1%10_c2 VSS x_PM_TLAT_X1%10_20 1.94118e-16
C_x_PM_TLAT_X1%10_c3 VSS x_PM_TLAT_X1%10_16 7.84783e-17
C_x_PM_TLAT_X1%10_c4 VSS x_PM_TLAT_X1%10_12 7.4957e-17
C_x_PM_TLAT_X1%10_c5 VSS N_10_M16_d 7.44585e-17
C_x_PM_TLAT_X1%10_c6 VSS N_10_M9_g 3.95857e-17
R_x_PM_TLAT_X1%10_r7 x_PM_TLAT_X1%10_27 N_10_M6_d 0.117619
R_x_PM_TLAT_X1%10_r8 x_PM_TLAT_X1%10_35 x_PM_TLAT_X1%10_22 4.94
R_x_PM_TLAT_X1%10_r9 x_PM_TLAT_X1%10_22 x_PM_TLAT_X1%10_20 25.0012
R_x_PM_TLAT_X1%10_r10 x_PM_TLAT_X1%10_27 x_PM_TLAT_X1%10_19 0.095
R_x_PM_TLAT_X1%10_r11 x_PM_TLAT_X1%10_20 x_PM_TLAT_X1%10_19 2.86357
R_x_PM_TLAT_X1%10_r12 x_PM_TLAT_X1%10_31 x_PM_TLAT_X1%10_16 25.0012
R_x_PM_TLAT_X1%10_r13 x_PM_TLAT_X1%10_14 N_10_M6_d 0.286607
R_x_PM_TLAT_X1%10_r14 x_PM_TLAT_X1%10_16 x_PM_TLAT_X1%10_14 1.37071
R_x_PM_TLAT_X1%10_r15 x_PM_TLAT_X1%10_31 x_PM_TLAT_X1%10_12 48.88
R_x_PM_TLAT_X1%10_r16 x_PM_TLAT_X1%10_12 x_PM_TLAT_X1%10_10 25.0012
R_x_PM_TLAT_X1%10_r17 x_PM_TLAT_X1%10_10 N_10_M16_d 0.483636
R_x_PM_TLAT_X1%10_r18 x_PM_TLAT_X1%10_35 x_PM_TLAT_X1%10_VSS 1.95
R_x_PM_TLAT_X1%10_r19 N_10_M9_g x_PM_TLAT_X1%10_VSS 31.59
C_x_PM_TLAT_X1%Q_c0 VSS N_Q_M19_d 7.40155e-17
R_x_PM_TLAT_X1%Q_r1 N_Q_M9_d Q 1.53357
R_x_PM_TLAT_X1%Q_r2 Q N_Q_M19_d 1.34357
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X1.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X1 VSS VDD A B ZN
*.PININFO VSS:B VDD:B A:I B:I ZN:O
M_M5 N_3_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M1_d N_B_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M8 noxref_8 N_A_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M9 N_VDD_M4_d N_B_M4_g noxref_8 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 9 N_A_M5_g N_3_M5_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M6_d N_B_M6_g 9 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_6_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M3 N_ZN_M8_d N_A_M8_g N_6_M7_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_6_M9_d N_B_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_XNOR2_X1%VSS_c0 VSS x_PM_XNOR2_X1%VSS_12 4.17228e-17
C_x_PM_XNOR2_X1%VSS_c1 VSS VSS 1.27789e-16
C_x_PM_XNOR2_X1%VSS_c2 VSS N_VSS_M6_d 3.66492e-17
R_x_PM_XNOR2_X1%VSS_r3 x_PM_XNOR2_X1%VSS_12 x_PM_XNOR2_X1%VSS_8 0.0731438
R_x_PM_XNOR2_X1%VSS_r4 VSS x_PM_XNOR2_X1%VSS_8 0.178824
R_x_PM_XNOR2_X1%VSS_r5 x_PM_XNOR2_X1%VSS_12 x_PM_XNOR2_X1%VSS_4 0.145286
R_x_PM_XNOR2_X1%VSS_r6 N_VSS_M6_d x_PM_XNOR2_X1%VSS_4 1.15357
C_x_PM_XNOR2_X1%VDD_c0 VSS x_PM_XNOR2_X1%VDD_21 2.91444e-18
C_x_PM_XNOR2_X1%VDD_c1 VSS N_VDD_M4_d 1.72672e-17
C_x_PM_XNOR2_X1%VDD_c2 VSS x_PM_XNOR2_X1%VDD_14 7.01703e-17
C_x_PM_XNOR2_X1%VDD_c3 VSS N_VDD_M1_d 2.21941e-17
C_x_PM_XNOR2_X1%VDD_c4 VSS x_PM_XNOR2_X1%VDD_8 2.5814e-17
C_x_PM_XNOR2_X1%VDD_c5 VSS N_VDD_M0_s 1.6454e-17
C_x_PM_XNOR2_X1%VDD_c6 VSS x_PM_XNOR2_X1%VDD_4 1.0897e-17
R_x_PM_XNOR2_X1%VDD_r7 N_VDD_M4_d x_PM_XNOR2_X1%VDD_16 0.230714
R_x_PM_XNOR2_X1%VDD_r8 x_PM_XNOR2_X1%VDD_21 x_PM_XNOR2_X1%VDD_15 0.0731438
R_x_PM_XNOR2_X1%VDD_r9 x_PM_XNOR2_X1%VDD_16 x_PM_XNOR2_X1%VDD_14 0.264221
R_x_PM_XNOR2_X1%VDD_r10 x_PM_XNOR2_X1%VDD_15 x_PM_XNOR2_X1%VDD_14 1.14
R_x_PM_XNOR2_X1%VDD_r11 x_PM_XNOR2_X1%VDD_21 x_PM_XNOR2_X1%VDD_10 0.145286
R_x_PM_XNOR2_X1%VDD_r12 N_VDD_M1_d x_PM_XNOR2_X1%VDD_10 0.556429
R_x_PM_XNOR2_X1%VDD_r13 VDD x_PM_XNOR2_X1%VDD_9 0.195294
R_x_PM_XNOR2_X1%VDD_r14 x_PM_XNOR2_X1%VDD_21 x_PM_XNOR2_X1%VDD_8 0.0731438
R_x_PM_XNOR2_X1%VDD_r15 x_PM_XNOR2_X1%VDD_9 x_PM_XNOR2_X1%VDD_8 0.692941
R_x_PM_XNOR2_X1%VDD_r16 VDD x_PM_XNOR2_X1%VDD_4 0.0689273
R_x_PM_XNOR2_X1%VDD_r17 N_VDD_M0_s x_PM_XNOR2_X1%VDD_4 0.556429
C_x_PM_XNOR2_X1%3_c0 VSS x_PM_XNOR2_X1%3_30 8.86677e-18
C_x_PM_XNOR2_X1%3_c1 VSS x_PM_XNOR2_X1%3_24 2.10647e-17
C_x_PM_XNOR2_X1%3_c2 VSS x_PM_XNOR2_X1%3_23 6.2984e-18
C_x_PM_XNOR2_X1%3_c3 VSS x_PM_XNOR2_X1%3_21 3.3632e-17
C_x_PM_XNOR2_X1%3_c4 VSS N_3_M0_d 7.84372e-17
C_x_PM_XNOR2_X1%3_c5 VSS x_PM_XNOR2_X1%3_16 5.023e-18
C_x_PM_XNOR2_X1%3_c6 VSS x_PM_XNOR2_X1%3_15 1.20094e-17
C_x_PM_XNOR2_X1%3_c7 VSS N_3_M5_s 5.43635e-17
C_x_PM_XNOR2_X1%3_c8 VSS N_3_M2_g 5.30778e-17
C_x_PM_XNOR2_X1%3_c9 VSS N_3_M7_g 5.67384e-17
R_x_PM_XNOR2_X1%3_r10 x_PM_XNOR2_X1%3_32 x_PM_XNOR2_X1%3_30 4.74714
R_x_PM_XNOR2_X1%3_r11 x_PM_XNOR2_X1%3_30 x_PM_XNOR2_X1%3_27 25.0012
R_x_PM_XNOR2_X1%3_r12 x_PM_XNOR2_X1%3_27 x_PM_XNOR2_X1%3_24 0.176429
R_x_PM_XNOR2_X1%3_r13 x_PM_XNOR2_X1%3_23 x_PM_XNOR2_X1%3_22 0.160909
R_x_PM_XNOR2_X1%3_r14 x_PM_XNOR2_X1%3_24 x_PM_XNOR2_X1%3_21 0.095
R_x_PM_XNOR2_X1%3_r15 x_PM_XNOR2_X1%3_22 x_PM_XNOR2_X1%3_21 1.08571
R_x_PM_XNOR2_X1%3_r16 x_PM_XNOR2_X1%3_23 x_PM_XNOR2_X1%3_17 0.0418175
R_x_PM_XNOR2_X1%3_r17 N_3_M0_d x_PM_XNOR2_X1%3_17 2.02214
R_x_PM_XNOR2_X1%3_r18 x_PM_XNOR2_X1%3_23 x_PM_XNOR2_X1%3_15 0.160909
R_x_PM_XNOR2_X1%3_r19 x_PM_XNOR2_X1%3_16 x_PM_XNOR2_X1%3_15 0.624286
R_x_PM_XNOR2_X1%3_r20 x_PM_XNOR2_X1%3_16 x_PM_XNOR2_X1%3_11 0.212317
R_x_PM_XNOR2_X1%3_r21 N_3_M5_s x_PM_XNOR2_X1%3_11 1.94071
R_x_PM_XNOR2_X1%3_r22 N_3_M2_g x_PM_XNOR2_X1%3_32 57.33
R_x_PM_XNOR2_X1%3_r23 x_PM_XNOR2_X1%3_VSS x_PM_XNOR2_X1%3_30 4.74714
R_x_PM_XNOR2_X1%3_r24 N_3_M7_g x_PM_XNOR2_X1%3_VSS 64.74
C_x_PM_XNOR2_X1%A_c0 VSS x_PM_XNOR2_X1%A_35 1.53793e-17
C_x_PM_XNOR2_X1%A_c1 VSS x_PM_XNOR2_X1%A_28 5.00895e-17
C_x_PM_XNOR2_X1%A_c2 VSS x_PM_XNOR2_X1%A_24 1.24371e-17
C_x_PM_XNOR2_X1%A_c3 VSS x_PM_XNOR2_X1%A_18 6.35278e-17
C_x_PM_XNOR2_X1%A_c4 VSS N_A_M3_g 8.69394e-17
C_x_PM_XNOR2_X1%A_c5 VSS N_A_M8_g 2.95658e-17
C_x_PM_XNOR2_X1%A_c6 VSS N_A_M0_g 8.24567e-17
C_x_PM_XNOR2_X1%A_c7 VSS N_A_M5_g 2.79859e-17
R_x_PM_XNOR2_X1%A_r8 x_PM_XNOR2_X1%A_28 A 0.189936
R_x_PM_XNOR2_X1%A_r9 x_PM_XNOR2_X1%A_24 x_PM_XNOR2_X1%A_29 3.9
R_x_PM_XNOR2_X1%A_r10 x_PM_XNOR2_X1%A_24 x_PM_XNOR2_X1%A_22 25.0012
R_x_PM_XNOR2_X1%A_r11 A x_PM_XNOR2_X1%A_22 0.210357
R_x_PM_XNOR2_X1%A_r12 x_PM_XNOR2_X1%A_35 x_PM_XNOR2_X1%A_20 7.02
R_x_PM_XNOR2_X1%A_r13 x_PM_XNOR2_X1%A_20 x_PM_XNOR2_X1%A_18 25.0012
R_x_PM_XNOR2_X1%A_r14 x_PM_XNOR2_X1%A_18 x_PM_XNOR2_X1%A_28 1.995
R_x_PM_XNOR2_X1%A_r15 x_PM_XNOR2_X1%A_35 x_PM_XNOR2_X1%A_13 1.95
R_x_PM_XNOR2_X1%A_r16 N_A_M3_g x_PM_XNOR2_X1%A_13 101.79
R_x_PM_XNOR2_X1%A_r17 x_PM_XNOR2_X1%A_35 x_PM_XNOR2_X1%A_9 1.95
R_x_PM_XNOR2_X1%A_r18 N_A_M8_g x_PM_XNOR2_X1%A_9 24.96
R_x_PM_XNOR2_X1%A_r19 x_PM_XNOR2_X1%A_29 x_PM_XNOR2_X1%A_5 1.95
R_x_PM_XNOR2_X1%A_r20 N_A_M0_g x_PM_XNOR2_X1%A_5 102.57
R_x_PM_XNOR2_X1%A_r21 x_PM_XNOR2_X1%A_29 x_PM_XNOR2_X1%A_VSS 1.95
R_x_PM_XNOR2_X1%A_r22 N_A_M5_g x_PM_XNOR2_X1%A_VSS 19.5
C_x_PM_XNOR2_X1%B_c0 VSS x_PM_XNOR2_X1%B_37 1.08287e-17
C_x_PM_XNOR2_X1%B_c1 VSS x_PM_XNOR2_X1%B_30 2.98051e-17
C_x_PM_XNOR2_X1%B_c2 VSS x_PM_XNOR2_X1%B_24 1.04426e-17
C_x_PM_XNOR2_X1%B_c3 VSS x_PM_XNOR2_X1%B_22 4.52557e-17
C_x_PM_XNOR2_X1%B_c4 VSS x_PM_XNOR2_X1%B_21 1.23504e-16
C_x_PM_XNOR2_X1%B_c5 VSS N_B_M4_g 4.31772e-17
C_x_PM_XNOR2_X1%B_c6 VSS N_B_M9_g 7.57073e-17
C_x_PM_XNOR2_X1%B_c7 VSS N_B_M1_g 3.60288e-17
C_x_PM_XNOR2_X1%B_c8 VSS N_B_M6_g 7.3953e-17
R_x_PM_XNOR2_X1%B_r9 x_PM_XNOR2_X1%B_30 B 0.189936
R_x_PM_XNOR2_X1%B_r10 x_PM_XNOR2_X1%B_24 x_PM_XNOR2_X1%B_31 3.38
R_x_PM_XNOR2_X1%B_r11 x_PM_XNOR2_X1%B_24 x_PM_XNOR2_X1%B_22 25.0012
R_x_PM_XNOR2_X1%B_r12 x_PM_XNOR2_X1%B_26 x_PM_XNOR2_X1%B_22 0.176429
R_x_PM_XNOR2_X1%B_r13 B x_PM_XNOR2_X1%B_21 0.095
R_x_PM_XNOR2_X1%B_r14 x_PM_XNOR2_X1%B_37 x_PM_XNOR2_X1%B_20 4.42
R_x_PM_XNOR2_X1%B_r15 x_PM_XNOR2_X1%B_21 x_PM_XNOR2_X1%B_19 0.486983
R_x_PM_XNOR2_X1%B_r16 x_PM_XNOR2_X1%B_20 x_PM_XNOR2_X1%B_19 25.0012
R_x_PM_XNOR2_X1%B_r17 x_PM_XNOR2_X1%B_26 x_PM_XNOR2_X1%B_18 0.095
R_x_PM_XNOR2_X1%B_r18 x_PM_XNOR2_X1%B_18 x_PM_XNOR2_X1%B_30 1.08571
R_x_PM_XNOR2_X1%B_r19 x_PM_XNOR2_X1%B_37 x_PM_XNOR2_X1%B_13 1.95
R_x_PM_XNOR2_X1%B_r20 N_B_M4_g x_PM_XNOR2_X1%B_13 36.27
R_x_PM_XNOR2_X1%B_r21 x_PM_XNOR2_X1%B_37 x_PM_XNOR2_X1%B_9 1.95
R_x_PM_XNOR2_X1%B_r22 N_B_M9_g x_PM_XNOR2_X1%B_9 90.48
R_x_PM_XNOR2_X1%B_r23 x_PM_XNOR2_X1%B_31 x_PM_XNOR2_X1%B_5 1.95
R_x_PM_XNOR2_X1%B_r24 N_B_M1_g x_PM_XNOR2_X1%B_5 36.27
R_x_PM_XNOR2_X1%B_r25 x_PM_XNOR2_X1%B_31 x_PM_XNOR2_X1%B_VSS 1.95
R_x_PM_XNOR2_X1%B_r26 N_B_M6_g x_PM_XNOR2_X1%B_VSS 85.8
C_x_PM_XNOR2_X1%6_c0 VSS x_PM_XNOR2_X1%6_8 2.18284e-17
C_x_PM_XNOR2_X1%6_c1 VSS x_PM_XNOR2_X1%6_7 1.05936e-16
C_x_PM_XNOR2_X1%6_c2 VSS N_6_M7_d 2.54705e-17
C_x_PM_XNOR2_X1%6_c3 VSS N_6_M9_d 1.96833e-17
R_x_PM_XNOR2_X1%6_r4 x_PM_XNOR2_X1%6_9 x_PM_XNOR2_X1%6_7 0.212317
R_x_PM_XNOR2_X1%6_r5 x_PM_XNOR2_X1%6_8 x_PM_XNOR2_X1%6_7 1.62857
R_x_PM_XNOR2_X1%6_r6 x_PM_XNOR2_X1%6_8 x_PM_XNOR2_X1%6_3 0.212317
R_x_PM_XNOR2_X1%6_r7 N_6_M7_d x_PM_XNOR2_X1%6_3 0.420714
R_x_PM_XNOR2_X1%6_r8 N_6_M9_d x_PM_XNOR2_X1%6_9 0.420714
C_x_PM_XNOR2_X1%ZN_c0 VSS x_PM_XNOR2_X1%ZN_18 4.71683e-17
C_x_PM_XNOR2_X1%ZN_c1 VSS x_PM_XNOR2_X1%ZN_15 2.17308e-17
C_x_PM_XNOR2_X1%ZN_c2 VSS ZN 1.97966e-17
C_x_PM_XNOR2_X1%ZN_c3 VSS N_ZN_M8_d 4.30743e-17
C_x_PM_XNOR2_X1%ZN_c4 VSS x_PM_XNOR2_X1%ZN_8 1.83189e-17
C_x_PM_XNOR2_X1%ZN_c5 VSS x_PM_XNOR2_X1%ZN_7 8.17562e-17
C_x_PM_XNOR2_X1%ZN_c6 VSS N_ZN_M2_d 2.1758e-17
R_x_PM_XNOR2_X1%ZN_r7 x_PM_XNOR2_X1%ZN_18 x_PM_XNOR2_X1%ZN_17 2.63286
R_x_PM_XNOR2_X1%ZN_r8 x_PM_XNOR2_X1%ZN_17 x_PM_XNOR2_X1%ZN_15 0.212317
R_x_PM_XNOR2_X1%ZN_r9 x_PM_XNOR2_X1%ZN_16 x_PM_XNOR2_X1%ZN_15 0.787143
R_x_PM_XNOR2_X1%ZN_r10 x_PM_XNOR2_X1%ZN_16 ZN 0.212317
R_x_PM_XNOR2_X1%ZN_r11 ZN x_PM_XNOR2_X1%ZN_13 0.000542857
R_x_PM_XNOR2_X1%ZN_r12 x_PM_XNOR2_X1%ZN_13 N_ZN_M8_d 0.745886
R_x_PM_XNOR2_X1%ZN_r13 x_PM_XNOR2_X1%ZN_18 x_PM_XNOR2_X1%ZN_7 0.212317
R_x_PM_XNOR2_X1%ZN_r14 x_PM_XNOR2_X1%ZN_8 x_PM_XNOR2_X1%ZN_7 1.81857
R_x_PM_XNOR2_X1%ZN_r15 x_PM_XNOR2_X1%ZN_8 x_PM_XNOR2_X1%ZN_3 0.212317
R_x_PM_XNOR2_X1%ZN_r16 N_ZN_M2_d x_PM_XNOR2_X1%ZN_3 0.203571
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XNOR2_X2.                                                        *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT XNOR2_X2 VSS VDD A B ZN
*.PININFO VSS:B VDD:B A:I B:I ZN:O
M_M5 N_3_M0_d N_A_M0_g N_VDD_M0_s VDD PMOS_VTL W=0.135000U L=0.050000U
M_M6 N_VDD_M1_d N_B_M1_g N_3_M0_d VDD PMOS_VTL W=0.135000U L=0.050000U
M_M7 N_ZN_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.270000U L=0.050000U
M_M8 noxref_8 N_A_M3_g N_ZN_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_VDD_M4_d N_B_M4_g noxref_8 VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 9 N_A_M5_g N_3_M5_s VSS NMOS_VTL W=0.130000U L=0.050000U
M_M1 N_VSS_M6_d N_B_M6_g 9 VSS NMOS_VTL W=0.130000U L=0.050000U
M_M2 N_6_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M3 N_ZN_M8_d N_A_M8_g N_6_M7_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_6_M9_d N_B_M9_g N_ZN_M8_d VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_XNOR2_X2%VSS_c0 VSS x_PM_XNOR2_X2%VSS_12 4.36937e-17
C_x_PM_XNOR2_X2%VSS_c1 VSS VSS 1.24374e-16
C_x_PM_XNOR2_X2%VSS_c2 VSS N_VSS_M6_d 2.1058e-17
R_x_PM_XNOR2_X2%VSS_r3 x_PM_XNOR2_X2%VSS_12 x_PM_XNOR2_X2%VSS_8 0.0731438
R_x_PM_XNOR2_X2%VSS_r4 VSS x_PM_XNOR2_X2%VSS_8 0.111765
R_x_PM_XNOR2_X2%VSS_r5 x_PM_XNOR2_X2%VSS_12 x_PM_XNOR2_X2%VSS_4 0.145286
R_x_PM_XNOR2_X2%VSS_r6 N_VSS_M6_d x_PM_XNOR2_X2%VSS_4 0.475
C_x_PM_XNOR2_X2%VDD_c0 VSS x_PM_XNOR2_X2%VDD_22 2.84978e-18
C_x_PM_XNOR2_X2%VDD_c1 VSS N_VDD_M4_d 1.66877e-17
C_x_PM_XNOR2_X2%VDD_c2 VSS x_PM_XNOR2_X2%VDD_14 6.36473e-17
C_x_PM_XNOR2_X2%VDD_c3 VSS N_VDD_M1_d 1.91872e-17
C_x_PM_XNOR2_X2%VDD_c4 VSS x_PM_XNOR2_X2%VDD_9 1.19767e-17
C_x_PM_XNOR2_X2%VDD_c5 VSS x_PM_XNOR2_X2%VDD_8 3.1616e-17
C_x_PM_XNOR2_X2%VDD_c6 VSS N_VDD_M0_s 1.58342e-17
R_x_PM_XNOR2_X2%VDD_r7 N_VDD_M4_d x_PM_XNOR2_X2%VDD_18 0.420714
R_x_PM_XNOR2_X2%VDD_r8 x_PM_XNOR2_X2%VDD_22 x_PM_XNOR2_X2%VDD_15 0.0731438
R_x_PM_XNOR2_X2%VDD_r9 VDD x_PM_XNOR2_X2%VDD_15 0.156471
R_x_PM_XNOR2_X2%VDD_r10 x_PM_XNOR2_X2%VDD_18 x_PM_XNOR2_X2%VDD_14 0.264221
R_x_PM_XNOR2_X2%VDD_r11 VDD x_PM_XNOR2_X2%VDD_14 0.994706
R_x_PM_XNOR2_X2%VDD_r12 x_PM_XNOR2_X2%VDD_22 x_PM_XNOR2_X2%VDD_10 0.145286
R_x_PM_XNOR2_X2%VDD_r13 N_VDD_M1_d x_PM_XNOR2_X2%VDD_10 0.420714
R_x_PM_XNOR2_X2%VDD_r14 x_PM_XNOR2_X2%VDD_22 x_PM_XNOR2_X2%VDD_8 0.0731438
R_x_PM_XNOR2_X2%VDD_r15 x_PM_XNOR2_X2%VDD_9 x_PM_XNOR2_X2%VDD_8 0.681765
R_x_PM_XNOR2_X2%VDD_r16 x_PM_XNOR2_X2%VDD_9 x_PM_XNOR2_X2%VDD_4 0.264221
R_x_PM_XNOR2_X2%VDD_r17 N_VDD_M0_s x_PM_XNOR2_X2%VDD_4 0.420714
C_x_PM_XNOR2_X2%3_c0 VSS x_PM_XNOR2_X2%3_30 1.33441e-17
C_x_PM_XNOR2_X2%3_c1 VSS x_PM_XNOR2_X2%3_25 5.98463e-17
C_x_PM_XNOR2_X2%3_c2 VSS N_3_M5_s 1.69065e-17
C_x_PM_XNOR2_X2%3_c3 VSS N_3_M0_d 5.7841e-17
C_x_PM_XNOR2_X2%3_c4 VSS x_PM_XNOR2_X2%3_14 5.88192e-18
C_x_PM_XNOR2_X2%3_c5 VSS x_PM_XNOR2_X2%3_13 1.2329e-17
C_x_PM_XNOR2_X2%3_c6 VSS x_PM_XNOR2_X2%3_12 3.90058e-17
C_x_PM_XNOR2_X2%3_c7 VSS N_3_M2_g 4.24395e-17
C_x_PM_XNOR2_X2%3_c8 VSS N_3_M7_g 8.22755e-17
R_x_PM_XNOR2_X2%3_r9 x_PM_XNOR2_X2%3_30 x_PM_XNOR2_X2%3_28 7.02
R_x_PM_XNOR2_X2%3_r10 x_PM_XNOR2_X2%3_28 x_PM_XNOR2_X2%3_25 25.0012
R_x_PM_XNOR2_X2%3_r11 x_PM_XNOR2_X2%3_25 x_PM_XNOR2_X2%3_23 1.20333
R_x_PM_XNOR2_X2%3_r12 x_PM_XNOR2_X2%3_23 x_PM_XNOR2_X2%3_15 0.095
R_x_PM_XNOR2_X2%3_r13 N_3_M0_d x_PM_XNOR2_X2%3_15 1.47929
R_x_PM_XNOR2_X2%3_r14 x_PM_XNOR2_X2%3_23 x_PM_XNOR2_X2%3_13 0.177333
R_x_PM_XNOR2_X2%3_r15 x_PM_XNOR2_X2%3_14 x_PM_XNOR2_X2%3_13 0.684
R_x_PM_XNOR2_X2%3_r16 x_PM_XNOR2_X2%3_14 x_PM_XNOR2_X2%3_12 0.212645
R_x_PM_XNOR2_X2%3_r17 x_PM_XNOR2_X2%3_11 N_3_M5_s 0.30478
R_x_PM_XNOR2_X2%3_r18 x_PM_XNOR2_X2%3_12 x_PM_XNOR2_X2%3_11 2.19857
R_x_PM_XNOR2_X2%3_r19 x_PM_XNOR2_X2%3_30 x_PM_XNOR2_X2%3_5 1.95
R_x_PM_XNOR2_X2%3_r20 N_3_M2_g x_PM_XNOR2_X2%3_5 36.66
R_x_PM_XNOR2_X2%3_r21 x_PM_XNOR2_X2%3_30 x_PM_XNOR2_X2%3_VSS 1.95
R_x_PM_XNOR2_X2%3_r22 N_3_M7_g x_PM_XNOR2_X2%3_VSS 88.14
C_x_PM_XNOR2_X2%A_c0 VSS x_PM_XNOR2_X2%A_26 8.35302e-18
C_x_PM_XNOR2_X2%A_c1 VSS A 5.85428e-17
C_x_PM_XNOR2_X2%A_c2 VSS x_PM_XNOR2_X2%A_20 1.47586e-17
C_x_PM_XNOR2_X2%A_c3 VSS x_PM_XNOR2_X2%A_17 4.13545e-17
C_x_PM_XNOR2_X2%A_c4 VSS N_A_M3_g 8.36256e-17
C_x_PM_XNOR2_X2%A_c5 VSS N_A_M8_g 4.45542e-17
C_x_PM_XNOR2_X2%A_c6 VSS N_A_M0_g 8.35794e-17
C_x_PM_XNOR2_X2%A_c7 VSS N_A_M5_g 3.11998e-17
R_x_PM_XNOR2_X2%A_r8 x_PM_XNOR2_X2%A_33 x_PM_XNOR2_X2%A_26 4.7687
R_x_PM_XNOR2_X2%A_r9 x_PM_XNOR2_X2%A_32 x_PM_XNOR2_X2%A_26 4.7687
R_x_PM_XNOR2_X2%A_r10 x_PM_XNOR2_X2%A_26 x_PM_XNOR2_X2%A_24 25.0012
R_x_PM_XNOR2_X2%A_r11 x_PM_XNOR2_X2%A_24 A 1.29807
R_x_PM_XNOR2_X2%A_r12 x_PM_XNOR2_X2%A_20 x_PM_XNOR2_X2%A_27 5.46
R_x_PM_XNOR2_X2%A_r13 x_PM_XNOR2_X2%A_20 x_PM_XNOR2_X2%A_18 25.0012
R_x_PM_XNOR2_X2%A_r14 A x_PM_XNOR2_X2%A_17 0.170882
R_x_PM_XNOR2_X2%A_r15 x_PM_XNOR2_X2%A_18 x_PM_XNOR2_X2%A_17 1.09929
R_x_PM_XNOR2_X2%A_r16 N_A_M3_g x_PM_XNOR2_X2%A_33 81.12
R_x_PM_XNOR2_X2%A_r17 N_A_M8_g x_PM_XNOR2_X2%A_32 34.32
R_x_PM_XNOR2_X2%A_r18 x_PM_XNOR2_X2%A_27 x_PM_XNOR2_X2%A_5 1.95
R_x_PM_XNOR2_X2%A_r19 N_A_M0_g x_PM_XNOR2_X2%A_5 101.01
R_x_PM_XNOR2_X2%A_r20 x_PM_XNOR2_X2%A_27 x_PM_XNOR2_X2%A_VSS 1.95
R_x_PM_XNOR2_X2%A_r21 N_A_M5_g x_PM_XNOR2_X2%A_VSS 24.18
C_x_PM_XNOR2_X2%B_c0 VSS x_PM_XNOR2_X2%B_35 1.37122e-17
C_x_PM_XNOR2_X2%B_c1 VSS x_PM_XNOR2_X2%B_22 5.13638e-17
C_x_PM_XNOR2_X2%B_c2 VSS x_PM_XNOR2_X2%B_20 8.5015e-18
C_x_PM_XNOR2_X2%B_c3 VSS x_PM_XNOR2_X2%B_17 9.56293e-17
C_x_PM_XNOR2_X2%B_c4 VSS N_B_M4_g 5.72893e-17
C_x_PM_XNOR2_X2%B_c5 VSS N_B_M9_g 7.47254e-17
C_x_PM_XNOR2_X2%B_c6 VSS N_B_M1_g 6.02432e-17
C_x_PM_XNOR2_X2%B_c7 VSS N_B_M6_g 5.15283e-17
R_x_PM_XNOR2_X2%B_r8 x_PM_XNOR2_X2%B_35 x_PM_XNOR2_X2%B_28 4.94
R_x_PM_XNOR2_X2%B_r9 x_PM_XNOR2_X2%B_28 x_PM_XNOR2_X2%B_26 25.0012
R_x_PM_XNOR2_X2%B_r10 x_PM_XNOR2_X2%B_26 B 0.0076
R_x_PM_XNOR2_X2%B_r11 B x_PM_XNOR2_X2%B_22 0.1216
R_x_PM_XNOR2_X2%B_r12 x_PM_XNOR2_X2%B_32 x_PM_XNOR2_X2%B_20 4.7687
R_x_PM_XNOR2_X2%B_r13 x_PM_XNOR2_X2%B_31 x_PM_XNOR2_X2%B_20 4.7687
R_x_PM_XNOR2_X2%B_r14 x_PM_XNOR2_X2%B_20 x_PM_XNOR2_X2%B_18 25.0012
R_x_PM_XNOR2_X2%B_r15 x_PM_XNOR2_X2%B_22 x_PM_XNOR2_X2%B_17 0.095
R_x_PM_XNOR2_X2%B_r16 x_PM_XNOR2_X2%B_18 x_PM_XNOR2_X2%B_17 2.34786
R_x_PM_XNOR2_X2%B_r17 x_PM_XNOR2_X2%B_35 x_PM_XNOR2_X2%B_13 1.95
R_x_PM_XNOR2_X2%B_r18 N_B_M4_g x_PM_XNOR2_X2%B_13 42.12
R_x_PM_XNOR2_X2%B_r19 x_PM_XNOR2_X2%B_35 x_PM_XNOR2_X2%B_9 1.95
R_x_PM_XNOR2_X2%B_r20 N_B_M9_g x_PM_XNOR2_X2%B_9 73.32
R_x_PM_XNOR2_X2%B_r21 N_B_M1_g x_PM_XNOR2_X2%B_32 69.03
R_x_PM_XNOR2_X2%B_r22 N_B_M6_g x_PM_XNOR2_X2%B_31 56.16
C_x_PM_XNOR2_X2%6_c0 VSS x_PM_XNOR2_X2%6_10 3.17166e-17
C_x_PM_XNOR2_X2%6_c1 VSS x_PM_XNOR2_X2%6_5 3.10631e-17
C_x_PM_XNOR2_X2%6_c2 VSS x_PM_XNOR2_X2%6_3 7.84652e-17
R_x_PM_XNOR2_X2%6_r3 N_6_M7_d x_PM_XNOR2_X2%6_5 0.176429
R_x_PM_XNOR2_X2%6_r4 x_PM_XNOR2_X2%6_5 x_PM_XNOR2_X2%6_4 0.095
R_x_PM_XNOR2_X2%6_r5 x_PM_XNOR2_X2%6_10 x_PM_XNOR2_X2%6_3 0.095
R_x_PM_XNOR2_X2%6_r6 x_PM_XNOR2_X2%6_4 x_PM_XNOR2_X2%6_3 1.62857
R_x_PM_XNOR2_X2%6_r7 N_6_M9_d x_PM_XNOR2_X2%6_10 0.176429
C_x_PM_XNOR2_X2%ZN_c0 VSS ZN 5.50502e-17
C_x_PM_XNOR2_X2%ZN_c1 VSS x_PM_XNOR2_X2%ZN_10 2.92707e-17
C_x_PM_XNOR2_X2%ZN_c2 VSS x_PM_XNOR2_X2%ZN_9 3.02253e-17
C_x_PM_XNOR2_X2%ZN_c3 VSS x_PM_XNOR2_X2%ZN_8 8.04002e-18
C_x_PM_XNOR2_X2%ZN_c4 VSS x_PM_XNOR2_X2%ZN_7 4.2133e-17
C_x_PM_XNOR2_X2%ZN_c5 VSS N_ZN_M2_d 3.84059e-17
R_x_PM_XNOR2_X2%ZN_r6 ZN x_PM_XNOR2_X2%ZN_12 1.11286
R_x_PM_XNOR2_X2%ZN_r7 ZN x_PM_XNOR2_X2%ZN_11 1.9
R_x_PM_XNOR2_X2%ZN_r8 x_PM_XNOR2_X2%ZN_10 N_ZN_M8_d 0.297071
R_x_PM_XNOR2_X2%ZN_r9 x_PM_XNOR2_X2%ZN_11 x_PM_XNOR2_X2%ZN_9 0.212317
R_x_PM_XNOR2_X2%ZN_r10 x_PM_XNOR2_X2%ZN_10 x_PM_XNOR2_X2%ZN_9 0.407143
R_x_PM_XNOR2_X2%ZN_r11 x_PM_XNOR2_X2%ZN_12 x_PM_XNOR2_X2%ZN_7 0.212317
R_x_PM_XNOR2_X2%ZN_r12 x_PM_XNOR2_X2%ZN_8 x_PM_XNOR2_X2%ZN_7 1.60143
R_x_PM_XNOR2_X2%ZN_r13 x_PM_XNOR2_X2%ZN_8 x_PM_XNOR2_X2%ZN_3 0.212317
R_x_PM_XNOR2_X2%ZN_r14 N_ZN_M2_d x_PM_XNOR2_X2%ZN_3 0.746429
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X1.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X1 VSS VDD A B Z
*.PININFO VSS:B VDD:B A:I B:I Z:O
M_M5 8 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_VDD_M1_d N_B_M1_g 8 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_7_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M8 N_Z_M3_d N_A_M3_g N_7_M2_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M9 N_7_M4_d N_B_M4_g N_Z_M3_d VDD PMOS_VTL W=0.195000U L=0.050000U
M_M0 N_3_M5_d N_A_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M6_d N_B_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_Z_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M3 noxref_9 N_A_M8_g N_Z_M7_d VSS NMOS_VTL W=0.130000U L=0.050000U
M_M4 N_VSS_M9_d N_B_M9_g noxref_9 VSS NMOS_VTL W=0.130000U L=0.050000U
C_x_PM_XOR2_X1%VSS_c0 VSS x_PM_XOR2_X1%VSS_22 2.92048e-18
C_x_PM_XOR2_X1%VSS_c1 VSS N_VSS_M9_d 2.46728e-17
C_x_PM_XOR2_X1%VSS_c2 VSS x_PM_XOR2_X1%VSS_14 6.48101e-17
C_x_PM_XOR2_X1%VSS_c3 VSS N_VSS_M6_d 3.79702e-17
C_x_PM_XOR2_X1%VSS_c4 VSS x_PM_XOR2_X1%VSS_9 1.0903e-17
C_x_PM_XOR2_X1%VSS_c5 VSS x_PM_XOR2_X1%VSS_8 3.24596e-17
C_x_PM_XOR2_X1%VSS_c6 VSS N_VSS_M5_s 3.21927e-17
R_x_PM_XOR2_X1%VSS_r7 N_VSS_M9_d x_PM_XOR2_X1%VSS_18 0.637857
R_x_PM_XOR2_X1%VSS_r8 x_PM_XOR2_X1%VSS_22 x_PM_XOR2_X1%VSS_15 0.0731438
R_x_PM_XOR2_X1%VSS_r9 VSS x_PM_XOR2_X1%VSS_15 0.178824
R_x_PM_XOR2_X1%VSS_r10 x_PM_XOR2_X1%VSS_18 x_PM_XOR2_X1%VSS_14 0.264221
R_x_PM_XOR2_X1%VSS_r11 VSS x_PM_XOR2_X1%VSS_14 0.927647
R_x_PM_XOR2_X1%VSS_r12 x_PM_XOR2_X1%VSS_22 x_PM_XOR2_X1%VSS_10 0.145286
R_x_PM_XOR2_X1%VSS_r13 N_VSS_M6_d x_PM_XOR2_X1%VSS_10 0.637857
R_x_PM_XOR2_X1%VSS_r14 x_PM_XOR2_X1%VSS_22 x_PM_XOR2_X1%VSS_8 0.0731438
R_x_PM_XOR2_X1%VSS_r15 x_PM_XOR2_X1%VSS_9 x_PM_XOR2_X1%VSS_8 0.692941
R_x_PM_XOR2_X1%VSS_r16 x_PM_XOR2_X1%VSS_9 x_PM_XOR2_X1%VSS_4 0.264221
R_x_PM_XOR2_X1%VSS_r17 N_VSS_M5_s x_PM_XOR2_X1%VSS_4 0.637857
C_x_PM_XOR2_X1%VDD_c0 VSS x_PM_XOR2_X1%VDD_12 1.31852e-16
C_x_PM_XOR2_X1%VDD_c1 VSS N_VDD_M1_d 3.28773e-17
C_x_PM_XOR2_X1%VDD_c2 VSS x_PM_XOR2_X1%VDD_2 3.94218e-17
R_x_PM_XOR2_X1%VDD_r3 x_PM_XOR2_X1%VDD_12 x_PM_XOR2_X1%VDD_6 0.145286
R_x_PM_XOR2_X1%VDD_r4 N_VDD_M1_d x_PM_XOR2_X1%VDD_6 0.800714
R_x_PM_XOR2_X1%VDD_r5 x_PM_XOR2_X1%VDD_12 x_PM_XOR2_X1%VDD_2 0.0731438
R_x_PM_XOR2_X1%VDD_r6 VDD x_PM_XOR2_X1%VDD_2 0.469412
C_x_PM_XOR2_X1%3_c0 VSS x_PM_XOR2_X1%3_28 1.38559e-17
C_x_PM_XOR2_X1%3_c1 VSS x_PM_XOR2_X1%3_23 5.89304e-17
C_x_PM_XOR2_X1%3_c2 VSS N_3_M5_d 4.35696e-17
C_x_PM_XOR2_X1%3_c3 VSS x_PM_XOR2_X1%3_16 2.02495e-17
C_x_PM_XOR2_X1%3_c4 VSS x_PM_XOR2_X1%3_15 1.17927e-17
C_x_PM_XOR2_X1%3_c5 VSS N_3_M0_s 7.49304e-17
C_x_PM_XOR2_X1%3_c6 VSS N_3_M2_g 9.27637e-17
C_x_PM_XOR2_X1%3_c7 VSS N_3_M7_g 2.39257e-17
R_x_PM_XOR2_X1%3_r8 x_PM_XOR2_X1%3_28 x_PM_XOR2_X1%3_26 5.46
R_x_PM_XOR2_X1%3_r9 x_PM_XOR2_X1%3_26 x_PM_XOR2_X1%3_23 25.0012
R_x_PM_XOR2_X1%3_r10 x_PM_XOR2_X1%3_23 x_PM_XOR2_X1%3_21 1.06176
R_x_PM_XOR2_X1%3_r11 x_PM_XOR2_X1%3_21 x_PM_XOR2_X1%3_17 0.095
R_x_PM_XOR2_X1%3_r12 N_3_M5_d x_PM_XOR2_X1%3_17 0.665
R_x_PM_XOR2_X1%3_r13 x_PM_XOR2_X1%3_21 x_PM_XOR2_X1%3_15 0.156471
R_x_PM_XOR2_X1%3_r14 x_PM_XOR2_X1%3_16 x_PM_XOR2_X1%3_15 0.514118
R_x_PM_XOR2_X1%3_r15 x_PM_XOR2_X1%3_16 x_PM_XOR2_X1%3_11 0.214913
R_x_PM_XOR2_X1%3_r16 N_3_M0_s x_PM_XOR2_X1%3_11 3.37929
R_x_PM_XOR2_X1%3_r17 x_PM_XOR2_X1%3_28 x_PM_XOR2_X1%3_5 1.95
R_x_PM_XOR2_X1%3_r18 N_3_M2_g x_PM_XOR2_X1%3_5 108.81
R_x_PM_XOR2_X1%3_r19 x_PM_XOR2_X1%3_28 x_PM_XOR2_X1%3_VSS 1.95
R_x_PM_XOR2_X1%3_r20 N_3_M7_g x_PM_XOR2_X1%3_VSS 19.5
C_x_PM_XOR2_X1%A_c0 VSS x_PM_XOR2_X1%A_33 1.01432e-17
C_x_PM_XOR2_X1%A_c1 VSS x_PM_XOR2_X1%A_23 1.19244e-16
C_x_PM_XOR2_X1%A_c2 VSS x_PM_XOR2_X1%A_19 1.19296e-17
C_x_PM_XOR2_X1%A_c3 VSS N_A_M3_g 3.57304e-17
C_x_PM_XOR2_X1%A_c4 VSS N_A_M8_g 8.33679e-17
C_x_PM_XOR2_X1%A_c5 VSS N_A_M0_g 3.40987e-17
C_x_PM_XOR2_X1%A_c6 VSS N_A_M5_g 8.82421e-17
R_x_PM_XOR2_X1%A_r7 x_PM_XOR2_X1%A_33 x_PM_XOR2_X1%A_25 3.38
R_x_PM_XOR2_X1%A_r8 x_PM_XOR2_X1%A_25 x_PM_XOR2_X1%A_23 25.0012
R_x_PM_XOR2_X1%A_r9 x_PM_XOR2_X1%A_23 A 0.631071
R_x_PM_XOR2_X1%A_r10 x_PM_XOR2_X1%A_19 x_PM_XOR2_X1%A_27 3.9
R_x_PM_XOR2_X1%A_r11 x_PM_XOR2_X1%A_19 x_PM_XOR2_X1%A_17 25.0012
R_x_PM_XOR2_X1%A_r12 A x_PM_XOR2_X1%A_17 0.726071
R_x_PM_XOR2_X1%A_r13 x_PM_XOR2_X1%A_33 x_PM_XOR2_X1%A_13 1.95
R_x_PM_XOR2_X1%A_r14 N_A_M3_g x_PM_XOR2_X1%A_13 25.35
R_x_PM_XOR2_X1%A_r15 x_PM_XOR2_X1%A_33 x_PM_XOR2_X1%A_9 1.95
R_x_PM_XOR2_X1%A_r16 N_A_M8_g x_PM_XOR2_X1%A_9 99.84
R_x_PM_XOR2_X1%A_r17 x_PM_XOR2_X1%A_27 x_PM_XOR2_X1%A_5 1.95
R_x_PM_XOR2_X1%A_r18 N_A_M0_g x_PM_XOR2_X1%A_5 25.35
R_x_PM_XOR2_X1%A_r19 x_PM_XOR2_X1%A_27 x_PM_XOR2_X1%A_VSS 1.95
R_x_PM_XOR2_X1%A_r20 N_A_M5_g x_PM_XOR2_X1%A_VSS 102.96
C_x_PM_XOR2_X1%B_c0 VSS x_PM_XOR2_X1%B_32 8.89458e-18
C_x_PM_XOR2_X1%B_c1 VSS x_PM_XOR2_X1%B_23 1.35531e-16
C_x_PM_XOR2_X1%B_c2 VSS x_PM_XOR2_X1%B_19 8.39309e-18
C_x_PM_XOR2_X1%B_c3 VSS N_B_M4_g 6.49199e-17
C_x_PM_XOR2_X1%B_c4 VSS N_B_M9_g 5.49098e-17
C_x_PM_XOR2_X1%B_c5 VSS N_B_M1_g 6.35342e-17
C_x_PM_XOR2_X1%B_c6 VSS N_B_M6_g 5.28658e-17
R_x_PM_XOR2_X1%B_r7 x_PM_XOR2_X1%B_32 x_PM_XOR2_X1%B_25 2.86
R_x_PM_XOR2_X1%B_r8 x_PM_XOR2_X1%B_25 x_PM_XOR2_X1%B_23 25.0012
R_x_PM_XOR2_X1%B_r9 x_PM_XOR2_X1%B_23 B 0.644643
R_x_PM_XOR2_X1%B_r10 x_PM_XOR2_X1%B_29 x_PM_XOR2_X1%B_19 4.7687
R_x_PM_XOR2_X1%B_r11 x_PM_XOR2_X1%B_28 x_PM_XOR2_X1%B_19 4.7687
R_x_PM_XOR2_X1%B_r12 x_PM_XOR2_X1%B_19 x_PM_XOR2_X1%B_17 25.0012
R_x_PM_XOR2_X1%B_r13 B x_PM_XOR2_X1%B_17 0.793929
R_x_PM_XOR2_X1%B_r14 x_PM_XOR2_X1%B_32 x_PM_XOR2_X1%B_13 1.95
R_x_PM_XOR2_X1%B_r15 N_B_M4_g x_PM_XOR2_X1%B_13 63.57
R_x_PM_XOR2_X1%B_r16 x_PM_XOR2_X1%B_32 x_PM_XOR2_X1%B_9 1.95
R_x_PM_XOR2_X1%B_r17 N_B_M9_g x_PM_XOR2_X1%B_9 61.62
R_x_PM_XOR2_X1%B_r18 N_B_M1_g x_PM_XOR2_X1%B_29 68.25
R_x_PM_XOR2_X1%B_r19 N_B_M6_g x_PM_XOR2_X1%B_28 60.06
C_x_PM_XOR2_X1%Z_c0 VSS x_PM_XOR2_X1%Z_18 3.30422e-17
C_x_PM_XOR2_X1%Z_c1 VSS x_PM_XOR2_X1%Z_16 5.28052e-17
C_x_PM_XOR2_X1%Z_c2 VSS x_PM_XOR2_X1%Z_13 3.38915e-17
C_x_PM_XOR2_X1%Z_c3 VSS x_PM_XOR2_X1%Z_11 5.14588e-17
C_x_PM_XOR2_X1%Z_c4 VSS Z 2.50125e-17
C_x_PM_XOR2_X1%Z_c5 VSS x_PM_XOR2_X1%Z_9 8.21972e-18
C_x_PM_XOR2_X1%Z_c6 VSS x_PM_XOR2_X1%Z_7 6.02654e-18
C_x_PM_XOR2_X1%Z_c7 VSS N_Z_M7_d 3.09621e-17
R_x_PM_XOR2_X1%Z_r8 N_Z_M3_d x_PM_XOR2_X1%Z_18 0.257857
R_x_PM_XOR2_X1%Z_r9 x_PM_XOR2_X1%Z_16 x_PM_XOR2_X1%Z_15 2.95857
R_x_PM_XOR2_X1%Z_r10 x_PM_XOR2_X1%Z_18 x_PM_XOR2_X1%Z_14 0.095
R_x_PM_XOR2_X1%Z_r11 x_PM_XOR2_X1%Z_16 x_PM_XOR2_X1%Z_13 0.212317
R_x_PM_XOR2_X1%Z_r12 x_PM_XOR2_X1%Z_14 x_PM_XOR2_X1%Z_13 0.868571
R_x_PM_XOR2_X1%Z_r13 x_PM_XOR2_X1%Z_15 x_PM_XOR2_X1%Z_11 0.212317
R_x_PM_XOR2_X1%Z_r14 x_PM_XOR2_X1%Z_12 x_PM_XOR2_X1%Z_11 1.81857
R_x_PM_XOR2_X1%Z_r15 x_PM_XOR2_X1%Z_12 Z 0.212317
R_x_PM_XOR2_X1%Z_r16 Z x_PM_XOR2_X1%Z_9 0.000542857
R_x_PM_XOR2_X1%Z_r17 x_PM_XOR2_X1%Z_9 x_PM_XOR2_X1%Z_7 0.352314
R_x_PM_XOR2_X1%Z_r18 x_PM_XOR2_X1%Z_7 x_PM_XOR2_X1%Z_3 0.202958
R_x_PM_XOR2_X1%Z_r19 N_Z_M7_d x_PM_XOR2_X1%Z_3 0.111765
C_x_PM_XOR2_X1%7_c0 VSS N_7_M2_d 3.76115e-17
C_x_PM_XOR2_X1%7_c1 VSS x_PM_XOR2_X1%7_3 7.9158e-17
C_x_PM_XOR2_X1%7_c2 VSS N_7_M4_d 3.49643e-17
R_x_PM_XOR2_X1%7_r3 x_PM_XOR2_X1%7_8 N_7_M2_d 0.257857
R_x_PM_XOR2_X1%7_r4 x_PM_XOR2_X1%7_8 x_PM_XOR2_X1%7_4 0.095
R_x_PM_XOR2_X1%7_r5 x_PM_XOR2_X1%7_13 x_PM_XOR2_X1%7_3 0.095
R_x_PM_XOR2_X1%7_r6 x_PM_XOR2_X1%7_4 x_PM_XOR2_X1%7_3 1.62857
R_x_PM_XOR2_X1%7_r7 x_PM_XOR2_X1%7_13 N_7_M4_d 0.257857
.ENDS

********************************************************************************
*                                                                              *
* Cellname:   XOR2_X2.                                                         *
*                                                                              *
* Technology: NCSU FreePDK 45nm.                                               *
* Format:     Cdl.                                                             *
*                                                                              *
*                                                                              *
********************************************************************************
.SUBCKT XOR2_X2 VSS VDD A B Z
*.PININFO VSS:B VDD:B A:I B:I Z:O
M_M5 8 N_A_M0_g N_3_M0_s VDD PMOS_VTL W=0.195000U L=0.050000U
M_M6 N_VDD_M1_d N_B_M1_g 8 VDD PMOS_VTL W=0.195000U L=0.050000U
M_M7 N_7_M2_d N_3_M2_g N_VDD_M1_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M8 N_Z_M3_d N_A_M3_g N_7_M2_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M9 N_7_M4_d N_B_M4_g N_Z_M3_d VDD PMOS_VTL W=0.390000U L=0.050000U
M_M0 N_3_M5_d N_A_M5_g N_VSS_M5_s VSS NMOS_VTL W=0.090000U L=0.050000U
M_M1 N_VSS_M6_d N_B_M6_g N_3_M5_d VSS NMOS_VTL W=0.090000U L=0.050000U
M_M2 N_Z_M7_d N_3_M7_g N_VSS_M6_d VSS NMOS_VTL W=0.180000U L=0.050000U
M_M3 noxref_9 N_A_M8_g N_Z_M7_d VSS NMOS_VTL W=0.260000U L=0.050000U
M_M4 N_VSS_M9_d N_B_M9_g noxref_9 VSS NMOS_VTL W=0.260000U L=0.050000U
C_x_PM_XOR2_X2%VSS_c0 VSS x_PM_XOR2_X2%VSS_22 2.92244e-18
C_x_PM_XOR2_X2%VSS_c1 VSS N_VSS_M9_d 1.78745e-17
C_x_PM_XOR2_X2%VSS_c2 VSS x_PM_XOR2_X2%VSS_14 6.68756e-17
C_x_PM_XOR2_X2%VSS_c3 VSS N_VSS_M6_d 3.00222e-17
C_x_PM_XOR2_X2%VSS_c4 VSS x_PM_XOR2_X2%VSS_9 1.09715e-17
C_x_PM_XOR2_X2%VSS_c5 VSS x_PM_XOR2_X2%VSS_8 3.03506e-17
C_x_PM_XOR2_X2%VSS_c6 VSS N_VSS_M5_s 2.75676e-17
R_x_PM_XOR2_X2%VSS_r7 N_VSS_M9_d x_PM_XOR2_X2%VSS_18 0.230714
R_x_PM_XOR2_X2%VSS_r8 x_PM_XOR2_X2%VSS_22 x_PM_XOR2_X2%VSS_15 0.0731438
R_x_PM_XOR2_X2%VSS_r9 VSS x_PM_XOR2_X2%VSS_15 0.19
R_x_PM_XOR2_X2%VSS_r10 x_PM_XOR2_X2%VSS_18 x_PM_XOR2_X2%VSS_14 0.264221
R_x_PM_XOR2_X2%VSS_r11 VSS x_PM_XOR2_X2%VSS_14 0.961176
R_x_PM_XOR2_X2%VSS_r12 x_PM_XOR2_X2%VSS_22 x_PM_XOR2_X2%VSS_10 0.145286
R_x_PM_XOR2_X2%VSS_r13 N_VSS_M6_d x_PM_XOR2_X2%VSS_10 0.665
R_x_PM_XOR2_X2%VSS_r14 x_PM_XOR2_X2%VSS_22 x_PM_XOR2_X2%VSS_8 0.0731438
R_x_PM_XOR2_X2%VSS_r15 x_PM_XOR2_X2%VSS_9 x_PM_XOR2_X2%VSS_8 0.681765
R_x_PM_XOR2_X2%VSS_r16 x_PM_XOR2_X2%VSS_9 x_PM_XOR2_X2%VSS_4 0.264221
R_x_PM_XOR2_X2%VSS_r17 N_VSS_M5_s x_PM_XOR2_X2%VSS_4 0.665
C_x_PM_XOR2_X2%VDD_c0 VSS x_PM_XOR2_X2%VDD_11 5.06462e-17
C_x_PM_XOR2_X2%VDD_c1 VSS x_PM_XOR2_X2%VDD_8 9.04239e-17
C_x_PM_XOR2_X2%VDD_c2 VSS N_VDD_M1_d 1.60113e-17
R_x_PM_XOR2_X2%VDD_r3 x_PM_XOR2_X2%VDD_11 x_PM_XOR2_X2%VDD_8 0.0731438
R_x_PM_XOR2_X2%VDD_r4 VDD x_PM_XOR2_X2%VDD_8 0.178824
R_x_PM_XOR2_X2%VDD_r5 x_PM_XOR2_X2%VDD_11 x_PM_XOR2_X2%VDD_4 0.145286
R_x_PM_XOR2_X2%VDD_r6 N_VDD_M1_d x_PM_XOR2_X2%VDD_4 0.230714
C_x_PM_XOR2_X2%3_c0 VSS x_PM_XOR2_X2%3_32 1.23496e-17
C_x_PM_XOR2_X2%3_c1 VSS x_PM_XOR2_X2%3_24 2.62007e-17
C_x_PM_XOR2_X2%3_c2 VSS x_PM_XOR2_X2%3_23 5.632e-18
C_x_PM_XOR2_X2%3_c3 VSS x_PM_XOR2_X2%3_21 2.20346e-17
C_x_PM_XOR2_X2%3_c4 VSS N_3_M5_d 4.51028e-17
C_x_PM_XOR2_X2%3_c5 VSS x_PM_XOR2_X2%3_16 1.44792e-17
C_x_PM_XOR2_X2%3_c6 VSS x_PM_XOR2_X2%3_15 1.10108e-17
C_x_PM_XOR2_X2%3_c7 VSS N_3_M0_s 9.96232e-17
C_x_PM_XOR2_X2%3_c8 VSS N_3_M2_g 9.32321e-17
C_x_PM_XOR2_X2%3_c9 VSS N_3_M7_g 2.97214e-17
R_x_PM_XOR2_X2%3_r10 x_PM_XOR2_X2%3_32 x_PM_XOR2_X2%3_30 5.46
R_x_PM_XOR2_X2%3_r11 x_PM_XOR2_X2%3_30 x_PM_XOR2_X2%3_27 25.0012
R_x_PM_XOR2_X2%3_r12 x_PM_XOR2_X2%3_27 x_PM_XOR2_X2%3_24 0.176429
R_x_PM_XOR2_X2%3_r13 x_PM_XOR2_X2%3_23 x_PM_XOR2_X2%3_22 0.160909
R_x_PM_XOR2_X2%3_r14 x_PM_XOR2_X2%3_24 x_PM_XOR2_X2%3_21 0.095
R_x_PM_XOR2_X2%3_r15 x_PM_XOR2_X2%3_22 x_PM_XOR2_X2%3_21 0.895714
R_x_PM_XOR2_X2%3_r16 x_PM_XOR2_X2%3_23 x_PM_XOR2_X2%3_17 0.0418175
R_x_PM_XOR2_X2%3_r17 N_3_M5_d x_PM_XOR2_X2%3_17 0.800714
R_x_PM_XOR2_X2%3_r18 x_PM_XOR2_X2%3_23 x_PM_XOR2_X2%3_15 0.160909
R_x_PM_XOR2_X2%3_r19 x_PM_XOR2_X2%3_16 x_PM_XOR2_X2%3_15 0.624286
R_x_PM_XOR2_X2%3_r20 x_PM_XOR2_X2%3_16 x_PM_XOR2_X2%3_11 0.212645
R_x_PM_XOR2_X2%3_r21 N_3_M0_s x_PM_XOR2_X2%3_11 3.61
R_x_PM_XOR2_X2%3_r22 x_PM_XOR2_X2%3_32 x_PM_XOR2_X2%3_5 1.95
R_x_PM_XOR2_X2%3_r23 N_3_M2_g x_PM_XOR2_X2%3_5 99.84
R_x_PM_XOR2_X2%3_r24 x_PM_XOR2_X2%3_32 x_PM_XOR2_X2%3_VSS 1.95
R_x_PM_XOR2_X2%3_r25 N_3_M7_g x_PM_XOR2_X2%3_VSS 21.84
C_x_PM_XOR2_X2%A_c0 VSS x_PM_XOR2_X2%A_36 1.60834e-17
C_x_PM_XOR2_X2%A_c1 VSS x_PM_XOR2_X2%A_26 1.21081e-17
C_x_PM_XOR2_X2%A_c2 VSS x_PM_XOR2_X2%A_22 6.23618e-17
C_x_PM_XOR2_X2%A_c3 VSS x_PM_XOR2_X2%A_18 8.15108e-17
C_x_PM_XOR2_X2%A_c4 VSS N_A_M3_g 5.31977e-17
C_x_PM_XOR2_X2%A_c5 VSS N_A_M8_g 8.25873e-17
C_x_PM_XOR2_X2%A_c6 VSS N_A_M0_g 5.15027e-17
C_x_PM_XOR2_X2%A_c7 VSS N_A_M5_g 8.25861e-17
R_x_PM_XOR2_X2%A_r8 x_PM_XOR2_X2%A_26 x_PM_XOR2_X2%A_30 3.9
R_x_PM_XOR2_X2%A_r9 x_PM_XOR2_X2%A_26 x_PM_XOR2_X2%A_24 25.0012
R_x_PM_XOR2_X2%A_r10 A x_PM_XOR2_X2%A_24 0.124483
R_x_PM_XOR2_X2%A_r11 x_PM_XOR2_X2%A_24 x_PM_XOR2_X2%A_22 0.0851724
R_x_PM_XOR2_X2%A_r12 x_PM_XOR2_X2%A_36 x_PM_XOR2_X2%A_20 7.02
R_x_PM_XOR2_X2%A_r13 x_PM_XOR2_X2%A_20 x_PM_XOR2_X2%A_18 25.0012
R_x_PM_XOR2_X2%A_r14 x_PM_XOR2_X2%A_22 x_PM_XOR2_X2%A_17 0.095
R_x_PM_XOR2_X2%A_r15 x_PM_XOR2_X2%A_18 x_PM_XOR2_X2%A_17 1.995
R_x_PM_XOR2_X2%A_r16 x_PM_XOR2_X2%A_36 x_PM_XOR2_X2%A_13 1.95
R_x_PM_XOR2_X2%A_r17 N_A_M3_g x_PM_XOR2_X2%A_13 39
R_x_PM_XOR2_X2%A_r18 x_PM_XOR2_X2%A_36 x_PM_XOR2_X2%A_9 1.95
R_x_PM_XOR2_X2%A_r19 N_A_M8_g x_PM_XOR2_X2%A_9 88.92
R_x_PM_XOR2_X2%A_r20 x_PM_XOR2_X2%A_30 x_PM_XOR2_X2%A_5 1.95
R_x_PM_XOR2_X2%A_r21 N_A_M0_g x_PM_XOR2_X2%A_5 48.75
R_x_PM_XOR2_X2%A_r22 x_PM_XOR2_X2%A_30 x_PM_XOR2_X2%A_VSS 1.95
R_x_PM_XOR2_X2%A_r23 N_A_M5_g x_PM_XOR2_X2%A_VSS 95.16
C_x_PM_XOR2_X2%B_c0 VSS x_PM_XOR2_X2%B_35 1.25048e-17
C_x_PM_XOR2_X2%B_c1 VSS x_PM_XOR2_X2%B_24 8.22451e-18
C_x_PM_XOR2_X2%B_c2 VSS x_PM_XOR2_X2%B_22 3.95314e-17
C_x_PM_XOR2_X2%B_c3 VSS x_PM_XOR2_X2%B_18 1.2109e-16
C_x_PM_XOR2_X2%B_c4 VSS N_B_M4_g 6.79516e-17
C_x_PM_XOR2_X2%B_c5 VSS N_B_M9_g 6.48967e-17
C_x_PM_XOR2_X2%B_c6 VSS N_B_M1_g 7.2975e-17
C_x_PM_XOR2_X2%B_c7 VSS N_B_M6_g 5.17135e-17
R_x_PM_XOR2_X2%B_r8 x_PM_XOR2_X2%B_28 B 0.095
R_x_PM_XOR2_X2%B_r9 x_PM_XOR2_X2%B_32 x_PM_XOR2_X2%B_24 4.7687
R_x_PM_XOR2_X2%B_r10 x_PM_XOR2_X2%B_31 x_PM_XOR2_X2%B_24 4.7687
R_x_PM_XOR2_X2%B_r11 x_PM_XOR2_X2%B_24 x_PM_XOR2_X2%B_22 25.0012
R_x_PM_XOR2_X2%B_r12 B x_PM_XOR2_X2%B_22 0.00730769
R_x_PM_XOR2_X2%B_r13 x_PM_XOR2_X2%B_35 x_PM_XOR2_X2%B_20 4.42
R_x_PM_XOR2_X2%B_r14 x_PM_XOR2_X2%B_20 x_PM_XOR2_X2%B_18 25.0012
R_x_PM_XOR2_X2%B_r15 x_PM_XOR2_X2%B_28 x_PM_XOR2_X2%B_17 0.095
R_x_PM_XOR2_X2%B_r16 x_PM_XOR2_X2%B_18 x_PM_XOR2_X2%B_17 2.64733
R_x_PM_XOR2_X2%B_r17 x_PM_XOR2_X2%B_35 x_PM_XOR2_X2%B_13 1.95
R_x_PM_XOR2_X2%B_r18 N_B_M4_g x_PM_XOR2_X2%B_13 65.52
R_x_PM_XOR2_X2%B_r19 x_PM_XOR2_X2%B_35 x_PM_XOR2_X2%B_9 1.95
R_x_PM_XOR2_X2%B_r20 N_B_M9_g x_PM_XOR2_X2%B_9 62.4
R_x_PM_XOR2_X2%B_r21 N_B_M1_g x_PM_XOR2_X2%B_32 85.41
R_x_PM_XOR2_X2%B_r22 N_B_M6_g x_PM_XOR2_X2%B_31 58.5
C_x_PM_XOR2_X2%Z_c0 VSS x_PM_XOR2_X2%Z_16 2.93962e-17
C_x_PM_XOR2_X2%Z_c1 VSS x_PM_XOR2_X2%Z_14 2.66606e-17
C_x_PM_XOR2_X2%Z_c2 VSS x_PM_XOR2_X2%Z_13 2.89113e-17
C_x_PM_XOR2_X2%Z_c3 VSS Z 3.24504e-17
C_x_PM_XOR2_X2%Z_c4 VSS x_PM_XOR2_X2%Z_3 9.34374e-17
R_x_PM_XOR2_X2%Z_r5 x_PM_XOR2_X2%Z_16 x_PM_XOR2_X2%Z_15 1.87286
R_x_PM_XOR2_X2%Z_r6 x_PM_XOR2_X2%Z_16 x_PM_XOR2_X2%Z_13 0.212317
R_x_PM_XOR2_X2%Z_r7 x_PM_XOR2_X2%Z_14 x_PM_XOR2_X2%Z_13 0.787143
R_x_PM_XOR2_X2%Z_r8 N_Z_M3_d Z 0.257857
R_x_PM_XOR2_X2%Z_r9 x_PM_XOR2_X2%Z_14 x_PM_XOR2_X2%Z_7 0.212317
R_x_PM_XOR2_X2%Z_r10 Z x_PM_XOR2_X2%Z_7 0.407143
R_x_PM_XOR2_X2%Z_r11 x_PM_XOR2_X2%Z_15 x_PM_XOR2_X2%Z_3 0.244544
R_x_PM_XOR2_X2%Z_r12 N_Z_M7_d x_PM_XOR2_X2%Z_3 1.01107
C_x_PM_XOR2_X2%7_c0 VSS N_7_M4_d 7.56582e-17
R_x_PM_XOR2_X2%7_r1 N_7_M4_d N_7_M2_d 2.03571
.ENDS

********************************************************************************
*
* END
*
********************************************************************************

* Customized PTM 45 PMOS

.model  PMOS_VTL  pmos  level = 54

+version = 4.0    binunit = 1    paramchk= 1    mobmod  = 0
+capmod  = 2      igcmod  = 1    igbmod  = 1    geomod  = 1
+diomod  = 1      rdsmod  = 0    rbodymod= 1    rgatemod= 1
+permod  = 1      acnqsmod= 0    trnqsmod= 0

* parameters related to the technology node
+tnom = 27    epsrox = 3.9
+eta0 = 0.0049    nfactor = 2.1    wint = 5e-09
+cgso = 1.1e-10    cgdo = 1.1e-10    xl = -2e-08

* parameters customized by the user
+toxe = 1.85e-09    toxp = 1.1e-09    toxm = 1.85e-09    toxref = 1.85e-09
+dtox = 7.5e-10    lint = 3.75e-09
+vth0 = -0.423    k1 = 0.491    u0 = 0.00432    vsat = 70000
+rdsw = 155    ndep = 2.54e+18    xj = 1.4e-08

*secondary parameters
+ll      = 0            wl      = 0            lln     = 1            wln     = 1
+lw      = 0            ww      = 0            lwn     = 1            wwn     = 1
+lwl     = 0            wwl     = 0            xpart   = 0
+k2      = -0.01        k3      = 0
+k3b     = 0            w0      = 2.5e-006     dvt0    = 1            dvt1    = 2
+dvt2    = -0.032       dvt0w   = 0            dvt1w   = 0            dvt2w   = 0
+dsub    = 0.1          minv    = 0.05         voffl   = 0            dvtp0   = 1e-009
+dvtp1   = 0.05         lpe0    = 0            lpeb    = 0
+ngate   = 2e+020       nsd     = 2e+020       phin    = 0
+cdsc    = 0.000        cdscb   = 0            cdscd   = 0            cit     = 0
+voff    = -0.126       etab    = 0
+vfb     = 0.55         ua      = 2.0e-009     ub      = 0.5e-018
+uc      = 0            a0      = 1.0          ags     = 1e-020
+a1      = 0            a2      = 1            b0      = -1e-020      b1      = 0
+keta    = -0.047       dwg     = 0            dwb     = 0            pclm    = 0.12
+pdiblc1 = 0.001        pdiblc2 = 0.001        pdiblcb = 3.4e-008     drout   = 0.56
+pvag    = 1e-020       delta   = 0.01         pscbe1  = 8.14e+008    pscbe2  = 9.58e-007
+fprout  = 0.2          pdits   = 0.08         pditsd  = 0.23         pditsl  = 2.3e+006
+rsh     = 5            rsw     = 85           rdw     = 85
+rdswmin = 0            rdwmin  = 0            rswmin  = 0            prwg    = 3.22e-008
+prwb    = 6.8e-011     wr      = 1            alpha0  = 0.074        alpha1  = 0.005
+beta0   = 30           agidl   = 0.0002       bgidl   = 2.1e+009     cgidl   = 0.0002
+egidl   = 0.8

+aigbacc = 0.012        bigbacc = 0.0028       cigbacc = 0.002
+nigbacc = 1            aigbinv = 0.014        bigbinv = 0.004        cigbinv = 0.004
+eigbinv = 1.1          nigbinv = 3            aigc    = 0.69         bigc    = 0.0012
+cigc    = 0.0008       aigsd   = 0.0087       bigsd   = 0.0012       cigsd   = 0.0008
+nigc    = 1            poxedge = 1            pigcd   = 1            ntox    = 1

+xrcrg1  = 12           xrcrg2  = 5
+cgbo    = 2.56e-011    cgdl    = 2.653e-10
+cgsl    = 2.653e-10    ckappas = 0.03         ckappad = 0.03         acde    = 1
+moin    = 15           noff    = 0.9          voffcv  = 0.02

+kt1     = -0.11        kt1l    = 0            kt2     = 0.022        ute     = -1.5
+ua1     = 4.31e-009    ub1     = 7.61e-018    uc1     = -5.6e-011    prt     = 0
+at      = 33000

+fnoimod = 1            tnoimod = 0

+jss     = 0.0001       jsws    = 1e-011       jswgs   = 1e-010       njs     = 1
+ijthsfwd= 0.01         ijthsrev= 0.001        bvs     = 10           xjbvs   = 1
+jsd     = 0.0001       jswd    = 1e-011       jswgd   = 1e-010       njd     = 1
+ijthdfwd= 0.01         ijthdrev= 0.001        bvd     = 10           xjbvd   = 1
+pbs     = 1            cjs     = 0.0005       mjs     = 0.5          pbsws   = 1
+cjsws   = 5e-010       mjsws   = 0.33         pbswgs  = 1            cjswgs  = 3e-010
+mjswgs  = 0.33         pbd     = 1            cjd     = 0.0005       mjd     = 0.5
+pbswd   = 1            cjswd   = 5e-010       mjswd   = 0.33         pbswgd  = 1
+cjswgd  = 5e-010       mjswgd  = 0.33         tpb     = 0.005        tcj     = 0.001
+tpbsw   = 0.005        tcjsw   = 0.001        tpbswg  = 0.005        tcjswg  = 0.001
+xtis    = 3            xtid    = 3

+dmcg    = 0e-006       dmci    = 0e-006       dmdg    = 0e-006       dmcgt   = 0e-007
+dwj     = 0.0e-008     xgw     = 0e-007       xgl     = 0e-008

+rshg    = 0.4          gbmin   = 1e-010       rbpb    = 5            rbpd    = 15
+rbps    = 15           rbdb    = 15           rbsb    = 15           ngcon   = 1

* Customized PTM 45 NMOS

.model  NMOS_VTL  nmos  level = 54

+version = 4.0    binunit = 1    paramchk= 1    mobmod  = 0
+capmod  = 2      igcmod  = 1    igbmod  = 1    geomod  = 1
+diomod  = 1      rdsmod  = 0    rbodymod= 1    rgatemod= 1
+permod  = 1      acnqsmod= 0    trnqsmod= 0

* parameters related to the technology node
+tnom = 27    epsrox = 3.9
+eta0 = 0.0049    nfactor = 2.1    wint = 5e-09
+cgso = 1.1e-10    cgdo = 1.1e-10    xl = -2e-08

* parameters customized by the user
+toxe = 1.75e-09    toxp = 1.1e-09    toxm = 1.75e-09    toxref = 1.75e-09
+dtox = 6.5e-10    lint = 3.75e-09
+vth0 = 0.471    k1 = 0.53    u0 = 0.04359    vsat = 147390
+rdsw = 155    ndep = 3.3e+18    xj = 1.4e-08

* secondary parameters
+ll      = 0            wl      = 0            lln     = 1            wln     = 1
+lw      = 0            ww      = 0            lwn     = 1            wwn     = 1
+lwl     = 0            wwl     = 0            xpart   = 0
+k2      = 0.01         k3      = 0
+k3b     = 0            w0      = 2.5e-006     dvt0    = 1            dvt1    = 2
+dvt2    = -0.032       dvt0w   = 0            dvt1w   = 0            dvt2w   = 0
+dsub    = 0.1          minv    = 0.05         voffl   = 0            dvtp0   = 1.0e-009
+dvtp1   = 0.1          lpe0    = 0            lpeb    = 0
+ngate   = 2e+020       nsd     = 2e+020       phin    = 0
+cdsc    = 0.000        cdscb   = 0            cdscd   = 0            cit     = 0
+voff    = -0.13        etab    = 0
+vfb     = -0.55        ua      = 6e-010       ub      = 1.2e-018
+uc      = 0            a0      = 1.0          ags     = 1e-020
+a1      = 0            a2      = 1.0          b0      = 0            b1      = 0
+keta    = 0.04         dwg     = 0            dwb     = 0            pclm    = 0.04
+pdiblc1 = 0.001        pdiblc2 = 0.001        pdiblcb = -0.005       drout   = 0.5
+pvag    = 1e-020       delta   = 0.01         pscbe1  = 8.14e+008    pscbe2  = 1e-007
+fprout  = 0.2          pdits   = 0.08         pditsd  = 0.23         pditsl  = 2.3e+006
+rsh     = 5            rsw     = 85           rdw     = 85
+rdswmin = 0            rdwmin  = 0            rswmin  = 0            prwg    = 0
+prwb    = 6.8e-011     wr      = 1            alpha0  = 0.074        alpha1  = 0.005
+beta0   = 30           agidl   = 0.0002       bgidl   = 2.1e+009     cgidl   = 0.0002
+egidl   = 0.8

+aigbacc = 0.012        bigbacc = 0.0028       cigbacc = 0.002
+nigbacc = 1            aigbinv = 0.014        bigbinv = 0.004        cigbinv = 0.004
+eigbinv = 1.1          nigbinv = 3            aigc    = 0.012        bigc    = 0.0028
+cigc    = 0.002        aigsd   = 0.012        bigsd   = 0.0028       cigsd   = 0.002
+nigc    = 1            poxedge = 1            pigcd   = 1            ntox    = 1

+xrcrg1  = 12           xrcrg2  = 5
+cgbo    = 2.56e-011    cgdl    = 2.653e-10
+cgsl    = 2.653e-10    ckappas = 0.03         ckappad = 0.03         acde    = 1
+moin    = 15           noff    = 0.9          voffcv  = 0.02

+kt1     = -0.11        kt1l    = 0            kt2     = 0.022        ute     = -1.5
+ua1     = 4.31e-009    ub1     = 7.61e-018    uc1     = -5.6e-011    prt     = 0
+at      = 33000

+fnoimod = 1            tnoimod = 0

+jss     = 0.0001       jsws    = 1e-011       jswgs   = 1e-010       njs     = 1
+ijthsfwd= 0.01         ijthsrev= 0.001        bvs     = 10           xjbvs   = 1
+jsd     = 0.0001       jswd    = 1e-011       jswgd   = 1e-010       njd     = 1
+ijthdfwd= 0.01         ijthdrev= 0.001        bvd     = 10           xjbvd   = 1
+pbs     = 1            cjs     = 0.0005       mjs     = 0.5          pbsws   = 1
+cjsws   = 5e-010       mjsws   = 0.33         pbswgs  = 1            cjswgs  = 3e-010
+mjswgs  = 0.33         pbd     = 1            cjd     = 0.0005       mjd     = 0.5
+pbswd   = 1            cjswd   = 5e-010       mjswd   = 0.33         pbswgd  = 1
+cjswgd  = 5e-010       mjswgd  = 0.33         tpb     = 0.005        tcj     = 0.001
+tpbsw   = 0.005        tcjsw   = 0.001        tpbswg  = 0.005        tcjswg  = 0.001
+xtis    = 3            xtid    = 3

+dmcg    = 0e-006       dmci    = 0e-006       dmdg    = 0e-006       dmcgt   = 0e-007
+dwj     = 0.0e-008     xgw     = 0e-007       xgl     = 0e-008

+rshg    = 0.4          gbmin   = 1e-010       rbpb    = 5            rbpd    = 15
+rbps    = 15           rbdb    = 15           rbsb    = 15           ngcon   = 1
